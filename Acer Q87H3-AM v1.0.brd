# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC3_CSN1: length 23.2
  TOP w0.127: v2(55.91,41.87) 56.23,41.55 56.23,41.39 R930.2 v2(55.1,40.95) ; v2(59.01,48.89) 59.6,48.89 59.98,49.26 59.98,49.82 P12.2 ; U41.15 54.32,35.95 54.52,36.15 54.7,36.15 54.93,36.38 55.74,36.38 56.65,37.29 56.65,38.01 56.72,38.08 ; 56.72,38.08 56.72,38.69 57.82,39.78 v2(57.82,40.16) ; 56.72,38.08 C803.1
  BOTTOM w0.127: v2(55.1,40.95) 55.05,40.89 55.05,40.39 55.28,40.16 v2(57.82,40.16) ; v2(55.91,41.87) 56.24,42.2 56.24,45.73 56.62,46.11 v1(56.62,46.59) 57.11,46.59 59.01,48.49 v2(59.01,48.89)
+VCC3_CSP1: length 11.7
  TOP w0.127: v2(56.83,41.87) 56.48,41.52 56.48,41.39 R931.1 ; v2(59.66,48.24) 59.66,48.58 60.26,49.18 60.74,49.18 P11.2
  BOTTOM w0.127: v2(56.83,41.87) 56.5,42.2 56.5,45.62 57.92,47.05 v1(58.4,47.05) 58.4,47.53 59.12,48.24 v2(59.66,48.24)
+VCC3_FB1: length 2.9
  TOP w0.508: R928.2 61.34,38.61 60.39,37.66 R927.1 60.26,37.62 R932.2
+VCC3_HG1: length 5
  TOP w0.635: QD3H1.G 64.05,40.62 63.35,40.62 63.3,40.57 62.75,40.57 R923.1 62.23,40.37 R922.1 61.2,41.13 v2(60.74,41.59)
+VCC_CSN2: length 57.2
  TOP w0.127: U41.7 54.32,31.15 54.21,31.04 54.21,30.51 54.31,30.4 54.31,30.3 C790.1 54.52,29.94 54.95,29.51 54.95,28.4 R914.2 55.72,27.63 56.33,27.63 v2(56.55,27.85) ; P9.2 61.37,9.94 61.37,10.32 62.08,11.03 v2(62.55,11.03)
  BOTTOM w0.127: v2(62.55,11.03) 62.55,11.39 62.88,11.72 68.33,11.72 v1(68.66,11.39) 68.99,11.72 72.01,11.72 79.03,18.73 79.03,23.51 75.39,27.15 63.34,27.15 62.9,27.59 56.8,27.59 v2(56.55,27.85)
+VCC_CSP2: length 52.4
  TOP w0.127: v2(56.55,27.08) 56.23,27.4 55.94,27.4 R915.1 ; v2(61.9,11.67) 61.9,11.21 61.27,10.57 60.61,10.57 P10.2
  BOTTOM w0.127: v2(56.55,27.08) 56.8,27.34 62.79,27.34 63.24,26.89 75.28,26.89 78.77,23.4 78.77,18.84 71.91,11.97 67.47,11.97 v1(67.11,12.33) 66.76,11.97 62.77,11.97 62.47,11.67 v2(61.9,11.67)
+VCC_FB2: length 18.5
  TOP w0.508: v2(59.47,30.39) 59.6,30.39 59.98,30 R917.2 58.83,29.59 R919.2 ; v2(45.63,27.21) 45.63,26.35 R916.1
  BOTTOM w0.508: v2(59.47,30.39) 59.34,30.51 50.9,30.51 50.13,29.75 48.17,29.75 47.05,28.63 v1(46.87,28.63) 46.87,28.46 v2(45.63,27.21)
+VCC_GH2: length 24.1
  TOP w0.635: QD5H1.G 66.16,18.38 v2(66.2,18.35) ; QD5H2.G 59.2,18.38 v2(60.03,19.21)
  BOTTOM w0.635: v2(66.2,18.35) v1(62.67,18.35) 60.89,18.35 v2(60.03,19.21) 58.88,20.35 49.31,20.35 48.71,20.96 SR54.1 48.71,22.42 SR53.1
+VCC_LG2: length 19.3
  TOP w0.635: v2(44.69,8.72) 44.69,8.24 45.65,7.27 QD5L1.G ; QD5L2.G 46.32,15.15 v2(44.61,15.15) 43.47,16.29 43.47,20.99 R910.1
  BOTTOM w0.635: v2(44.61,15.15) 43.85,14.38 v1(43.85,12.66) 43.85,9.94 44.69,9.1 v2(44.69,8.72)
+VCC_VGA_S:
  vias: v1(171.99,203.72)
+VCCIO_OUT: length 92.9
  TOP w0.508: R816.1 R818.1 ; R818.1 R814.1 ; R818.1 v2(217.71,144.43) ; R35.2 199.68,140.62 v2(199.55,140.49) ; R981.1 226.06,136.46 225.08,137.45 v2(224.7,137.45) ; R72.1 201.3,137.95 202.44,139.1 v2(202.7,139.1) R73.1 203.65,139.38 203.99,139.73 205.39,139.73 206.28,138.84 206.28,138.47 207.84,136.91 v2(210.38,136.91) v2(214.66,132.62) ; R819.1 v2(223.81,141.13) ; v2(218.73,137.19) 217.71,138.21 v2(217.71,141.89) ; R980.1 222.82,136.18 v2(222.16,136.18) ; R5.2 204.92,147.13 v2(204.76,146.97) R6.2 203.68,148.4 R11.2
  BOTTOM w0.203: 219.41,130.41 SJ1.43 223.04,130.41 223.35,130.72 223.81,130.72 224.11,130.41 SJ1.44
  BOTTOM w0.508: v2(224.7,137.45) 224.19,137.45 222.92,136.18 v2(222.16,136.18) 221.14,137.19 v2(218.73,137.19) 210.66,137.19 v2(210.38,136.91) ; v2(217.71,141.89) 210.75,141.89 205.67,146.97 v2(204.76,146.97) ; v2(217.71,141.89) 223.43,141.89 223.81,141.51 v2(223.81,141.13) ; v2(217.71,141.89) v2(217.71,144.43) ; v2(199.55,140.49) 200.57,140.49 v1(201.76,139.3) 201.96,139.1 v2(202.7,139.1) ; 219.41,130.41 215.22,130.41 214.66,130.97 v2(214.66,132.62)
+VCCIO_PCH: length 122.9
  TOP w0.305: v3(54.9,87.28) 54.93,87.31 PCH1.C39
  TOP w0.381: v2(56.04,84.61) 56.94,84.61 58.08,85.76
  TOP w0.508: v2(67.09,90.18) 65.82,88.91 65.82,88.49 C286.1 65.12,87.03 64.96,86.87 C284.1 C285.1 64.83,85.25 59.12,85.25 59.11,85.26 59.11,85.27 58.62,85.76 58.08,85.76 ; v2(109.76,111.92) 109.09,112.59 R71.1 109.09,113.28 v2(110.01,114.21)
  BOTTOM w0.305: v2(56.04,84.61) 55.79,84.61 55.46,84.94 v1(55.46,86.27) 55.46,86.72 v3(54.9,87.28)
  BOTTOM w0.381: v2(110.01,114.21) 110.06,114.21 117.17,121.32 118.02,121.32 120.17,123.48 125.64,123.48 130.33,128.18 138.84,128.18 139.61,127.41 140.62,127.41 141.38,126.65 143.75,126.65 144.46,125.94 144.86,125.94 146.34,127.41 SR24.2
  BOTTOM w0.508: v2(109.76,111.92) 109.25,111.92 106.84,109.51 106.13,109.51 102.8,106.18 102.8,102.42 101.35,100.97 101.35,99.35 95.22,93.23 77.36,93.23 74.92,90.79 71,90.79 70.72,91.07 67.98,91.07 v2(67.09,90.18)
+VCCST: length 15.4
  TOP w0.381: CPU1.K9 v4(147.45,137.55)
  BOTTOM w0.508: v4(147.45,137.55) 146.59,136.69 146.59,134.3 v1(146.44,134.14) 145.7,133.41 145.7,132.75 146.46,131.99 SC12.2 148.15,130.94 SC14.1 149.56,129.52 149.56,127.88 SR24.1 SR17.2
+VDD33: length 122.8
  TOP w0.254: RLAN.46 46.6,226.52 46.18,226.09 ; RLAN.2 57.92,226.02 C458.2 ; RLAN.16 56.61,233.02 58.2,234.6 C457.2 ; RLAN.53 49.84,223.83 ; 45.94,231.74 46.67,231.02 RLAN.37 ; RLAN.59 52.84,223.94
  TOP w0.381: R762.2 62.52,237.36 v2(61.91,237.36)
  TOP w0.508: C457.2 58.74,235.13 v2(58.58,235.29) 60.2,235.29 v2(61.29,236.38) ; v2(45.12,227.87) R949.2 ; ROM2.3 31.88,205.29 31.6,205.01 ; 45.94,231.74 45.37,232.32 44.32,232.32 C456.2 44.86,233.1 v2(45.12,233.1) ; v2(58.58,225.08) 58.1,225.55 C458.2 ; v2(59.72,238.54) R763.2 v2(60.61,237.74) ; v2(51.09,221.14) 51.4,221.46 51.66,221.46 51.85,221.65 C455.2 51.85,222.94 52.84,223.94 ; 49.84,223.83 48.29,222.28 C452.2 48.71,221.74 48.98,221.47 48.98,220.05 v2(48.93,220) ; v2(44.2,223.81) C453.2 44.61,224.57 44.69,224.64 44.73,224.64 46.18,226.09 ; R453.2 v2(43.94,220.79) ; R694.1 v2(57.69,238.54) ; R454.1 53.6,237.77 v2(53.6,238.49)
  TOP w0.762: 28.76,204.02 28.76,205.85 29.24,206.33 30.66,206.33 31.86,207.52 33.51,207.52 34.96,208.97 v5(34.96,209.71) ; 28.76,204.02 28.15,204.02 27.52,203.38 ; 28.76,204.02 30.61,204.02 31.6,205.01 ; R450.1 C451.2 20.57,202.76 C857.1 22.89,204.19 QP9.D ; v5(50.65,211.54) 50.65,210.78 v5(51.72,209.71) ; v5(37.37,210.8) 39.44,208.73 47.71,208.73 47.93,208.95 v5(47.94,208.95)
  BOTTOM w0.381: v2(60.61,237.74) 61.53,237.74 v2(61.91,237.36) 61.91,237 v2(61.29,236.38)
  BOTTOM w0.508: v2(53.6,238.49) 54.44,237.65 56.8,237.65 v2(57.69,238.54) v2(59.72,238.54) ; 47.28,224.97 47.28,224.95 49.18,223.04 ; 47.28,224.97 47.28,234.86 47.71,235.29 54.13,235.29 54.13,235.29 v2(58.58,235.29) ; 47.28,224.97 v1(47.3,224.95)
  BOTTOM w0.762: v5(37.37,210.8) 36.46,210.8 35.36,209.71 v5(34.96,209.71) ; v5(47.94,208.95) 48.44,209.46 51.47,209.46 v5(51.72,209.71) ; 48.6,219.21 48.6,218.98 51.65,215.93 51.65,212.56 50.65,211.56 v5(50.65,211.54)
  vias: v2(53.63,219.74) v2(54.39,219.74)
+VIN: length 138.8
  TOP w0.508: R810.1 v2(219.11,142.78)
  TOP w0.635: R817.1 229.59,161.39 228.89,160.69 v2(228.38,160.69) ; v2(221.88,160.1) 221.9,160.08 R812.1
  BOTTOM w0.508: v2(211.42,193.52) 214.6,193.52 217.71,190.41 229.33,190.41 238.16,181.58 238.16,179.86 237.33,179.04 237.33,175.99 238.09,175.23 238.09,155.93 237.33,155.16 237.33,152.12 238.28,151.16 238.28,143.54 235.94,141.19 234.92,141.19 232.42,143.69 226.73,143.69 225.56,142.53 219.36,142.53 v2(219.11,142.78)
  BOTTOM w0.635: v2(221.88,160.1) 227.79,160.1 v2(228.38,160.69) 228.51,160.81 228.51,174.89 224.03,179.36 216.06,179.36 214.92,178.21 v2(210.22,178.21)
  vias: v2(138.84,192.18) v2(138.84,190.79) v2(138.84,189.39) v2(140.75,192.18) v2(141.51,194.47) v2(142.53,192.18) v2(143.54,194.47) v2(144.56,192.18) v2(145.32,190.41) v2(145.57,194.47) v2(146.59,192.18) v2(147.61,194.47) v2(148.37,192.82) v2(148.37,190.41) v2(149.89,194.47) v2(149.89,191.29) v2(151.42,192.82) v2(153.45,195.87) v2(155.1,195.87) v2(162.08,193.45) v2(163.61,193.45) v2(165.13,193.45) v2(166.66,193.45) v2(168.43,193.96) v2(168.43,193.07) v2(171.48,193.96) v2(171.48,193.07) v2(176.05,193.45) v2(178.34,193.45) v2(180.63,193.45) v2(183.93,193.96) v2(183.93,193.07) v2(186.85,193.96) v2(186.85,193.07) v2(190.85,193.52) v2(193.14,193.52) v2(195.42,193.52) v2(197.71,193.52) v2(199.99,193.52) v2(202.28,193.52) v2(202.47,184.56) v2(202.47,183.29) v2(204.57,193.52) v2(205.39,184.56) v2(205.39,183.29) v2(206.85,193.52) v2(209.14,193.52) v2(209.46,179.48) v2(209.46,177.58) v2(209.68,183.06) v2(211.08,183.06) v2(212.35,183.06) v2(216.31,196.91) v2(217.96,197.37) v2(219.08,194.27) v2(219.49,197.14) v2(219.87,195.74) v2(221.14,197.14) v2(221.14,195.74) v2(221.14,194.22)
-12V: length 716.5
  TOP w0.254: v2(109.76,184.44) 110.27,184.44 110.9,185.07 110.9,191.3 120.3,200.69 129.13,200.69 131.16,202.72 140.56,202.72 144.94,207.11 144.94,214.15 144.81,214.28 v2(144.81,214.41) ; v2(97.06,181.64) 97.06,156.36 95.97,155.27 95.97,132.16 94.06,130.25 94.06,115.85 92.42,114.21 86.96,114.21 83.66,110.9 80.8,110.9 78.84,112.87 78.84,114.14 v2(79.28,114.59) ; 36.23,205.39 36.23,202.6 34.63,201 22.22,201 21.76,201.45 18.07,201.45 12.61,195.99 12.61,189.49 15.6,186.49 15.6,176.77 11.97,173.13 8.92,173.13 8.29,172.5 4.02,172.5 0.69,169.17 0.69,146.97 v2(1.33,146.34) ; v2(1.66,143.77) 2.7,144.81 11.59,144.81 17.12,150.34 17.88,150.34 19.01,151.47 22.56,151.47 23.56,152.47 25.6,152.47 26.35,153.23 33.13,153.23 34.8,151.56 37.68,151.56 38.64,150.6 38.64,149.19 38.98,148.86 38.98,147.31 38.92,147.26 38.92,146.37 39,146.29 39,144.86 38.92,144.78 38.92,143.85 38.98,143.8 38.98,142.25 38.9,142.18 38.9,139.65 41.52,137.03 43.43,137.03 44.02,137.61 45.31,137.61 45.86,137.06 45.86,136.01 50.01,131.86 58.13,131.86 58.9,131.1 65.22,131.1 76.11,120.21 76.11,115.48 v2(76.87,114.71) ; v2(198.03,213.9) 197.17,213.9 C810.1 196.41,214.33 D30.N
  TOP w0.381: v2(5.24,27.85) 5.24,28.29 4.67,28.86 2.26,28.86 0.7,30.42 0.7,145.71 v2(1.33,146.34) ; v2(90.84,9.54) 88.2,9.54 83.48,14.26 76.9,14.26 72.3,9.65 72.3,5.37 70.77,3.84 57.31,3.84 56.29,4.86 54.01,4.86 51.68,2.53 9.86,2.53 7.78,4.61 7.78,6.19 3.21,10.76 3.21,23.15 4.48,24.42 v2(4.6,24.42)
  TOP w0.508: v2(37.37,204.38) 37.36,204.39 37.36,206.88 C352.1 36.86,207.17 36.23,206.53 36.23,205.39 ; v2(39.15,204.38) 39.15,203.41 PCI.B1 ; v2(125.44,10.97) 125.44,15.03 C624.1 C625.1 126.91,15.23 126.91,13.14 ATX_POWER.4
  BOTTOM w0.254: v2(144.81,214.41) 145.7,215.3 149.26,215.3 150.45,214.1 151.49,214.1 154.01,216.62 165.34,216.62 165.59,216.87 168.61,216.87 169.2,216.29 170.39,216.29 172.27,218.17 184.3,218.17 186.34,216.12 189.39,216.12 192.76,212.76 196.88,212.76 v2(198.03,213.9) ; v2(1.33,146.34) 1.33,146.28 2.12,145.5 2.12,144.23 v2(1.66,143.77) ; v2(109.76,184.44) 99.85,184.44 v2(97.06,181.64) ; v2(79.28,114.59) 79.22,114.52 77.06,114.52 v2(76.87,114.71)
  BOTTOM w0.381: v2(4.6,24.42) 4.6,27.21 v2(5.24,27.85)
  BOTTOM w0.508: v2(39.15,204.38) v2(37.37,204.38) ; v2(125.44,10.97) 105.46,10.97 104.03,9.54 v2(90.84,9.54)
DGND: length 6.5
  TOP w0.508: R467.1 119.64,215.84 USB3_LAN.28
GND: length 1502.2
  TOP w0.102: v3(58,101.97) 58.28,101.97 58.86,102.55 59.67,102.55 60.92,103.79 63.79,103.79 63.91,103.92 ; v3(55.51,100.61) 55.72,100.82 56.54,100.82 56.79,101.07 58.39,101.07 58.89,101.57 60.1,101.57 60.98,102.45 63.79,102.45 64.08,102.74 65.54,102.74 67.98,100.3 67.98,98.08 68.61,97.44 68.61,96.91 68.94,96.58 R131.1 ; C241.2 35.08,62.95
  TOP w0.127: v2(55.28,223.93) 55.62,223.93 56.17,223.39 56.17,222.57 56.29,222.44 R451.2 ; v2(56.04,224.57) 56.74,223.87 57.13,223.87 57.56,223.44 v2(57.56,222.66)
  TOP w0.152: PCH1.AP4 39.07,105.79 39.78,105.08 v3(39.88,105.08)
  TOP w0.178: U41.17 53.52,34.6 ; 53.52,32.4 U41.5 ; PCH1.AV17 36.73,98.9 36.73,98.91 36.44,98.91 36.38,98.96 35.66,98.96 v3(35.61,98.91)
  TOP w0.203: v3(49.35,108.15) 49.16,107.96 PCH1.R1 ; v3(43.94,84.64) 44.12,84.82 PCH1.AE41 ; v2(58.76,157.64) 58.84,157.55 U11.48 ; U11.42 61.24,157.51 ; U11.95 50.09,142.89 50.03,142.83 50.03,142.81 49.21,142.81 v2(49.18,142.78) ; U11.111 58.04,141.99 58.49,142.44 v2(58.56,142.44) ; PCH1.B3 56.16,106.29 v3(55.53,105.66) ; v2(49.44,149.49) 49.9,149.49 50.03,149.36 50.03,149.35 50.09,149.29 U11.79 ; v2(49.31,151.29) 49.71,151.69 U11.73 ; U11.22 65.14,150.89 v2(64.4,150.15) ; v3(35.69,96.96) 35.87,97.13 36.7,97.13 36.71,97.13 37,97.13 PCH1.AV21 ; U11.60 v2(54.04,155.1) 54.59,155.1 54.85,155.36 54.84,155.36 U11.58 ; PCH1.B30 56.51,92.11 57.32,92.11 57.46,91.98 v3(57.46,91.98) ; PCH1.Y41 46.65,85.99 46.65,85.11 v3(46.77,85) ; v2(63.76,142.53) 63.24,142.01 U11.124 ; PCH1.U1 47.99,109.02 48.04,109.08 v2(48.01,109.08) ; v2(63.86,158.15) 63.64,157.93 U11.36 ; v2(58.71,143.16) 59.21,142.65 59.21,142.27 58.84,141.9 U11.113
  TOP w0.216: v3(58.58,97.06) 58.36,96.84 56.98,96.84 PCH1.A21
  TOP w0.229: PCH1.B25 57.4,94.71 57.54,94.57 58.99,94.57 v3(59.57,95.16) ; v4(165.93,107.18) 165.73,107.39 165.73,108.67 CPU1.AY26
  TOP w0.254: v3(39.85,89.75) 39.99,89.75 40.41,89.32 PCH1.AM35 ; U43.11 15.8,26.85 v2(15.27,26.32) ; v2(8.54,148.62) 8.8,148.62 9.32,148.1 C607.2 ; QN48.E 135.8,25.94 139.22,25.94 v2(139.61,25.56) 139.89,25.85 C827.2 ; D39.P 128.94,207.93 129.06,207.8 v2(129.06,208.06) ; R169.2 57.69,66.58 v2(57.44,66.33) ; v2(193.96,10.95) 193.96,10.98 196.58,13.6 RJ17.3 ; v2(192.31,10.95) 192.31,11.08 194.16,12.94 R945.2 194.65,13.65 RJ7.3 ; PCH1.AV12 36.78,101.43 36.74,101.47 36.15,101.47 35.94,101.68 v3(35.78,101.68) ; U11.97 52.39,140.67 51.97,140.24 v2(51.72,140.24) ; v2(18.96,218.09) 18.7,217.83 CODEC.7 ; PCH1.AV2 37.62,106.33 PCH1.AU3 ; C594.2 135.16,22.7 135.16,20.99 134.78,20.61 v2(134.65,20.61) ; U21.74 v2(208.48,17.3) ; PCH1.Y1 46.84,107.83 v2(46.84,108.74) ; v2(64.99,79.7) 65.46,80.17 R174.2 ; v2(197.96,211.42) 198.13,211.25 U42.11 ; CPU1.G15 v4(152.94,139.38) ; RLAN.31 v2(48.34,234.6) ; v2(220.25,33.81) 219.9,33.81 219.48,33.39 U21.7 ; RLAN.25 v2(51.34,234.6)
  TOP w0.305: PCH1.AM26 40.22,94 40.22,93.68 ; 40.22,93.68 40.22,93.5 PCH1.AN28 ; 40.22,93.68 v3(40.21,93.68) ; v3(37.58,87.96) 38.28,87.96 PCH1.AT38 38.31,87.96 38.67,88.33 PCH1.AR37 ; v3(37.58,87.96) 37.58,87.27 ; v3(37.58,87.96) 37.58,87.99 PCH1.AT36 38.45,88.85 38.45,89.1 PCH1.AR35 ; v2(163.54,209.96) U36.3 ; v3(55.98,85.33) 55.98,85.75 PCH1.C41 ; PCH1.AM24 40.43,95.11 v3(40.77,94.77) 41.14,95.14 PCH1.AK24 ; PCH1.H8 52.5,103.64 v3(52.25,103.4) ; C345.2 50.96,136.35 50.81,136.2 50.81,135.34 v2(50.99,135.16) ; PCH1.R34 48.98,90.35 v3(48.72,90.35) 48.62,90.35 PCH1.U32 PCH1.U31 ; PCH1.AT33 37.96,90.57 v3(37.82,90.71) 37.61,90.5 PCH1.AV33 ; PCH1.W5 v3(47.9,106.17) ; v3(47.9,106.17) 47.78,106.29 PCH1.W3 ; v3(47.9,106.17) 47.99,106.08 PCH1.U4 ; CPU1.AY23 162.7,108.53 v4(162.7,108.09) ; PCH1.D32 54.92,91.07 v3(55.5,90.49) 55.59,90.4 PCH1.B33 ; PCH1.K4 51.88,105.93 52.23,105.59 PCH1.J5 52.47,105.6 v3(53.03,106.16) ; PCH1.AC38 45.39,87.89 v3(45.39,87.44) ; PCH1.AT28 37.87,93.1 v3(37.78,93) 38.35,92.42 PCH1.AT29 ; v3(58,101.97) 57.95,101.92 PCH1.A12 ; 37.58,87.27 36.97,86.66 PCH1.AV40 ; 37.58,87.27 PCH1.AU39 ; PCH1.A16 57.18,99.34 57.61,99.77 59.26,99.77 v3(59.46,99.98) ; v3(37.8,95.77) 38.18,95.77 PCH1.AT23 38.36,95.59 PCH1.AT24 ; v2(107.83,213.88) 108.03,214.08 108.77,214.08 D35.P ; PCH1.W20 46.66,97.61 v3(46.64,97.61) ; PCH1.M16 50.51,99.4 v3(50.2,99.1) 50.72,98.58 PCH1.M18 ; PCH1.AW7 35.46,104.45 v3(35.34,104.32) ; U35.3 168.88,209.9 168.82,209.96 v2(168.76,209.96) ; v3(52.25,103.4) 52.66,102.99 PCH1.H9 ; v3(52.25,103.4) 52.01,103.15 PCH1.K9 ; PCH1.AM16 40.77,99.75 v3(40.77,100.08) ; CPU1.E38 v4(176.17,140.29) ; v3(50.48,87.43) 50.35,87.56 PCH1.N38 ; CPU1.AJ32 v4(171.6,119.26) ; PCH1.AW30 34.79,91.69 v3(34.7,91.78) ; PCH1.D14 55.41,100.52 v3(55.51,100.61) ; PCH1.AC34 45.45,90.44 v3(45.64,90.44) 45.84,90.44 PCH1.AA34 ; v3(39.99,87.46) 40.14,87.62 PCH1.AM38 40.78,87.99 PCH1.AL37 41.16,88.03 PCH1.AK37 ; CPU1.AL21 161.07,116.97 160.62,117.42 v4(160.62,117.43) ; PCH1.AJ28 41.56,92.71 v3(41.56,92.34) ; v3(40.22,106.17) 40.36,106.03 PCH1.AM4 40.4,105.59 PCH1.AL5 ; PCH1.H4 53.14,105.4 v3(53.41,105.13) 53.23,104.94 PCH1.H6 ; PCH1.V38 47.82,87.49 v3(47.9,87.42) 47.9,86.96 PCH1.V40 ; C245.2 C210.2 165.67,210.98 164.73,210.98 164.5,210.75 v2(164.5,210.42) ; CPU1.P5 v4(144.71,132.98) ; v3(54.26,91.22) 54.62,91.58 PCH1.E31 54.65,91.68 PCH1.D31 ; CPU1.AM19 v4(159.71,116.52) ; v2(118.52,213.14) 118.52,213.91 D37.P ; PCH1.AP9 39.01,103.43 v3(38.83,103.61) 38.66,103.61 PCH1.AT8 38.01,104.26 PCH1.AT7 ; PCH1.AT1 38.28,108.13 v3(38.39,108.24) ; PCH1.D41 55,85.33 v3(54.92,85.25) ; PCH1.AL11 40.8,101.14 v3(40.77,101.12) 40.77,100.95 PCH1.AM14 ; CPU1.M9 v4(147.45,135.72) ; PCH1.AG34 42.62,89.87 v3(42.3,89.87) ; v3(57.45,88.87) 57.15,89.17 PCH1.A35 ; PCH1.AG4 42.93,106.08 v3(42.84,106.17) 42.93,106.27 PCH1.AG2 ; PCH1.N35 50.21,89.14 v3(49.79,89.14) ; PCH1.H16 52.61,99.64 v3(52.61,100.08) 52.85,100.32 PCH1.H14 ; PCH1.AR11 38.63,101.93 PCH1.AT11 38.01,102.2 PCH1.AT10 38.35,102.54 v3(37.78,103.12) ; PCH1.N4 50.52,106.08 v3(50.43,106.17) ; v3(42.83,87.43) 42.76,87.5 PCH1.AG38 ; v3(46.64,98.42) 46.62,98.42 PCH1.AA17 ; PCH1.L41 51.76,85.2 51.81,85.15 v3(51.81,85.2) ; PCH1.AA22 46.24,96.4 v3(46.64,96) 46.66,96 PCH1.W22 ; PCH1.AK9 41.13,103.64 PCH1.AM8 ; PCH1.N8 50.18,103.25 v3(49.91,103.25) 49.5,103.25 PCH1.R8 ; PCH1.T17 48.35,98.42 v3(48.33,98.42) ; v2(205.14,31.02) 204.39,31.02 203.91,31.5 U21.38 ; PCH1.R10 48.83,103.22 v3(48.68,103.22) 48.48,103.22 PCH1.U8 ; PCH1.AT21 38.01,97.2 38.3,97.48 PCH1.AT20 v3(37.78,98.06) 37.87,98.16 PCH1.AT18 ; v3(41.31,108.24) 41.52,108.02 PCH1.AJ1 ; PCH1.AM6 40.32,105.08 v3(39.88,105.08) ; v2(53.37,162.72) 53.98,162.72 C349.2 53.73,161.9 53.73,160.68 C326.2 ; PCH1.H22 52.51,96.69 v3(52.51,96.81) 52.51,96.92 PCH1.H20 ; CPU1.AT6 v4(144.71,113.77) ; CPU1.AT10 148.82,113.34 v4(148.34,112.86) ; v3(35.69,84.59) 36.8,84.59 38.1,85.89 PCH1.AT41 ; CPU1.J11 v4(150.2,138.46) ; v4(141.97,138.46) CPU1.J3 ; PCH1.AT14 37.87,100.69 v3(37.75,100.57) 37.8,100.57 38.35,100.01 PCH1.AT15 38.36,99.75 PCH1.AT16 ; v4(146.54,138.46) CPU1.J7 ; CPU1.N4 v4(142.88,133.89)
  TOP w0.356: CPU1.AL39 177.54,117 v4(177.08,117.46) 176.63,117 CPU1.AL38 ; v4(139.55,135.15) 139.67,135.26 CPU1.M1 ; CPU1.AY27 166.57,108.14 v4(166.63,108.03) ; v4(165.74,141.21) CPU1.F28 ; CPU1.AM15 155.12,116.54 v4(155.12,116.52) 155.12,116.49 CPU1.AM14 ; CPU1.H11 v4(149.28,139.38) CPU1.H10 ; v4(166.11,117.43) CPU1.AK27 v4(166.11,118.35) ; CPU1.K30 167.13,137.09 v4(167.58,137.55) ; CPU1.D32 v4(170.68,141.21) ; CPU1.E7 v4(145.62,141.21) CPU1.E6 ; CPU1.K4 v4(142.88,137.55) ; v4(159.68,119.26) 159.25,118.83 CPU1.AJ19 ; CPU1.AU34 172.99,111.49 v4(173.45,111.03) 172.99,110.57 CPU1.AV34 ; CPU1.AA33 v4(172.51,125.66) CPU1.AB34 ; CPU1.AC40 178.59,124.29 178.99,124.68 178.99,124.71 v4(179.03,124.75) ; CPU1.AD7 v4(145.62,123.83) ; v4(168.85,119.26) CPU1.AJ30 v4(168.85,118.35) ; CPU1.H28 v4(165.74,139.38) ; CPU1.AM30 v4(168.85,116.52) ; v4(172.51,132.98) CPU1.N33 ; CPU1.AK13 v4(153.31,118.35) ; CPU1.AJ5 v4(143.79,119.26) CPU1.AK5 ; v4(152.94,135.72) 152.49,135.26 CPU1.M14 ; CPU1.AL30 v4(168.85,117.43) CPU1.AK30 ; CPU1.AM2 v4(141.97,117.46) CPU1.AM3 ; CPU1.AE40 v4(179.12,122.46) ; CPU1.AM35 173.81,116.13 173.66,116.13 173.66,116.14 173.19,116.14 173.04,116.13 CPU1.AM34 v4(172.51,115.6) ; CPU1.AJ11 v4(151.48,118.35) CPU1.AK11 ; CPU1.AJ16 156.48,118.8 ; 156.48,118.8 156.04,118.36 156.04,118.35 156.05,118.34 v4(156.05,118.34) ; 156.48,118.8 v4(156.03,119.26) ; v4(139.93,115.07) 140.01,115.15 CPU1.AP1 ; CPU1.K40 178.47,136.18 v4(178.98,136.68) ; CPU1.W4 v4(143.79,128.4) ; v4(143.79,128.4) CPU1.Y5 ; v4(143.79,128.4) CPU1.Y4 ; CPU1.AR27 166.57,113.32 166.3,113.58 166.3,113.97 CPU1.AP27 166.59,114.23 v4(167.05,114.69) 166.59,115.15 CPU1.AN27 166.57,115.27 166.47,115.37 166.47,115.83 166.57,115.94 CPU1.AM27 v4(167.03,116.52) CPU1.AL27 v4(166.11,116.52) ; CPU1.AR31 v4(170.69,112.86) CPU1.AR32 ; CPU1.H17 v4(154.77,139.38) CPU1.G17 ; v4(145.62,139.38) CPU1.G6 ; v4(153.85,143.03) CPU1.D15 ; CPU1.F16 v4(153.85,140.29) CPU1.G16 ; CPU1.AM31 v4(170.68,115.6) ; v4(152.02,143.03) CPU1.D13 ; CPU1.J14 v4(152.94,137.55) ; CPU1.AM24 v4(163.37,116.52) CPU1.AL24 ; CPU1.T6 v4(145.62,131.15) CPU1.T7 ; v4(173.43,119.26) CPU1.AJ34 v4(173.43,118.35) ; CPU1.AW7 v4(145.62,111.03) CPU1.AV7 CPU1.AU7 ; CPU1.AY17 v4(157.42,108.1) ; v4(156.97,117.43) CPU1.AL17 v4(157.88,117.43) ; CPU1.AK29 v4(167.94,118.35) ; CPU1.L7 v4(145.62,136.63) CPU1.K7 ; CPU1.AH33 v4(171.6,120.17) ; CPU1.AT7 145.96,113.2 145.29,113.2 CPU1.AT6 ; v4(169.87,108.29) 169.77,108.29 CPU1.AY30 CPU1.AW30 ; CPU1.AN8 v4(147.45,115.58) ; CPU1.G3 v4(142.88,139.38) CPU1.H4 ; CPU1.M26 v4(163.91,135.72) ; 165.63,112.4 v4(165.17,111.94) 164.74,111.51 CPU1.AU25 ; 165.63,112.4 CPU1.AT26 ; 165.63,112.4 v4(165.17,112.86) 164.74,112.43 CPU1.AT25 164.64,112.3 163.93,112.3 CPU1.AT24 163.8,112.4 v4(163.39,111.94) ; CPU1.N7 v4(145.62,134.8) CPU1.N6 ; CPU1.K10 v4(149.28,136.63) ; CPU1.AT11 v4(152.39,112.86) 152.85,112.43 CPU1.AT12 ; v4(179.13,113.18) 178.99,113.32 CPU1.AR40 ; CPU1.K34 v4(172.51,135.72) ; CPU1.AG33 v4(171.6,121.09) ; v4(145.62,138.46) CPU1.H7 ; v4(143.79,115.58) CPU1.AP5 ; v4(143.79,115.58) CPU1.AN5 ; v4(143.79,115.58) 143.36,115.15 CPU1.AP4 ; CPU1.M32 v4(170.68,133.89) ; CPU1.AF5 v4(143.79,122.92) CPU1.AE5 ; v4(139.48,131.37) 139.71,131.6 CPU1.T1 CPU1.T2 ; CPU1.C19 157.05,143.96 v4(156.8,144.21) 156.14,143.55 CPU1.C18 ; CPU1.AR20 v4(159.74,112.86) CPU1.AR19 ; CPU1.AV21 v4(161.08,109.94) ; CPU1.G9 v4(147.45,139.38) CPU1.H9 ; v4(165.76,137.55) 165.3,137.09 CPU1.K28 ; CPU1.AC39 v4(178,124.75) ; CPU1.T4 v4(142.88,131.15) ; v4(162.45,117.43) CPU1.AL22 v4(161.54,117.43) CPU1.AL21 ; CPU1.AG37 v4(176.17,121.09) ; CPU1.AL11 151.45,116.49 v4(151.45,116.52) ; v4(171.6,111.92) 171.14,112.38 CPU1.AT32 ; CPU1.G14 v4(152.94,140.29) ; CPU1.M20 v4(158.42,135.72) ; CPU1.AU5 v4(143.79,111.94) ; CPU1.AR33 172.05,113.29 v4(171.6,112.83) ; CPU1.H8 v4(146.54,139.38) CPU1.G7 ; CPU1.F26 v4(163.91,141.21) ; CPU1.M4 v4(142.88,135.72) CPU1.L3 ; CPU1.AH8 v4(146.54,121.09) ; v4(165.74,144.86) CPU1.B28 ; CPU1.P2 v4(141.97,132.98) CPU1.R3 ; CPU1.AA8 146.87,127.16 146.21,127.16 CPU1.AA7 145.96,126.91 145.96,126.24 CPU1.AB7 ; CPU1.L9 v4(147.45,136.63) CPU1.L8 ; v4(154.77,135.72) 154.32,135.26 CPU1.M16 ; CPU1.D5 v4(144.71,142.12) CPU1.D6 ; CPU1.H34 v4(172.51,137.55) ; CPU1.AL36 174.8,117 v4(175.25,117.46) CPU1.AK36 ; v4(156.05,114.68) 156.07,114.68 155.62,114.23 CPU1.AP15 ; CPU1.M28 v4(165.74,135.72) ; CPU1.F14 v4(152.02,140.29) CPU1.G13 ; CPU1.AF36 CPU1.AG36 v4(175.25,120.17) ; CPU1.AT15 155.11,111.94 ; 155.11,111.94 CPU1.AT14 ; 155.11,111.94 v4(155.16,111.94) ; CPU1.AN24 163.85,115.15 ; CPU1.AE37 v4(176.17,122.92) ; CPU1.AC38 v4(176.17,124.75) CPU1.AC37 v4(175.25,124.75) ; CPU1.M24 v4(162.08,135.72) ; v4(171.6,115.6) CPU1.AM33 ; v4(167.97,111.03) 167.48,110.6 CPU1.AV28 ; v4(167.94,111.94) 168.4,112.39 CPU1.AT29 CPU1.AT30 ; v4(148.74,145.21) 148.82,145.13 CPU1.B10 ; CPU1.AP24 163.54,113.95 163.54,113.6 163.82,113.32 CPU1.AR24 CPU1.AR23 CPU1.AR22 v4(161.51,112.86) CPU1.AR21 ; CPU1.AM36 174.8,116.03 v4(175.25,115.58) CPU1.AN36 ; CPU1.AK18 v4(158.8,118.35) CPU1.AK19 ; CPU1.AJ8 v4(147.45,119.26) ; CPU1.AR36 v4(175.25,113.77) CPU1.AP36 ; CPU1.D34 v4(172.51,141.21) ; CPU1.J20 v4(158.42,137.55) CPU1.K20 ; CPU1.AK7 v4(145.62,119.26) ; v4(150.2,143.03) CPU1.D11 ; CPU1.AN40 v4(179.12,115.15) ; CPU1.A15 153.4,145.99 v4(153.5,146.1) ; CPU1.AH36 v4(175.25,119.26) CPU1.AJ36 ; CPU1.AD6 v4(145.62,124.75) CPU1.AC6 ; CPU1.AT5 v4(143.79,113.77) CPU1.AR5 ; CPU1.AD33 v4(171.6,122.92) CPU1.AE33 ; v4(150.2,136.63) CPU1.L11 ; CPU1.AK10 v4(149.28,118.35) ; CPU1.E3 v4(142.89,141.19) CPU1.F4 ; CPU1.M22 v4(160.25,135.72) ; v4(174.89,108.8) 174.8,109.24 CPU1.AW36 ; CPU1.AT8 v4(147.45,112.86) CPU1.AT9 ; CPU1.F19 CPU1.E20 v4(158.42,141.21) ; CPU1.AV30 169.34,110.57 v4(169.77,111.02) 169.34,111.49 CPU1.AU30 ; CPU1.AC7 v4(146.54,124.75) CPU1.AD8 ; CPU1.AG40 v4(179.12,120.63) ; CPU1.AN37 v4(176.18,115.58) ; CPU1.AN16 156.05,115.61 v4(156.05,115.6) ; CPU1.AY7 v4(146.08,109) ; CPU1.AT38 176.65,112.4 v4(177.08,111.97) CPU1.AU38 ; v4(143.79,131.15) CPU1.U4 ; CPU1.U2 v4(141.05,130.23) ; CPU1.AT28 167.48,112.38 v4(167.05,111.94) 166.57,112.38 CPU1.AT27 ; CPU1.AJ31 v4(170.68,119.26) ; CPU1.AA6 v4(144.71,127.49) CPU1.Y6 ; CPU1.AK12 v4(152.39,118.35) ; v4(178.99,126.86) 177.78,126.86 177.04,126.12 CPU1.AA38 ; v4(175.25,124.75) CPU1.AC36 v4(174.34,124.75) CPU1.AC35 v4(173.43,124.75) CPU1.AC34 172.51,124.75 CPU1.AC33 v4(172.51,123.83) ; v4(175.25,124.75) CPU1.AB37 ; CPU1.AM4 v4(142.88,117.46) ; v4(155.16,112.86) 155.11,112.86 CPU1.AR14 ; v4(139.88,118.8) CPU1.AK1 ; CPU1.M6 v4(145.62,135.72) CPU1.M7 ; CPU1.D17 v4(155.68,142.12) CPU1.E18 ; v4(162.1,137.55) 161.64,137.09 CPU1.K24 ; v4(158.77,119.26) 158.34,118.83 CPU1.AJ18 ; CPU1.F34 v4(172.51,139.38) ; CPU1.A17 155.22,145.94 v4(155.4,146.11) ; CPU1.AK4 v4(142.88,119.26) ; CPU1.AT36 v4(175.25,111.94) ; v4(167.57,141.21) CPU1.F30 ; CPU1.V40 179.3,128.86 v4(179.63,129.19) ; v4(145.62,118.35) CPU1.AK6 v4(144.71,119.26) ; CPU1.V6 v4(144.71,129.32) ; CPU1.AM32 v4(170.68,116.52) ; v4(177.08,131.15) CPU1.R39 ; PCH1.AM20 40.43,97.46 40.74,97.77 v3(40.75,97.77) 40.7,97.82 40.7,97.88 40.43,98.14 PCH1.AM18 ; CPU1.AJ14 154.68,118.82 154.24,119.26 v4(154.2,119.26) ; CPU1.AC3 CPU1.AD3 CPU1.AD2 141.51,124.31 v4(141.05,124.77) 140.59,124.31 CPU1.AD1 140.47,124.29 v4(139.98,124.77) ; CPU1.F24 v4(162.08,141.21) ; CPU1.H26 v4(163.91,139.38) ; PCH1.B41 56.6,85.88 v3(57.44,85.88) ; v4(151.11,143.95) CPU1.C12 ; CPU1.AJ33 v4(172.51,119.26) ; CPU1.H24 v4(162.08,139.38) ; CPU1.AK26 v4(165.2,118.35) ; v4(163.93,137.55) 163.47,137.09 CPU1.K26 ; CPU1.H22 v4(160.25,139.38) ; CPU1.H30 v4(167.57,139.38) ; CPU1.AT2 v4(141.97,113.77) CPU1.AT3 ; v4(146.54,119.26) CPU1.AK8 ; CPU1.AT1 140.57,113.34 140.04,113.34 v4(139.84,113.15) ; CPU1.M5 v4(144.71,134.8) ; CPU1.AG8 v4(146.54,122) ; v4(152.94,143.95) CPU1.C14 ; v4(168.85,114.69) 169.34,115.15 CPU1.AN30 ; v3(55.28,108.17) 55.01,107.91 PCH1.D1 ; CPU1.AL37 v4(176.17,117.46) ; v4(172.99,108.62) 172.97,109.02 CPU1.AW34 ; CPU1.AK28 v4(167.03,118.35) ; v4(167.57,144.86) CPU1.B30 ; CPU1.H39 v4(178,138.46) ; CPU1.AT4 v4(142.88,113.77) ; CPU1.AR17 v4(157.88,112.86) CPU1.AR18 ; CPU1.AF33 v4(172.51,122) ; CPU1.AK24 v4(164.28,118.35) CPU1.AK25 ; CPU1.AH5 v4(143.79,120.17) ; v4(167.57,143.03) CPU1.D30 ; CPU1.B34 v4(172.51,143.03) ; CPU1.AU3 142.42,112.38 v4(141.99,111.94) ; v4(148.37,142.12) CPU1.E10 ; CPU1.B24 v4(162.08,144.86) ; v4(139.93,122.46) CPU1.AF1 ; CPU1.H13 v4(152.02,139.38) ; CPU1.AD4 CPU1.AD5 144.69,124.72 v4(144.69,124.75) ; CPU1.B8 146.99,145.07 v4(147.07,145.15) ; v4(141.99,111.94) 141.53,112.4 CPU1.AU2 ; v4(141.99,111.94) 142.01,111.92 CPU1.AV3 ; CPU1.AJ23 v4(162.45,119.26) ; CPU1.AR38 176.63,113.34 v4(177.08,113.8) 177.54,113.34 CPU1.AR39 ; v4(165.74,143.03) CPU1.D28 ; v4(154.2,116.52) 154.19,116.52 154.21,116.5 CPU1.AL14 154.22,117.43 v4(154.23,117.43) ; CPU1.A13 151.57,146.01 v4(151.47,146.11) ; CPU1.M30 v4(167.57,135.72) ; PCH1.M20 PCH1.M18 ; CPU1.AH3 v4(141.97,121.09) CPU1.AH2 ; CPU1.H32 v4(170.68,137.55) ; CPU1.AN7 v4(146.54,115.58) ; CPU1.AK9 v4(148.37,119.26) ; CPU1.AE36 v4(175.25,122.92) CPU1.AD36 ; CPU1.AW26 v4(166.11,110.12) ; v4(144.71,136.63) CPU1.L6 ; CPU1.AL5 v4(143.79,117.46) CPU1.AM5 ; CPU1.D24 v4(162.08,143.03) ; CPU1.F1 140.03,140.75 140.03,140.74 v4(139.95,140.74) ; v4(145.62,140.29) CPU1.F7 ; CPU1.AR37 v4(176.17,113.77) ; v4(139.81,128.95) 139.89,128.86 CPU1.W1 ; CPU1.D26 v4(163.91,143.03) ; CPU1.AA3 141.83,127.03 v4(141.51,127.35) ; CPU1.AJ26 v4(165.2,119.26) ; v4(145.62,143.95) CPU1.C6 ; v4(144.03,145.99) 144.03,145.54 CPU1.A5 ; CPU1.AN22 161.97,115.15 v4(161.51,114.69) ; v4(154.77,143.95) CPU1.C16 ; CPU1.A7 146.08,146.04 v4(146.09,146.08) ; CPU1.AM11 v4(151.48,115.6) ; CPU1.AH4 v4(142.88,121.09) ; CPU1.M18 v4(156.6,135.72) ; CPU1.AE8 v4(147.45,123.83) ; v4(144.71,126.6) 144.23,126.12 CPU1.AB5 ; v4(161.54,119.26) CPU1.AJ22 ; v4(160.27,137.55) 159.81,137.09 CPU1.K22 ; CPU1.AY5 v4(144.25,109) ; CPU1.R5 CPU1.T5 v4(144.71,131.15) ; CPU1.A11 149.74,145.84 149.63,145.94 v4(149.63,145.95) ; v4(144.71,132.98) CPU1.R6 ; CPU1.F32 v4(170.68,139.38) ; v4(148.37,143.03) CPU1.D9 ; CPU1.AH1 v4(139.93,120.63) ; CPU1.AJ40 v4(179.12,118.8) ; CPU1.F12 v4(150.2,140.29) CPU1.G11 ; CPU1.AL40 v4(179.12,116.97) ; CPU1.N3 v4(141.97,134.8) CPU1.N2 v4(141.05,134.8) CPU1.N1 ; CPU1.AF8 v4(147.45,122.92) ; CPU1.V3 v4(141.97,129.32) ; CPU1.AR30 v4(168.85,113.8) 169.34,114.23 CPU1.AP30 ; CPU1.B26 v4(163.91,144.86) ; CPU1.C21 158.88,144.12 v4(158.54,144.46) ; CPU1.AG39 177.54,120.66 v4(177.08,121.09) 176.63,120.66 CPU1.AG38 ; CPU1.H18 v4(155.68,138.46) ; CPU1.D7 v4(146.54,142.12) CPU1.E8 ; CPU1.AJ37 v4(176.18,119.27) ; v4(145.62,137.55) CPU1.J6 ; CPU1.AF4 v4(142.88,122.89) ; CPU1.B32 v4(170.68,143.03) ; v2(155.67,221.39) 155.67,221.37 155.9,221.14 U7.2 ; CPU1.AT39 v4(178,112.86) ; CPU1.AJ27 v4(166.11,119.26) ; v4(154.22,118.35) CPU1.AK14 ; CPU1.AT34 CPU1.AR34 v4(173.43,113.77) 173.88,113.3 CPU1.AR35 v4(174.34,113.77) ; CPU1.AM1 v4(139.93,116.97) ; CPU1.L38 v4(176.17,135.72) ; v4(145.62,129.32) CPU1.W7 ; CPU1.K1 v4(140.14,136.63) ; v4(143.79,122) CPU1.AG5 ; CPU1.G12 v4(150.2,139.38) ; CPU1.AW32 171.14,109.02 v4(171.11,109) ; CPU1.AN9 v4(148.37,115.58) ; CPU1.AN23 v4(162.45,115.6) ; CPU1.K32 v4(170.68,135.72) ; CPU1.AN10 v4(148.37,116.52) ; CPU1.AN6 v4(145.62,115.58) ; CPU1.AJ35 v4(174.34,119.26) ; CPU1.U7 v4(145.62,130.23)
  TOP w0.381: CPU1.P38 v4(177.08,132.98) CPU1.P39 ; CPU1.AR11 151.48,113.77 v4(151.47,113.77) ; U8.8 v2(174.02,220.25) ; C350.2 47.75,191.45 v2(48.55,190.66) ; v2(17.43,93.96) 17.6,93.79 C846.2 ; CPU1.R38 v4(177.08,131.15) ; v2(161.32,209.99) 160.81,210.51 C208.2 C246.2 ; CPU1.AB6 145.17,126.15 v4(144.71,126.6) ; C403.1 v2(63.63,112.14) ; v2(52.36,135.16) 53.75,135.16 55.56,136.97 C333.2 ; v4(177.08,130.23) CPU1.T38 ; C351.2 v2(49.05,197.39) ; PCH1.B41 56.31,86.18 PCH1.B40 ; 195.28,5.58 R409.2 ; 195.28,5.58 C431.1 ; 195.28,5.58 v2(196.12,4.73) 195.58,4.73 C845.2 ; v4(176.17,131.15) CPU1.T37 ; C710.2 v2(168.56,223.17) ; v2(162.37,223.17) C709.2 ; CPU1.N39 v4(178,132.98) CPU1.P40 ; C371.2 18.54,5.62 C370.2 17.3,5.75 v2(17.3,6.99) ; CPU1.AN11 151.48,114.68 ; 151.48,114.68 v4(151.41,114.68) ; 151.48,114.68 151.49,114.68 CPU1.AP11 ; U2.3 v2(213.77,220.38) ; CPU1.M37 v4(176.17,133.89) ; U4.8 v2(182.4,229.14) ; U1.3 v2(209.96,220.5) ; U23.11 235.35,20.34 235.74,20.73 v2(236.24,20.73) ; U10.8 v2(177.96,223.04) ; v2(58.76,157.64) 61.12,157.64 61.24,157.51 ; CPU1.R37 v4(175.25,131.15) CPU1.T36 ; v2(20.48,89.06) 20.57,89.15 C659.1 ; U12.3 12.15,107.29 11.84,107.6 v2(11.59,107.6) ; v2(31.4,85.25) 30.54,85.25 R161.1 30.43,85.22 29.48,84.27 R160.1 ; CPU1.R40 v4(178,131.15) CPU1.T39 ; v2(142.15,35.34) 142.15,36.06 C180.2 ; U8.3 v2(174.02,223.3) ; C308.2 54.9,200.82 55.28,200.44 v2(55.28,200.31) ; CPU1.U36 v4(175.25,130.23) ; U23.25 v2(230.8,26.45) ; CPU1.AP24 164.28,114.69 v4(164.31,114.69) 163.85,115.15 ; v2(235.43,23.65) 235.35,23.73 U23.18 ; CPU1.AM14 154.46,115.84 154.46,115.36 CPU1.AN14 CPU1.AP14 ; C373.2 30.81,5.54 30.13,5.54 ; v2(64.75,137.29) 65.06,137.6 65.06,138.08 ; C334.1 60.92,138.11 v2(61.09,138.28) 61.25,138.44 RJ1.3 ; U4.3 v2(182.4,226.6) ; U14.2 12.48,119.79 v2(12.35,119.92) ; C706.2 v2(166.02,217.46) ; CPU1.W35 v4(174.34,128.4) ; D3.8 27.62,51.09 v2(27.72,51.19) ; v2(235.36,138.72) 234.76,138.11 C756.2 ; U1.8 v2(209.96,223.17) ; CPU1.AA35 v4(173.43,125.66) ; CPU1.M40 v4(179.09,134.35) ; C198.1 v2(59.98,123.73) C199.1 ; U5.3 v2(185.71,226.6) ; C354.2 46.74,187.83 v2(47.75,187.83) ; v2(231.43,17.5) 230.8,18.12 U23.4 ; D17.8 v2(111.41,216.64) ; C48.2 54.48,194.63 v2(54.26,194.85) ; U24.2 162.16,219.62 v2(162,219.45) ; CPU1.U37 v4(176.17,130.23) ; C44.1 153.45,59.85 v2(153.07,60.23) ; C708.2 v2(164.53,223.14) ; CPU1.U35 v4(174.34,130.23) ; C668.2 36.74,120.66 37.27,121.19 v2(37.52,121.19) ; U2.8 v2(213.77,223.17) ; v2(41.94,8.85) 41.82,8.72 SPIROM2.4 ; D16.8 v2(115.22,217.33) ; U20.2 v2(25.31,58.83) ; U5.8 v2(185.71,229.14) ; CPU1.AN19 159.25,115.17 v4(158.81,115.61) 158.34,115.15 CPU1.AN18 ; CPU1.H1 v4(139.96,138.92) ; C120.2 v2(157,217.96) C121.2 ; C707.2 v2(167.22,223.12) ; CPU1.AT16 CPU1.AT15 ; U10.3 v2(177.96,219.97) ; v4(145.62,130.23) CPU1.V7 ; D2.8 v2(27.59,55.15) ; CPU1.AT14 CPU1.AT13 ; CPU1.AR16 CPU1.AR17 ; CPU1.W37 v4(176.17,128.4)
  TOP w0.406: v3(35.67,85.76) 36.55,85.76 PCH1.AV41 ; v3(35.67,86.44) 35.69,86.47 PCH1.AW40
  TOP w0.457: U25.3 12.3,135.71 v2(12.4,135.82) ; U16.3 142.85,210.87 v2(142.98,211) ; U13.3 11.91,126.52 v2(12.17,126.78) ; C239.2 28.73,78.21 29.26,77.68 v2(29.32,77.68) 29.35,77.68 29.88,78.21 C242.2 ; v2(153.7,212.88) C126.2
  TOP w0.508: R10.1 v2(199.88,150.15) ; v2(26.93,104.78) 26.63,105.08 C660.1 ; v2(160.05,38.18) 160.78,37.45 C157.2 ; R220.2 44.23,71.3 v2(43.97,71.05) ; C609.2 101.63,198.69 v2(101.2,198.25) 101.15,198.2 100.22,198.2 C605.2 ; v2(220.25,33.81) 221.14,34.7 C387.2 220.6,35.37 220.38,35.59 220.38,35.87 219.92,36.32 C391.2 C392.2 ; R204.1 33.18,77.34 33.18,78.67 ; QN47.S 111.54,6.13 v2(112.05,5.62) ; C389.2 203.37,36.07 204.38,36.07 204.38,36.2 ; v2(107.6,102.39) R600.1 ; C817.2 7.91,143.51 v2(8.03,143.39) ; R23.1 v2(199.55,131.48) R30.1 ; C271.2 72.8,91.98 v2(73.31,91.47) ; QN5.E 231.43,130.08 v2(230.82,130.08) ; R33.1 205.39,125.89 v2(205.52,125.76) ; R936.2 54.51,38.99 53.91,38.39 v2(53.91,37.78) ; v2(70.9,173.39) 71.37,172.91 C848.1 ; C287.2 26.07,82.58 25.24,83.41 v2(24.42,83.41) ; C174.2 157.42,58.61 v4(157.39,58.58) C170.2 ; v2(88.35,188.63) 87.97,188.25 C54.2 C50.2 ; v2(29.95,205.39) 30.87,205.39 32.04,206.56 ROM2.4 ; v2(66.07,227.49) 66.58,228 C463.1 ; v2(219.36,133) R987.1 C1.2 ; v2(34.04,133.56) 32.01,133.56 31.24,134.33 R265.2 ; QN51.E 141,21.24 v2(141,20.73) ; R856.2 C757.2 234.51,145.83 v2(235.24,145.83) 235.36,145.7 C766.1 ; C854.2 R995.2 v2(190.28,16.34) ; PCIE1X.A4 64.9,195.77 C303.2 ; R297.2 8.13,97.73 v2(8.54,97.31) ; QN11.S v2(219.36,205.14) ; v4(154.72,58.43) 155,58.71 C169.2 ; C300.2 v2(56.77,190.37) ; C774.1 R897.1 225.84,119.29 v2(225.71,119.41) ; 217.48,59.59 R123.2 ; 217.48,59.59 C183.2 ; 217.48,59.59 217.53,59.59 217.53,59.82 217.02,60.33 v4(217,60.33) ; v2(56.29,219.62) 56.29,220.5 C459.1 57.06,220.5 v2(57.06,219.62) ; v2(99.22,191.68) 98.97,191.93 QN62.E ; C684.1 89.24,7.02 C812.2 90.42,7.37 v2(91.6,7.37) ; v2(199.54,141.29) 199.55,141.3 199.55,141.51 199.17,141.89 R57.1 ; v2(235.65,148.59) 234.92,148.59 R939.2 ; v2(196.12,205.34) 196.12,204.53 194.7,203.11 QN74.S ; C450.1 19.16,206.66 v2(18.8,206.31) ; C549.2 v2(188.82,35.08) ; QN33.E 31.66,140.16 32.29,140.8 v2(33.97,140.8) ; v2(99.22,188.88) 99.73,188.88 QN67.E ; v2(71.03,227.49) 71.28,227.74 C669.1 ; C470.1 v2(60.48,232.32) ; C448.2 v2(45.88,217.84) C449.2 ; C474.1 C475.1 49.03,237.95 v2(48.93,238.06) ; QN4.E 234.96,130.99 v2(234.5,130.99) ; U32.4 101.25,98.58 102.14,99.47 ; C305.2 v2(66.2,190.71) ; R138.2 28.91,99.42 v2(28.61,99.73) 28.58,99.76 C254.2 ; R45.1 205.26,132.87 v2(205.39,133) ; v2(40.39,114.71) 40.42,114.69 R147.1 ; v2(81.31,219.11) 81.31,219.13 80.83,219.62 C483.1 ; C243.2 62.08,76.82 61.5,76.23 v2(61.5,75.72) ; C737.2 R815.2 219.62,144.34 219.59,144.34 219.37,144.56 v2(219.11,144.56) ; R67.1 v2(208.31,118.27) ; C522.2 v2(12.76,216.57) ; v4(179.23,143.29) 179.23,142.44 CPU1.D40 ; v2(58.71,166.2) 59.27,166.76 62.03,166.76 C340.2 ; C823.1 65.06,237.11 v2(65.06,237.78) ; C122.2 v2(152.31,217.96) ; v2(4.73,174.02) R508.2 v2(2.95,174.02) ; v2(8.67,138.95) 8.48,139.13 R938.2 C420.2 ; C307.2 66.23,192.41 v2(65.69,192.95) ; QN24.E v2(14.59,158.86) ; C497.1 75.95,99.57 v2(76.23,99.85) ; C736.2 R864.2 222.54,151.92 v2(222.28,152.18) 222.03,151.92 221.62,151.92 R863.2 ; C413.1 v2(233.33,224.44) ; 204.38,36.2 204.38,36.71 v2(204.68,37.01) ; 204.38,36.2 C388.2 ; C452.1 48.04,220.54 v2(48.04,220) ; v2(20.1,212.76) 19.97,212.88 C523.2 ; C726.2 v2(44.32,25.34) ; v2(225.84,58.33) 225.53,58.64 C186.2 C185.2 ; v4(179.3,110.93) 179.02,110.93 CPU1.AU40 ; C249.2 52.39,76.96 v2(51.59,77.76) C273.2 ; U17.2 v2(134.78,219.74) ; C670.2 60.99,208.06 v2(61.25,208.31) ; C499.2 103.97,216.49 105.06,217.58 v2(105.06,218.22) ; 30.13,5.54 C372.2 30.13,6.51 28.92,7.72 SPIROM1.4 27.77,7.72 27.59,7.9 v2(27.59,8.92) ; U3.2 222.54,219.49 v2(223.3,218.73) ; C666.1 8.8,203.74 v2(8.67,203.61) ; v2(209.84,11.59) 209.84,11.4 209.3,10.86 C434.1 ; v2(209.84,11.59) 209.84,11.94 C678.2 ; v2(209.84,11.59) 210.1,11.32 R366.1 ; C579.1 100.33,112.65 R608.1 101.25,113.06 100.87,113.44 v2(100.87,113.57) ; v2(225.58,129.45) 227.43,129.45 C6.1 ; v2(64.19,80.68) 63.31,80.68 62.8,81.19 C224.2 ; C176.2 v2(155.73,46.42) ; v2(226.45,107.06) C410.2 ; R296.2 C357.2 4,120.65 v2(4.22,120.43) ; v2(214.92,208.06) 214.92,207.42 214.66,207.17 R88.2 ; C189.2 170.63,221.36 v2(171.61,220.38) 171.48,220.25 C676.2 ; ROM1.4 v2(234.35,44.36) ; R66.1 v2(207.17,118.27) ; 35.08,62.95 v2(35.08,61.63) 35.34,61.37 R256.1 ; R621.1 R622.1 v2(86.04,48.71) ; v4(163.94,78.39) C130.2 ; C149.2 167.93,37.69 v2(167.93,38.26) ; v2(167.29,154.21) 166.53,154.21 C39.1 166.53,154.97 v2(167.29,154.97) ; v2(235.11,118.14) 235.62,117.63 QN77.E ; v2(153.7,47.78) 153.29,47.37 C153.2 ; v2(136.81,216.82) 137.19,217.2 C361.2 ; C858.2 48.17,38.16 48.01,38.01 R912.1 48.01,37.15 v2(48.51,36.64) ; QN44.S 8.01,56.04 v2(6.51,56.04) 6.12,56.04 R401.1 ; QN59.E 100.87,122.08 v2(102.9,122.08) ; C427.2 237.4,17.18 237.55,17.02 C428.2 v2(238.03,18.89) ; C396.2 199.33,12.89 198.91,12.48 C397.2 198.91,11.21 v2(198.79,11.08) ; v2(31.27,75.34) 31.47,75.34 C283.2 ; v2(145.12,59.95) 145.12,59.98 144.56,59.42 C177.2 ; C353.2 C304.2 24.36,199.9 v2(24.24,199.78) ; R778.1 v2(99.35,106.2) ; 102.14,104.55 102.14,99.47 ; R22.1 v2(199.55,129.95) R20.1 ; C582.2 92.49,103.79 93.25,103.03 v2(93.25,102.78) 93.25,102.52 92.49,101.76 C581.2 ; C704.2 174.66,201.96 175.55,202.85 v2(175.55,203.87) ; v2(4,100.11) C358.2 C359.2 ; v2(229.27,123.73) 229.14,123.86 R896.1 C773.1 ; C225.2 23.48,71.41 v2(23.62,71.27) ; C478.2 23.59,202.06 v2(23.45,202.2) 22.99,202.66 C451.1 ; C476.1 v2(42.45,225.84) ; C663.1 16.13,101.79 16.42,101.51 v2(16.42,101) ; C250.1 57.28,112.05 v2(58.33,112.05) 57.75,112.62 C253.2 ; R175.2 53.75,65.87 v2(53.58,65.69) 53.75,65.51 R209.2 ; v2(198.88,152.97) C820.2 ; v2(38.28,205.29) 38.25,205.32 38.25,206.94 C352.2 ; v2(66.71,88.81) 66.52,88.62 C286.2 66.52,87.48 66.02,86.98 66.02,86.63 C284.2 C285.2 ; C227.2 9.81,164.62 v2(9.94,164.75) 11.42,164.75 QN27.E 13.57,162.61 QN25.E ; v2(219.46,58.1) 219.46,58.83 219.74,59.11 C673.2 ; v2(165.92,38.26) 165.92,37.03 C168.2 ; v2(16.92,66.45) 17.05,66.33 C232.2 C231.2 ; v2(24.28,144.56) 24.67,144.56 25.25,145.14 28.91,145.14 QN31.E ; C844.2 v2(51.35,120.84) ; v2(4.8,69.06) 4.92,69.18 C238.1 ; C9.1 173.48,76.01 173.77,75.72 v2(174.02,75.72) ; 102.14,99.47 102.78,99.47 103.16,99.85 v2(103.16,100.36) ; C399.2 199.06,30.84 v2(198.15,30.84) ; CPU1.AW38 177.27,109.02 v4(177.32,109.02) ; C144.2 168.82,59.47 v4(168.94,59.6) ; U22.4 v2(118.78,186.09) ; C557.2 165.67,19.72 v2(165.67,20.07) 165.39,20.35 C553.2 ; v2(18.07,206.03) 18.07,205.49 R1001.1 ; 84.11,57.82 83.73,58.2 C585.2 ; 84.11,57.82 83.73,57.44 C586.2 ; 84.11,57.82 v2(84.49,57.82) ; C235.2 v2(24.89,68.16) C236.2 ; v2(232.32,118.14) 231.81,117.63 QN80.E ; CPU1.C3 142.42,143.5 v4(141.84,144.08) ; C809.1 C696.1 v2(185.58,5.87) ; C152.2 149.16,46.42 v2(149.77,47.02) ; U31.3 174.53,22.26 174.82,22.54 R574.2 175.98,22.54 v2(176.02,22.59) ; C310.2 66.02,187 v2(64.88,187) ; C133.2 139.94,78.16 v4(140.04,78.26) ; C723.2 127.37,4.3 v2(127.03,4.3) 126.7,4.3 C725.2 ; R117.2 146.84,57.94 v4(147.61,57.18) ; v4(140.11,143.67) 140.42,143.67 CPU1.D2 ; v2(27.97,111.16) 28.48,111.67 C196.2 ; R451.2 57.34,222.44 v2(57.56,222.66) ; QN37.E 122.46,35.34 v2(121.83,34.7) ; R32.1 199.5,135.54 v2(199.52,135.57) ; v2(198.28,213.14) C810.2 ; C282.2 23.85,80.33 C281.2 24.1,80.58 C484.2 24.1,82.39 v2(23.78,82.71) ; C472.1 v2(59.85,230.92) ; U26.2 v2(7.78,132.87) ; v2(225,141.13) 224.95,141.18 R871.2 ; C230.2 33.18,79.31 33.18,78.67 ; C408.2 v2(109.92,173.55) ; v4(212.58,57.74) 212.84,57.48 C182.2 ; C188.2 223.71,57.48 C187.2 v2(225.81,57.48) ; v4(141.79,109.04) 142.41,109.66 CPU1.AY3 CPU1.AW3 ; R137.2 28.73,88.68 v2(28.61,88.55) 28.58,88.58 27.94,88.58 R178.2 ; QN2.E 231.81,127.41 v2(231.68,127.54) ; v2(223.68,217.96) 223.81,217.84 224.22,217.84 R75.1 ; v2(5.49,66.83) 5.62,66.83 6,66.45 R254.1 6.89,66.68 6.89,67.66 C237.1 ; v2(162.72,154.97) 161.96,154.97 C41.1 161.96,154.21 v2(162.72,154.21) ; PCIE16X_1.B4 77.67,194.72 76.49,194.72 75.98,195.23 C55.2 ; R555.1 47.34,70.61 v2(47.69,70.26) R219.2 R226.2 R213.2 ; v2(63.91,99.98) 64.54,99.98 C654.1 ; R44.1 205.34,128.56 205.37,128.58 v2(205.39,128.58) ; D34.1 11.91,204.44 v2(11.91,203.49) ; C563.2 v2(151.09,11.75) C419.1 ; C797.2 C789.2 v2(58.83,33.05) ; C381.1 229.39,11.34 C382.1 230.28,9.62 v2(229.2,8.54) ; v2(67.22,223.81) 67.41,224 C462.1 ; C355.2 14.99,129.19 15.2,129.4 v2(15.2,129.98) ; v2(229.27,156.12) 228.89,156.5 C738.2 ; C398.2 v2(198.06,31.94) ; C461.1 C468.1 v2(54.64,238.54) ; R933.2 61.88,35.81 C796.2 61.63,33.05 61.37,33.05 v2(60.87,33.56) ; C505.2 28.99,208.69 v2(28.23,209.46) ; QN84.E QN83.E 191.98,20.23 v2(192.36,19.84) ; C369.2 v2(28.2,61.12) ; C477.1 v2(42.45,226.85) ; C778.1 47.09,35.47 v2(47.09,34.58) 47.34,34.32 R906.1 ; v2(83.37,64.27) 83.37,64.02 83.47,63.91 C591.2 83.85,63.25 83.88,63.28 C592.2 ; C546.2 v2(181.77,35.08) ; v2(127.82,26.27) 127.82,26.85 QN49.E ; v2(224.59,226.35) 224.82,226.12 R76.2 ; C404.1 61.63,112.9 v2(61.63,112.17) ; CPU1.C40 v4(178.46,143.29) ; C172.2 165.23,57.96 v4(165.26,58) 165.62,58.36 C166.2 ; v2(225.99,139.96) 226.12,140.09 C745.1 ; v2(73.84,87.79) 73.03,87.79 72.8,88.02 C258.2 ; C415.1 v2(236.13,224.44) ; C116.1 148.24,213.52 v2(149.13,214.41) ; v2(51.21,74.81) 51.79,74.23 C251.2 ; v2(205.39,131.45) 205.37,131.48 R47.1 ; C805.2 61.75,30.26 v2(61.7,30.31) ; C437.1 v2(67.09,222.54) ; v2(57.44,66.33) 57.69,66.07 R176.2 57.87,64.95 C821.2 ; QN10.S v2(223.04,206.15) ; C260.2 69.95,109.11 v2(69.76,109.3) 69.76,109.38 68.64,110.49 C401.1 ; R39.1 205.39,135.67 v2(205.52,135.54) ; R421.2 216.92,8.32 216.5,7.91 v2(216.5,7.46) ; v2(101.76,115.86) 101.12,115.86 QN56.S 98.84,115.86 97.44,115.86 QN58.S ; v2(224.87,150.78) R862.2 ; R21.1 v2(199.55,128.56) R18.1 ; v2(237.57,150.81) 237.97,150.41 C735.2 ; v2(40.82,60.61) 40.57,60.87 40.57,61.49 C679.2 ; v2(75.6,150.81) 75.5,150.91 R276.1 ; C409.2 v2(238.89,224.31) ; v2(183.93,208.69) 183.8,208.57 QN22.S ; C486.1 65.79,112.78 v2(65.18,112.17) ; v2(28.48,94.39) 28.61,94.27 R199.2 ; C147.2 v2(147.83,36.26) ; v2(121.25,26.97) C600.2 121.25,28.42 120.81,28.86 QN61.E ; C252.2 v2(39.15,117.58) ; R236.2 48.42,75.34 v2(49.28,74.48) 49.69,74.07 R139.2 ; C850.1 v2(69.88,160.08) ; v2(44.97,238.03) C469.1 ; C473.1 59.72,227.62 v2(59.85,227.49) ; C681.2 v2(28.61,95.66) ; C155.2 v2(156.46,36.26) ; v2(124.34,32.72) 124.49,32.57 C597.2 ; v2(44.61,28.16) C781.1 C782.1 ; R34.1 v2(205.39,127.03) ; C436.2 227.3,3.59 v2(228.19,2.7) ; v4(100.67,57.61) 100.39,57.34 C140.2 ; C489.1 59.37,75.22 v2(59.39,75.24) ; v2(10.32,152.56) 10.32,152.92 10.55,153.14 QN26.E ; v2(29.75,118.02) 29.15,117.41 R140.2 R141.2 29.15,114.94 C261.2 C263.2 ; C139.2 100.39,58.59 v4(100.03,58.22) ; C394.2 C689.2 212.74,35.1 213.39,34.45 v2(213.39,34.2) ; C700.2 v2(222.28,226.85) ; v2(50.45,220) 50.32,220.12 C471.1 ; QP3.C v2(12.61,41.41) ; v2(101.38,190.02) R654.1 ; C141.2 v2(165.67,46.42) ; QN78.E 235.62,121.57 v2(235.11,122.08) ; QN64.E 93.89,189.52 94.43,188.97 v2(95.79,188.97) ; C488.1 57.21,75.22 v2(57.28,75.29) ; v2(219.49,57.31) 219.74,57.06 C674.2 ; R132.1 70.64,96.22 v2(70.14,95.71) 69.5,96.35 R131.1 ; C255.2 45.75,118.32 v2(46.57,117.51) ; v2(203.49,144.69) QN1.S ; C697.2 55.54,68.26 v2(55.68,68.41) 55.83,68.26 C698.2 ; R299.2 C362.2 v2(143.26,225.33) ; C302.2 55.31,192.41 v2(54.26,193.45) ; C341.2 56.45,136.97 C333.2 ; R189.1 12.5,168.99 v2(11.46,168.99) ; R36.1 v2(199.55,132.87) R28.1 ; D22.A 104.81,117.63 v2(105.19,118.02) ; v2(67.95,18.78) 67.72,19.01 67.72,20.09 C779.1 69.29,20.19 C780.2 ; C835.2 80.93,49.94 81.44,49.44 v2(81.57,49.44) ; v2(156.5,212.88) C125.2 R111.1 ; v2(34.2,200.18) 34.86,200.18 35.34,200.66 C309.2 ; C675.2 170.59,219.13 v2(170.59,219.79) 170.54,219.74 169.39,219.74 C705.1 ; C167.2 v2(158.18,46.42) ; v2(189.77,223.17) 189.8,223.14 C107.2 ; v2(206.03,212.12) 205.8,212.34 C807.2 ; U6.2 v2(190.53,218.47) ; v2(55.15,181.77) 55.53,182.15 C306.2 ; C233.2 34.83,64.83 v2(34.83,65.56) 34.93,65.46 35.34,65.46 C234.2 ; v2(154.46,215.42) C119.2 ; C151.2 v2(152.15,36.26) ; v2(207.68,202.34) QN45.E 205.14,201.45 203.14,201.45 R418.1 ; R381.2 v2(115.6,185.45) ; C672.2 137.88,37.74 DIMM1.199 ; v2(31.78,186.98) 29.75,184.94 C299.2 ; C193.2 R159.1 28.61,109.25 v2(27.97,109.89) ; R198.1 36.58,78.75 v2(36.53,78.7) ; v2(142.02,4.86) 141.29,4.86 C828.2 ; R240.2 43.09,73.97 v2(43.09,74.71) R218.2 R203.2 ; R112.1 C123.2 v2(159.49,212.88) ; C346.1 48.29,182.02 v2(48.8,181.52) ; v2(73.72,191.32) 74.56,191.32 75.5,190.37 C52.2 ; C191.2 v2(42.58,114.71) R145.1 ; v2(31.88,117.91) 31.88,118.85 C195.2 ; C703.1 v2(191.96,223.3) ; 33.18,78.67 v2(33.2,78.67) ; v2(7.75,176.38) 8.12,176.75 C526.1 ; R109.2 146.97,213.77 147.61,214.41 v2(147.99,214.41) ; C849.1 v2(71.63,167.45) ; v2(103.54,11.34) 104.05,11.34 104.43,11.72 C685.1 ; v2(46.57,117.51) 46.13,117.08 C256.2 ; v2(46.57,117.51) 47.14,118.08 C259.2 ; CPU1.AV38 CPU1.AV39 178.44,109.68 v4(178.44,108.5) ; v4(158.01,78.23) 158.01,77.53 C134.2 ; R31.1 R26.1 ; R31.1 R29.1 ; R31.1 136.18,138.97 v2(135.95,139.2) ; v2(8.8,158.78) 8.9,158.89 C226.2 ; RJ9.3 v2(199.17,17.94) ; C158.2 v2(141.13,58.06) ; C455.1 v2(51.85,220) ; C608.2 v2(4.41,154.66) ; C814.2 v2(230.28,224.44) ; C390.2 198.44,25.59 C393.2 198.44,27.34 v2(198.58,27.49) ; C395.2 v2(206.79,37.01) ; v2(176.44,154.97) 175.67,154.97 C42.1 175.67,154.21 v2(176.44,154.21) ; C677.1 v2(6.86,162.24) ; C683.1 v2(91.47,17.84) ; R438.1 65.06,205.52 v2(64.68,205.14) ; R87.2 v2(216.98,214.06) ; R952.2 43.15,231.52 C467.1 C456.1 v2(42.45,232.44) ; R783.1 194.72,215.9 v2(194.72,215.42) ; C429.2 231.49,28.32 v2(231.49,28.23) 231.65,28.07 C422.2 ; C596.2 138.08,19.08 v2(137.19,19.08) 136.18,18.07 C593.2 ; C154.2 138.59,59.21 v2(138.72,59.34) 138.72,59.27 138.79,59.34 C164.2 ; R445.1 72.26,221.74 C442.1 v2(72.42,222.54) ; C598.1 v2(117.38,28.68) ; C356.2 8.26,122.72 v2(7.96,123.02) ; R146.1 v2(44.86,114.71) C192.2 ; v2(8.31,108.52) 8.92,109.13 R294.1 ; C400.2 198.69,22.35 199.17,21.88 RJ8.3 200.07,21.58 v2(200.21,21.72) ; C146.2 v2(154.31,36.26) ; R56.1 197.39,144.43 v2(196.88,144.94) ; C433.1 224.85,7.87 v2(225.2,7.53) 225.39,7.53 225.74,7.87 C432.1 ; v2(233.59,119.67) 233.08,119.67 QN79.E ; C118.2 v2(157.39,215.42) ; D36.P 104.76,214.23 v2(104.68,214.15) ; C457.1 C465.1 v2(60.48,233.59) ; RT2.2 165.26,182.88 v2(165.26,182.53) ; v2(46.51,143.29) 46.51,143.16 46.9,142.78 R285.2 R286.2 R284.2 ; C402.1 C487.1 67.34,111.67 v2(66.96,112.05) ; v4(177.85,144.2) 177.54,143.9 CPU1.B39 ; v2(145.83,45.5) 146.21,45.5 146.84,46.13 C173.2 ; R777.1 94.52,93.63 v2(94.9,94.01) ; QN65.E v2(3.79,152.61) ; v2(150.91,57.31) 150.91,56.45 C175.2 ; v2(150.91,57.31) 151.04,57.44 C179.2 ; v2(150.91,57.31) 149.64,57.31 C671.2 ; R794.2 187.77,208.92 v2(187.99,208.69) ; RJ10.3 RJ11.3 199.85,20.35 v2(199.93,20.28) ; C550.2 v2(195.83,34.2) ; C46.1 161.73,58.99 v4(163.08,58.99) ; C664.1 16.39,89.24 16.16,89.01 v2(16.16,88.53) ; C541.2 192.72,23.02 v2(193.07,23.02) ; v4(153.96,55.79) 153.96,55.91 154.49,56.45 C165.2 ; R1002.2 v2(234.67,217.01) ; SPI_DEBUG.9 15.55,9.68 v2(15.88,10.01) ; v2(67.05,205.14) 67.25,205.14 68.49,206.38 68.49,206.95 R434.2 ; C181.2 214.03,58.64 213.57,58.17 v4(213.39,58.17) ; U28.2 v2(99.73,213.14) ; C145.2 v2(144.3,35.53) ; v2(107.6,101.25) C576.2 ; v2(181.52,30.26) 180.75,30.26 C547.2 180.75,29.5 v2(181.52,29.5) ; v2(35.54,182.84) 35.21,182.5 C347.1 ; C466.1 v2(46.01,220) ; C690.1 21.28,70.01 v2(21.09,69.82) 20.57,69.3 C691.2 ; R657.1 99.07,185.22 C612.2 97.82,185.58 v2(97.7,185.45) ; U29.4 120.27,204.07 v2(121.65,204.07) ; v2(55.79,29.37) 55.79,28.99 56.01,28.77 R921.2 ; QN3.E 235.49,125.64 236,125.13 v2(236.51,125.13) ; C564.1 128.05,33.43 QN39.E v2(129.32,33.56) ; C808.2 v2(206.76,210.6) ; R861.2 222.66,140.27 v2(222.66,141.13) C760.2 ; C197.2 C194.2 28.99,107.98 v2(28.61,107.6) ; U18.2 v2(128.81,217.08) ; R935.1 47.34,33.05 v2(47.02,32.74) 47.02,31.66 C783.1 ; R49.2 209.94,117.58 v2(210.04,117.48) ; C578.1 97.51,105.89 v2(97.06,105.44) ; R562.1 R554.1 44.57,68.77 v2(44.28,68.49) ; v2(140.21,219.62) C360.2 R298.2 ; v2(241.21,16.42) 240.95,16.42 C425.2 ; v2(63.51,239.38) 63.27,239.14 C824.1 ; R460.1 v2(42.45,233.59) ; v4(167.42,59.6) C150.2 ; D9.1 12.76,44 v2(12.61,43.85) ; v2(104.05,198.2) 104.11,198.27 104.86,198.27 C611.2 ; R25.1 201.35,134.32 v2(202.01,134.32) ; v2(161.96,38.18) 161.96,37.15 C163.2 ; v2(164.17,22.18) R578.2 165.16,23.05 C548.2 ; v2(38.89,70.01) 38.8,70.1 C247.2 ; v2(227.74,144.89) 227.18,145.45 C746.1 ; C711.2 202.09,12.76 v2(202.09,12.05) ; v2(182.53,11.59) 182.53,12.26 182.4,12.38 C418.2 ; U15.2 v2(10.7,96.04) ; v2(230.41,2.7) 230.73,3.02 QN82.S ; v2(151.8,215.42) C117.2 ; v2(33.81,148.24) R267.1 ; C129.2 v2(149.54,223.17) ; C348.2 v2(47.75,170.16) ; v2(74.18,192.72) 74.49,192.41 C53.2 ; C148.2 v2(149.99,36.26) ; R238.2 22.64,75.72 v2(22.56,75.8) ; R505.1 15.37,208.44 v2(14.64,208.44) ; C128.2 v2(163.26,215.77) ; v2(141.76,45.63) 141.76,46.19 141.54,46.42 C171.2 ; R377.1 v2(232.47,97.92) ; R558.1 v2(45.24,73.69) ; R1002.1 v2(231.05,217.01) ; C445.1 59.65,209.33 v2(59.6,209.38) 59.54,209.33 C446.1 ; C426.2 231.43,17.02 v2(231.43,17.5) ; C724.2 v2(118.02,3.84) ; C520.2 15.53,211.87 v2(15.27,211.61) ; v2(117.76,141.26) 117.76,140.11 119.16,138.72 R51.1 R13.1 ; C464.1 v2(47.15,220) ; C132.2 v4(152.1,78.24) ; CPU1.B38 v4(176.63,144.15) ; R983.1 218.31,129.48 v2(218.6,129.19) ; v2(103.03,93.38) C573.1 102.08,94.46 101.76,94.77 R596.1 ; C776.2 87.22,25.24 v2(87.03,25.43) ; C838.1 v2(200.44,139.35) ; C262.2 48.61,79.28 v2(49.18,78.71) 49.69,79.22 C264.2 ; v2(171.99,154.21) 171.23,154.21 C40.1 171.23,154.97 v2(171.99,154.97) ; C301.2 25.89,190.55 v2(24.21,190.55) ; C492.1 v2(59.85,229.01) ; R144.1 43.72,114.66 v2(43.67,114.71) 43.72,114.76 C190.2 ; v2(73.84,142.17) 73.36,142.65 73.36,143.36 72.88,143.85 72.09,143.85 C339.2 ; R620.1 81.85,61.41 v2(82.15,61.7) ; C384.2 v2(205.65,37.01) ; C414.1 v2(234.73,224.44) ; v2(34.7,142.15) QN34.S ; R163.2 R164.2 63.86,78.14 64.24,77.76 v2(64.8,77.76) R179.2 ; v2(82.33,220.12) R512.2 83.6,220.12 v2(84.11,219.62) ; R118.2 v2(134.78,35.34) ; CPU1.C4 143.36,143.49 v4(143.81,143.94) CPU1.B4 ; R796.2 182.15,204.5 183.67,202.98 v2(185.78,202.98) ; v2(146.21,35.31) 146.21,34.58 145.7,34.07 145.19,34.58 v2(145.19,35.31) ; v2(232.19,112.81) 232.19,113.57 QN28.E ; v2(202.72,140.49) C680.2 ; R124.2 C184.2 217.51,56.04 217.28,55.81 v4(217,55.81) ; v2(23.4,210.54) QP7.C ; v2(13.37,123.43) 13.75,123.43 14.08,123.76 14.08,124.31 14.73,124.97 C405.2 ; v2(52.61,65.69) R201.2 ; R43.1 v2(205.39,129.95) ; v2(7.02,44.23) 7.65,44.23 8.67,43.21 C417.2 9.11,43.34 C855.2 ; v2(21.11,212.76) C524.2 ; QP5.C v2(23.65,214.41) ; C240.1 35.11,78.16 v2(35.12,78.16) ; R739.1 v2(199.6,127.03) 198.93,127.03 C2.2 ; C95.1 v2(228.76,224.44) ; C521.2 v2(14.51,211.49) ; v2(73.44,28.23) 74.65,28.23 C777.2 ; C126.2 R110.1 ; v2(2.95,36.23) 3.84,36.23 D40.1 ; C826.2 196.44,221.98 196.44,222.6 v2(195.87,223.17) 195.23,222.54 R784.2 ; C131.2 145.96,78.13 v4(146.1,78.28) ; RJ5.3 233.59,17.24 v2(234.22,17.88) ; FB17.2 240.19,26.19 239.81,25.81 v2(238.73,25.81) ; C435.2 v2(208.41,204.34) ; C423.2 235.94,28.1 v2(236.38,28.54) ; C498.1 v2(73.79,99.85) ; R17.1 v2(197.01,136.68) ; C851.1 v2(66.49,164.02) ; C43.1 143.21,57.18 143.59,57.56 143.87,57.56 v4(143.9,57.59) 144.46,57.03 C143.2 ; R248.2 23.31,74.58 v2(22.56,74.58) ; v2(204.38,11.16) 203.47,11.16 C386.2 204.15,11.94 R943.1 ; QN40.E v2(230.16,107.42) ; v2(8.03,155.48) 8.16,155.48 8.29,155.35 C229.2 ; C458.1 59.72,225.84 v2(59.85,225.71) ; R52.1 v2(199.55,134.27) ; R41.1 v2(205.39,134.27) ; C747.1 v2(231.52,140.11) ; v2(223.55,226.91) C825.2 ; C228.1 11.98,167.81 C682.2 9.89,167.81 9.89,166.96 v2(10.07,166.78) ; C406.2 v2(234.89,100.52) ; v2(158.17,57.18) C45.1 ; R383.1 v2(118.14,182.15) ; C156.2 v2(158.62,36.26) ; C490.1 v2(70.8,99.85) ; C686.1 105.65,7.09 C811.2 103.89,7.09 v2(102.78,8.21) ; C460.1 v2(55.63,223.14) ; QP4.C v2(27.34,214.41) ; C178.2 v2(131.64,37.08) ; C525.2 17.37,213.49 v2(17.37,212.76) ; C127.2 v2(160.97,215.77) ; C542.2 v2(107.47,32.54) ; U9.2 v2(152.81,220.58) ; v2(230.18,111.54) QN29.E ; C3.2 v2(199.52,137.83) ; C407.2 v2(115.09,191.55) ; C412.1 v2(231.93,224.44) ; C142.2 v2(145.67,36.26) ; v2(205.52,136.81) R37.1 ; D19.P v2(11.88,208.32) ; C453.1 v2(43.24,223.81)
  TOP w0.635: v2(12.45,39.4) 13.18,39.4 13.49,39.09 R300.2 C368.1
  BOTTOM w0.102: 155.62,113.93 155.62,113.52 ; 152.55,115.15 152.22,115.15
  BOTTOM w0.178: v2(218.98,134.65) 219.22,134.42 SJ1.59
  BOTTOM w0.203: SJ1.31 222.79,127.41 v2(223.04,127.16) ; SJ1.2 225.82,119.91 225.71,119.79 v2(225.71,119.41) ; SJ1.26 v2(225.6,125.91) ; v2(225.58,129.45) 225.58,129.32 225.99,128.91 SJ1.38 ; SJ1.7 222.75,121.41 223.04,121.7 v2(223.04,121.95) 223.04,122.78 222.92,122.91 SJ1.13 ; SJ1.25 222.9,125.91 223.04,125.76 v2(223.04,125.13) 223.04,124.66 222.79,124.41 SJ1.19 ; SJ1.20 228.97,124.41 229.27,124.11 v2(229.27,123.73) 229.27,123.35 228.83,122.91 SJ1.14 ; SJ1.8 225.75,121.41 v2(225.58,121.57) ; SJ1.32 v2(225.59,127.41) ; SJ1.37 218.83,128.91 218.6,129.14 v2(218.6,129.19) ; SJ1.49 219.94,131.91 219.36,132.49 v2(219.36,133) ; SJ1.1 v2(219.36,119.91) ; SJ1.50 229.58,131.91 v2(229.65,131.99)
  BOTTOM w0.254: v3(34.7,98.08) 33.69,97.06 SC35.1
  BOTTOM w0.305: v2(132.57,218.57) 132.57,218.05 132.87,217.74 SC48.2
  BOTTOM w0.356: SC49.2 157.29,221.14 155.92,221.14 v2(155.67,221.39)
  BOTTOM w0.381: v3(38.39,108.24) 38.77,107.86 SC26.2 ; SC34.2 41.89,92.01 v3(41.56,92.34) ; SC29.1 46.5,92.63 v3(46.62,92.74) ; SC27.1 43.29,92.82 v3(43.47,92.64) ; SC46.1 42.45,227.46 v2(42.45,226.85)
  BOTTOM w0.508: v2(24.8,94.39) 24.83,94.36 SC41.1 ; SC12.1 v2(149.1,133.03) ; v2(83.47,213.52) 85.15,213.52 SC6.2 ; SC16.1 v2(19.69,108.27) ; 203.2,25.28 SC50.1 ; 203.2,25.28 203.23,25.31 203.61,25.31 v2(204.07,24.85) ; 203.2,25.28 SC51.1 ; v2(84.49,211.23) 84.49,211.61 84.87,212 SC5.2 ; v2(91.47,213.01) SC10.1 ; SC2.2 v2(91.8,218.6) ; v3(48.7,101.66) 48.67,101.63 47.69,101.63 SC19.2 SC20.2 ; SR32.1 231.52,133.16 v2(231.93,132.75) 231.52,132.33 SR37.1 ; v2(28.48,94.39) 28.1,94.39 27.54,94.95 SC52.1 ; v3(52.61,100.08) 52.6,100.06 SC18.2 ; v2(88.04,210.19) 88.84,210.99 SC7.2 ; SQP1.C 14.83,15.15 15.27,14.7 v2(15.27,14.26) ; v2(88.04,213.52) 88.55,213.52 88.84,213.23 SC8.2 ; v4(170.68,119.26) 170.15,119.79 SR23.2 ; SR38.1 SC43.1 v2(216.44,132.62) ; SC15.1 v2(36.1,83.24) ; SC9.1 68.76,95.66 v2(68.78,95.69) ; v4(146.54,128.38) 146.97,128.81 SC14.2 ; SC22.2 50.5,102.66 v3(49.91,103.25) ; v2(28.25,91.68) 28.76,91.68 29.15,92.06 SC17.2 ; v2(91.73,217.08) SC1.2 ; v3(35.69,96.96) 36.04,96.62 SC32.2 ; SC38.1 74.74,212.09 v2(74.84,212) SC40.1 ; SC4.2 v2(88.04,216.72) ; v2(96.99,213.14) SU2.2 v2(99.73,213.14) ; SR19.2 150.15,125.13 ; SC36.1 v2(32.41,99.49) ; SC3.2 v2(88.04,215.32) ; SU1.2 v2(96.81,217.2) ; v2(40.39,114.71) 40.39,113.32 41.15,112.56 SC25.2 ; v2(19.08,218.98) SR15.2 v2(17.18,218.98) ; SR20.1 55.82,107.63 v3(55.28,108.17)
  vias: v2(11.84,20.53) v2(12.91,15.21) v2(23.91,39.66) v2(24.04,35.85) v2(25.69,22.38) v2(26.19,15.78) v2(31.02,79.92) v2(31.43,103.56) v2(31.53,57.18) v2(31.66,53.18) v2(32.01,14.71) v2(32.16,32.67) v2(32.67,59.85) v2(32.93,51.34) v2(33.31,39.66) v2(33.56,22.26) v2(34.83,54.85) v2(35.47,23.27) v2(35.59,19.21) v2(35.8,57.11) v2(36.23,109.13) v2(36.23,108.36) v2(42.58,54.39) v2(44.86,18.83) v2(44.86,18.07) v2(44.86,17.3) v2(44.86,16.54) v2(44.99,12.91) v2(44.99,12.15) v2(44.99,11.39) v2(44.99,10.62) v2(45.63,18.83) v2(45.63,18.07) v2(45.63,17.3) v2(45.63,16.54) v2(45.63,12.53) v2(45.63,11.77) v2(45.63,11.01) v2(45.63,10.24) v2(46.39,45.88) v2(47.15,45.88) v2(47.53,20.99) v2(54.13,110.94) v2(55.4,87.92) v2(57.56,109.7) v2(58.66,201.58) v2(58.83,222.03) v2(58.76,159.42) v2(58.76,158.53) v2(61.4,133.31) v2(64.4,161.45) v2(64.4,160.69) v2(64.93,106.71) v2(65.46,233.18) v2(65.69,106.71) v2(68.49,101.51) v2(69.25,101.51) v2(69.76,233.03) v2(71.08,233.03) v2(71.28,13.24) v2(73.84,138.49) v2(73.84,137.73) v2(73.84,136.94) v2(74.07,162.19) v2(74.58,137.85) v2(74.58,136.94) v2(74.84,72.3) v2(74.84,71.53) v2(75.34,54.13) v2(75.34,53.37) v2(75.34,52.61) v2(75.34,51.85) v2(75.34,51.04) v2(75.39,179) v2(75.6,72.3) v2(75.6,71.53) v2(75.72,44.86) v2(75.72,44.1) v2(75.72,43.34) v2(75.72,42.58) v2(75.72,41.82) v2(75.93,172.24) v2(75.98,53.75) v2(75.98,52.99) v2(75.98,52.23) v2(75.98,51.47) v2(76.36,72.3) v2(76.36,71.53) v2(76.36,44.48) v2(76.36,43.72) v2(76.36,42.96) v2(76.36,42.2) v2(76.49,182.66) v2(77.12,210.09) v2(77.88,210.09) v2(78.65,210.09) v2(79.41,210.09) v2(80.17,214.03) v2(82.23,66.86) v2(82.81,67.34) v2(83.47,214.28) v2(85.76,215.3) v2(88.42,196.5) v2(90.23,165.69) v2(90.2,163.48) v2(90.2,161.45) v2(90.2,157.51) v2(90.2,155.48) v2(90.2,153.58) v2(90.2,151.42) v2(90.2,145.45) v2(90.2,143.54) v2(90.2,141.51) v2(90.2,139.61) v2(90.2,137.45) v2(90.2,135.41) v2(90.2,133.64) v2(90.2,131.48) v2(90.2,129.57) v2(90.2,127.54) v2(90.2,125.38) v2(90.2,123.48) v2(90.2,121.44) v2(90.2,119.41) v2(90.33,181.64) v2(90.33,179.48) v2(90.33,177.58) v2(90.33,175.42) v2(90.33,173.64) v2(90.33,171.36) v2(90.33,169.58) v2(90.33,159.54) v2(90.33,117.63) v2(90.46,147.48) v2(91.09,194.6) v2(91.98,179.48) v2(91.98,175.42) v2(91.98,171.36) v2(91.98,167.29) v2(92.11,177.58) v2(92.23,173.64) v2(92.23,163.48) v2(92.23,161.45) v2(92.23,157.64) v2(92.23,155.48) v2(92.23,153.58) v2(92.23,151.29) v2(92.23,149.38) v2(92.23,145.45) v2(92.23,143.54) v2(92.23,141.51) v2(92.23,139.61) v2(92.23,137.45) v2(92.23,135.54) v2(92.23,133.64) v2(92.23,131.48) v2(92.23,129.57) v2(92.23,127.54) v2(92.23,125.38) v2(92.23,123.48) v2(92.23,121.44) v2(92.23,119.41) v2(92.23,117.83) v2(92.26,181.46) v2(92.26,169.58) v2(92.26,159.65) v2(93.25,197.39) v2(93.25,195.99) v2(94.14,76.36) v2(94.14,75.6) v2(94.14,74.84) v2(94.14,69.12) v2(94.14,68.36) v2(94.14,67.6) v2(94.9,54.39) v2(94.9,51.98) v2(94.9,49.56) v2(95.66,56.67) v2(96.17,56.04) v2(98.71,47.91) v2(98.71,46.77) v2(98.71,45.5) v2(99.85,33.31) v2(100.11,219.23) v2(101.73,203.82) v2(102.39,85.63) v2(102.6,203.82) v2(103.66,86.77) v2(103.92,39.53) v2(103.92,38.31) v2(104.05,24.54) v2(104.55,94.77) v2(104.55,93.38) v2(104.55,91.09) v2(104.55,88.93) v2(104.81,24.29) v2(105.84,128.25) v2(105.82,45.63) v2(105.95,38.39) v2(106.15,212.63) v2(106.2,43.29) v2(106.33,96.55) v2(106.97,39.94) v2(107.14,212.94) v2(107.53,97.7) v2(107.93,38.36) v2(107.96,41.84) v2(108.36,128.51) v2(108.64,102.5) v2(108.64,100.21) v2(108.95,39.91) v2(109.13,196.37) v2(109.51,105.06) v2(109.94,38.36) v2(110.08,148.66) v2(110.27,196.37) v2(110.9,107.47) v2(111.03,109.25) v2(111.28,123.73) v2(111.92,38.39) v2(111.97,39.53) v2(112.17,110.4) v2(112.43,150.93) v2(112.48,148.29) v2(112.63,198.15) v2(113.14,123.02) v2(113.82,112.3) v2(113.95,38.39) v2(114.33,15.91) v2(114.48,200.92) v2(114.54,149.71) v2(114.59,152.74) v2(114.56,125.91) v2(114.87,122.92) v2(114.94,40.01) v2(115.22,15.91) v2(115.73,114.21) v2(115.93,38.39) v2(116.24,15.91) v2(116.62,151.52) v2(116.57,127.18) v2(116.95,43.75) v2(116.95,41.38) v2(117,123.86) v2(117.13,15.91) v2(117.38,125.89) v2(117.38,115.73) v2(117.89,127.03) v2(117.94,39.58) v2(117.91,38.39) v2(117.99,15.91) v2(118.35,155.62) v2(118.45,151.52) v2(118.65,141.19) v2(118.78,210.22) v2(119.29,117.63) v2(119.54,210.22) v2(119.95,38.39) v2(120.43,154.29) v2(120.71,150.5) v2(120.81,119.03) v2(120.94,39.94) v2(121.19,188.63) v2(121.19,187.74) v2(121.19,186.85) v2(121.19,185.96) v2(121.93,38.39) v2(122.21,142.53) v2(122.28,154.01) v2(122.33,120.68) v2(122.59,15.91) v2(123.48,23.91) v2(123.48,15.91) v2(123.86,46.51) v2(123.86,45.63) v2(123.93,38.39) v2(124.04,156.37) v2(124.16,152.61) v2(124.24,15.91) v2(124.49,141.89) v2(124.49,23.91) v2(124.76,47.45) v2(124.95,39.96) v2(124.98,15.91) v2(125.23,216.62) v2(125.25,144.05) v2(125.64,231.81) v2(125.94,43.39) v2(125.94,41.87) v2(125.94,38.39) v2(126.22,155) v2(126.93,39.94) v2(127.1,145.69) v2(127.16,215.04) v2(127.6,143.54) v2(127.92,38.39) v2(128.05,243.11) v2(128.05,240.19) v2(128.05,237.01) v2(128.1,155.12) v2(129.57,145.32) v2(129.93,39.55) v2(129.95,38.39) v2(130.19,153.77) v2(130.97,217.71) v2(131.6,243.11) v2(131.6,240.19) v2(131.6,237.01) v2(131.6,233.97) v2(131.93,38.39) v2(132.75,182.28) v2(132.75,181.52) v2(132.75,180.75) v2(132.75,179.99) v2(132.75,174.53) v2(132.75,173.77) v2(132.75,173.01) v2(132.75,172.24) v2(132.75,171.48) v2(133,140.49) v2(132.95,39.96) v2(133.38,182.66) v2(133.38,181.9) v2(133.38,181.13) v2(133.38,180.37) v2(133.38,179.61) v2(133.38,174.15) v2(133.38,173.39) v2(133.38,172.63) v2(133.38,171.86) v2(133.89,43.09) v2(133.92,41.84) v2(133.92,38.39) v2(134.63,155.25) v2(134.91,45.24) v2(134.93,39.94) v2(135.16,243.11) v2(135.16,240.19) v2(135.16,237.01) v2(135.16,233.97) v2(135.95,43.31) v2(135.92,41.84) v2(135.92,38.39) v2(137.09,155.28) v2(137.65,155.86) v2(138.72,243.11) v2(138.72,240.19) v2(138.72,237.01) v2(139.99,243.11) v2(139.99,240.19) v2(139.99,237.01) v2(140.27,155.99) v2(140.98,156.52) v2(142.53,242.98) v2(142.53,238.92) v2(142.65,236.13) v2(143.54,157.39) v2(143.49,156.65) v2(143.92,38.26) v2(145.93,38.26) v2(145.96,236) v2(146.08,157.26) v2(146.97,28.86) v2(147.61,243.11) v2(147.61,28.48) v2(147.73,188.63) v2(147.91,38.26) v2(148.37,183.93) v2(148.62,188.69) v2(149.7,188.63) v2(149.77,239.05) v2(149.77,236) v2(149.92,38.26) v2(150.91,124.87) v2(151.8,243.11) v2(151.8,174.78) v2(151.8,174.02) v2(151.8,173.26) v2(151.8,172.5) v2(151.8,126.02) v2(151.8,124.87) v2(151.92,182.28) v2(151.92,181.52) v2(151.92,180.75) v2(151.92,179.99) v2(151.92,38.26) v2(152.05,123.98) v2(152.43,174.4) v2(152.43,173.64) v2(152.43,172.88) v2(152.43,172.12) v2(152.43,171.36) v2(152.56,182.66) v2(152.56,181.9) v2(152.56,181.13) v2(152.56,180.37) v2(152.56,179.61) v2(153.93,38.26) v2(154.46,7.91) v2(155.23,243.11) v2(155.94,38.26) v2(156.37,123.98) v2(157,132.11) v2(157,131.22) v2(157,130.08) v2(157,129.19) v2(157,128.18) v2(157,127.29) v2(157,126.14) v2(157,125.25) v2(157.94,38.26) v2(159.42,243.11) v2(160.69,123.98) v2(161.58,35.06) v2(161.58,34.32) v2(162.08,7.53) v2(162.34,35.06) v2(162.34,34.32) v2(163.1,35.06) v2(163.1,34.32) v2(163.61,243.11) v2(163.91,38.26) v2(163.99,35.06) v2(163.99,34.32) v2(165.01,123.98) v2(165.26,132.11) v2(165.26,131.22) v2(165.26,130.08) v2(165.26,129.19) v2(165.26,128.18) v2(165.26,127.29) v2(165.26,126.14) v2(165.26,125.25) v2(166.15,124.87) v2(166.53,185.71) v2(167.29,243.11) v2(167.67,185.71) v2(167.67,184.69) v2(168.31,124.87) v2(170.09,35.08) v2(170.09,34.32) v2(170.85,35.08) v2(170.97,243.11) v2(170.97,34.32) v2(171.74,175.67) v2(171.74,35.08) v2(171.74,34.32) v2(172.05,208.63) v2(172.24,174.91) v2(172.24,174.15) v2(172.24,173.39) v2(172.37,182.15) v2(172.37,181.39) v2(172.37,180.63) v2(172.37,179.86) v2(172.5,175.67) v2(172.5,35.08) v2(172.5,34.32) v2(173.01,174.61) v2(173.01,173.84) v2(173.01,173.08) v2(173.01,172.32) v2(173.13,183.93) v2(173.13,183.04) v2(173.13,182.15) v2(173.13,181.39) v2(173.13,180.63) v2(173.13,179.86) v2(173.79,207.86) v2(173.82,207.07) v2(175.04,243.11) v2(176.05,39.66) v2(176.44,208.24) v2(176.56,236.63) v2(177.78,208.24) v2(177.81,207.4) v2(177.96,39.66) v2(179.23,236.63) v2(180.5,232.82) v2(180.63,242.98) v2(180.63,236.89) v2(181.72,213.98) v2(182.02,39.66) v2(183.52,214.94) v2(183.93,39.66) v2(184.06,243.11) v2(184.06,237.01) v2(184.78,212.54) v2(185.05,210.5) v2(185.83,39.66) v2(187.23,17.69) v2(187.36,184.06) v2(187.48,243.11) v2(187.48,237.01) v2(187.89,39.53) v2(187.92,38.39) v2(188.12,184.06) v2(188.12,183.17) v2(188.88,184.06) v2(188.88,183.17) v2(188.93,41.41) v2(188.93,39.94) v2(189.01,47.78) v2(189.9,43.09) v2(190.02,38.41) v2(190.91,41.41) v2(190.91,39.91) v2(191.29,243.11) v2(191.29,237.01) v2(191.93,38.39) v2(193.94,39.55) v2(193.94,38.36) v2(194.6,243.11) v2(194.6,237.01) v2(194.9,206.61) v2(195.94,38.39) v2(196.93,39.94) v2(197.66,48.38) v2(197.95,41.87) v2(197.92,38.39) v2(198.15,243.11) v2(198.15,237.01) v2(198.81,222.94) v2(198.94,43.75) v2(198.91,39.91) v2(199.83,222.94) v2(199.93,41.84) v2(199.93,38.39) v2(200.57,243.11) v2(200.57,237.01) v2(201.91,38.39) v2(202.09,242.98) v2(202.34,236.13) v2(202.34,232.32) v2(202.9,39.94) v2(203.13,222.94) v2(203.94,38.39) v2(204.15,222.94) v2(205.95,38.39) v2(206.41,242.86) v2(206.41,236) v2(206.53,232.57) v2(206.94,39.89) v2(207.3,48.17) v2(207.93,43.36) v2(207.93,41.82) v2(207.93,38.39) v2(208.06,242.98) v2(208.06,236.76) v2(208.92,39.86) v2(209.4,212.5) v2(209.43,211.61) v2(209.91,38.39) v2(210.73,243.11) v2(210.73,239.3) v2(210.73,236) v2(211.92,39.53) v2(211.92,38.39) v2(213.34,212.22) v2(213.44,210.9) v2(214.03,38.39) v2(214.28,243.11) v2(214.28,239.3) v2(214.28,236) v2(214.92,39.94) v2(215.93,41.87) v2(215.96,38.39) v2(216.92,43.77) v2(216.9,39.91) v2(217.08,48.04) v2(217.33,243.11) v2(217.33,239.3) v2(217.33,236) v2(217.91,41.84) v2(217.94,38.39) v2(219.92,39.48) v2(220.02,38.39) v2(220.91,39.86) v2(221.01,243.11) v2(221.01,239.3) v2(221.01,236) v2(222.03,48.93) v2(222.03,48.04) v2(222.03,47.02) v2(222.03,46.01) v2(222.03,44.86) v2(222.03,41.82) v2(222.03,40.29) v2(223.43,51.21) v2(224.19,51.98) v2(224.44,243.11) v2(224.44,236.63) v2(224.95,52.74) v2(225.79,55.61) v2(226.47,237.27) v2(226.47,234.47) v2(226.47,231.68) v2(226.6,243.11) v2(226.73,175.29) v2(226.73,174.53) v2(226.73,173.77) v2(226.73,173.01) v2(226.73,172.24) v2(226.73,167.93) v2(226.73,167.16) v2(226.73,166.4) v2(226.73,165.64) v2(227.11,164.95) v2(227.49,174.53) v2(227.49,173.77) v2(227.49,173.01) v2(227.49,172.24) v2(227.49,167.93) v2(227.49,167.16) v2(227.49,166.4) v2(227.49,165.64) v2(228.76,237.27) v2(228.76,234.47) v2(228.76,231.68) v2(229.78,243.11) v2(229.78,240.95) v2(229.78,238.41) v2(233.84,192.06) v2(233.84,190.66) v2(233.84,189.26) v2(233.84,187.99) v2(233.97,243.11) v2(233.97,238.41) v2(235.24,189.26) v2(235.24,187.99) v2(236.51,189.26) v2(236.51,187.99) v2(237.4,243.11) v2(237.4,240.95) v2(237.4,238.41) v2(237.78,192.06) v2(237.78,190.66) v2(237.78,189.26) v2(237.78,187.99) v2(240.57,243.11) v2(241,232.44) v2(241.1,236.02) v2(241.05,226.04) v3(10.82,36.18) v3(10.82,33.48) v3(12.61,36.18) v3(12.61,33.48) v3(42.14,103.43) v3(43.09,100.24) v3(43.09,99.6) v3(43.09,98.97) v3(43.47,103.54) v3(43.47,102.9) v3(43.47,102.27) v3(44.1,92.74) v3(44.6,103.18) v3(44.58,91.88) v3(44.94,92.78) v3(45.37,106.17) v3(45.64,103.18) v3(45.63,92.62) v3(45.8,100.03) v3(47.64,103.18) v3(48.2,232.66) v3(48.2,229.27) v3(48.2,225.87) v3(48.33,96) v3(48.33,95.19) v3(51.19,91.73) v3(51.59,232.66) v3(51.59,225.87) v3(51.8,93.56) v3(52.02,34.66) v3(52.02,32.46) v3(52.81,92.36) v3(53.09,87.43) v3(53.98,98.86) v3(54.02,88.86) v3(54.21,34.66) v3(54.21,32.46) v3(54.71,96.81) v3(54.99,232.66) v3(54.99,229.27) v3(54.99,225.87) v3(55.48,103.17) v3(55.51,98.05) v3(55.48,95.59) v3(55.47,93.09) v3(70.67,216.26) v3(70.67,213.77) v3(73.16,216.26) v3(73.16,213.77) v3(76.54,62.87) v3(78.85,62.67) v3(79.71,64.65) v3(121.44,208.01) v3(121.44,205.32) v3(123.23,208.01) v3(123.23,205.32) v3(146.58,183.73) v3(227.01,152.02) v3(227.01,150.53) v3(227.01,149.03) v3(228.51,152.02) v3(228.51,149.03) v3(230,152.02) v3(230,150.53) v3(230,149.03) v4(107.63,48.06) v4(110.67,46.64) v4(112.5,46.84) v4(114.94,46.41) v4(118.71,46.84) v4(120.68,46.44) v4(122.74,46.69) v4(126.4,46.95) v4(127.97,45.78) v4(131.12,47.35) v4(132.85,46.74) v4(133.2,47.48) v4(136.18,47.07) v4(138.49,46.49) v4(139.99,126.14) v4(146.54,132.98) v4(147.45,133.89) v4(148.37,134.8) v4(149.28,134.8) v4(150.2,134.8) v4(152.02,136.63) v4(152.94,136.63) v4(153.85,136.63) v4(154.77,136.63) v4(155.68,137.55) v4(155.68,136.63) v4(156.6,137.55) v4(157.51,138.46) v4(158.42,139.38) v4(159.34,141.21) v4(159.34,140.29) v4(160.25,145.78) v4(160.25,144.86) v4(160.25,143.95) v4(160.25,143.03) v4(160.25,142.12) v4(160.25,141.21) v4(169.93,104.68) v4(171.6,130.23) v4(171.6,129.32) v4(171.6,128.4) v4(171.6,127.49) v4(171.6,126.58) v4(172.51,133.89) v4(172.51,129.32) v4(173.43,134.8) v4(173.43,133.89) v4(173.43,132.06) v4(173.43,129.32) v4(174.34,143.03) v4(174.34,142.12) v4(174.34,141.21) v4(174.34,140.29) v4(174.34,139.38) v4(174.34,138.46) v4(174.34,137.55) v4(174.34,135.72) v4(174.34,134.8) v4(174.36,136.65) v4(175.25,142.12) v4(175.25,139.38) v4(176.17,137.55) v4(184.18,128.43) v4(184.49,47.07) v4(185.33,128.43) v4(186.72,46.59) v4(186.85,128.43) v4(188.5,128.43) v4(190.15,128.43) v4(191.24,47.3) v4(191.55,128.43) v4(192.72,46.57) v4(193.07,128.43) v4(194.34,128.3) v4(195.44,127.14) v4(196.34,126.25) v4(196.98,46.31) v4(197.24,125.35) v4(198.14,124.45) v4(199.04,123.55) v4(199.93,122.65) v4(200.13,47.23) v4(200.83,121.75) v4(201.73,120.85) v4(202.27,47.3) v4(202.27,46.59) v4(202.63,119.95) v4(203.53,119.05) v4(204.15,45.4) v4(204.43,118.15) v4(205.33,117.25) v4(206.23,116.35) v4(207.13,115.46) v4(208.03,114.56) v4(208.39,47.17) v4(208.93,113.66) v4(209.83,112.76) v4(210.14,46.72) v4(210.72,111.86) v4(211.62,110.96) v4(212.22,47.1) v4(212.52,110.06) v4(213.42,109.16) v4(213.65,108.11) v4(213.65,106.71) v4(213.65,105.32) v4(213.65,103.79) v4(213.65,102.39) v4(213.65,100.87) v4(213.65,99.47) v4(214.66,98.2) v4(214.74,46.49) v4(215.81,97.06) v4(215.93,95.28) v4(215.93,93.63) v4(216.69,92.62) v4(217.71,91.6) v4(218.17,47.28) v4(218.6,90.58) v4(218.6,88.93) v4(218.6,87.28) v4(218.6,85.76) v4(218.6,83.98) v4(220.2,46.62) v4(220.5,82.2) v4(221.27,81.44) v4(222.16,80.55)
