# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_AMT_L_C: length 9.7
  TOP w0.102: v1(11.92,151.9) 13.57,153.55 QN26.C
  TOP w0.254: QN26.C QN24.B 12.86,156.83 12.15,156.12 10.29,156.12 R185.1
SLP_LAN_L: length 314.9
  TOP w0.102: v2(75.7,124.19) 74.7,124.19 66.93,131.96 59.31,131.96 58.65,132.62 50.32,132.62 47.02,135.92 46.62,136.32 46.62,137.38 45.62,138.38 44.75,138.38 43.62,139.51 43.62,140.98 43.34,141.26 43.34,143.29 42.55,144.08 42.23,144.08 41.26,145.05 41.26,150.09 40.92,150.42 40.92,152.05 40.17,152.81 39.04,152.81 37.77,154.08 35.09,154.08 34.67,154.49 31.12,154.49 v1(31.02,154.59) 30.92,154.49 23.37,154.49 22.38,153.5 18.94,153.5 17.97,152.53 17.18,152.53 16.03,151.39 16.03,150.53 11.08,145.57 2.83,145.57 v2(2.06,146.34) ; v2(98.08,149.51) 98.08,151.16 98.71,151.8 98.71,182.56 R657.2 R653.2 ; v2(3.72,63.41) 4.4,64.09 6.05,64.09 7.55,65.59 8.26,65.59 9.77,67.1 14.82,67.1 16.78,69.06 18.54,69.06 20.16,70.68 22.51,70.68 22.68,70.52 24.12,70.52 24.29,70.68 24.9,70.68 26.68,72.46 26.68,79.63 28.82,81.77 31.41,81.77 31.93,82.29 31.93,83.47 33.56,85.1 33.56,86.56 35.38,88.39 37.06,88.39 37.36,88.69 PCH1.AU36 ; v2(91.47,148.88) 91.35,149 89.59,149 89.34,149.26 86.44,149.26 85.71,148.53 84.4,148.53 83.36,149.56 80,149.56 79.01,148.57 78.02,148.57 77.55,148.11 77.55,129.66 v2(75.7,127.8)
  BOTTOM w0.102: v2(3.72,63.41) 3.46,63.41 1.24,65.62 1.24,142.62 2.42,143.8 2.42,145.98 v2(2.06,146.34) ; v2(91.47,148.88) 91.73,148.62 97.19,148.62 v2(98.08,149.51) ; v2(75.7,124.19) 75.22,124.67 75.22,127.32 v2(75.7,127.8)
SLP_S3_L: length 1055.6
  TOP w0.102: v2(230.28,54.64) 229.8,55.13 229.8,60.31 224.97,65.14 224.97,70.08 224.24,72.37 224.24,76.92 225.03,77.71 225.03,88.93 227.62,91.52 v2(227.62,93.25) ; v2(107.6,173.51) 109.13,171.99 118.7,171.99 129.57,182.86 129.57,189.77 137.8,198 202.32,198 v2(203.23,198.91) ; v2(99.19,123.95) R609.2 99.31,122.84 103.09,122.84 v2(103.73,122.21) ; v2(236,135.92) 237.59,137.51 237.59,138.91 v2(238.03,139.35) ; R598.2 106.68,105.24 108.72,107.28 108.72,109.99 110.62,111.89 110.62,118.68 v2(105.38,123.92) 102.39,126.91 v2(102.39,177.63) 102.39,182.53 108.11,188.25 v2(108.11,189.01) 108.11,192 115.32,199.21 v2(115.32,199.57) 115.63,199.57 118.02,201.96 118.02,203.13 115.91,205.24 115.91,207.6 116.87,208.57 U29.1 ; v2(9.94,136.05) 10.19,136.3 12.73,136.3 12.95,136.52 U25.5 13.28,137.36 16.54,140.62 18.19,140.62 19.13,141.56 22.46,141.56 23.48,140.55 25.81,140.55 28.07,138.28 33.26,138.28 34.07,137.47 34.07,136.27 R268.1 ; v2(78.75,88.12) 79.18,88.55 82,88.55 84.64,91.19 84.64,110.55 87.79,113.7 91.22,113.7 v2(91.35,113.57) ; U19.1 5.62,36.74 v2(5.37,36.99) 4.86,37.5 3.46,37.5 v2(2.95,36.99) ; v2(87.79,32.16) 87.41,32.54 87.41,40.14 86.98,40.57 81.97,40.57 v2(81.16,39.76) ; v2(8.92,107.6) 9.26,107.94 U12.5 ; v2(8.26,129.93) 8.85,129.93 9.66,129.12 12.17,129.12 12.56,128.72 U13.5 ; v2(236.63,124.11) 237.21,124.11 238.08,124.98 238.08,125.96 R61.1 ; U16.5 143.5,211.79 143.35,211.64 140.82,211.64 140.32,211.13 140.32,205.98 139.61,205.26 v2(135.82,205.26) ; v2(86.39,24.42) 86.39,21.88 84.23,19.72 84.23,16.54 82.71,15.02 76.74,15.02 71.69,9.96 71.69,5.65 70.52,4.48 58.48,4.48 v2(58.22,4.73) ; U21.71 206.98,18.18 207.55,18.75 207.55,25.31 v2(206.92,25.94) ; C677.2 5.91,162.08 ME_TEST.2 ; v2(99.22,187.48) 99.14,187.41 95.58,187.41 R644.2 ; PCH1.AK40 41.43,86.59 40.86,86.01 40.86,85.51 37.29,81.94 37.29,79.23 37.5,79.02 37.5,75.07 37.29,74.86 37.29,74.79 37.29,74.78 37.29,67.67 37.09,67.47 35.19,67.47 31.85,64.13 22.83,64.13 22.64,64.32 16.56,64.32 15.59,63.35 13.07,63.35 12.34,62.62 9.53,62.62 v2(7.91,60.99)
  BOTTOM w0.102: v2(203.23,198.91) 205.01,200.69 v1(207.3,200.69) 208.07,200.69 210.23,202.85 236.89,202.85 241.21,198.53 241.21,142.53 v2(238.03,139.35) ; v2(135.82,205.26) 128.45,197.9 117.13,197.9 115.45,199.57 v2(115.32,199.57) ; v2(58.22,4.73) 57.67,5.29 54.65,5.29 51.97,2.62 4.31,2.62 2.62,4.31 2.62,27.81 5.14,30.33 5.14,36.76 v2(5.37,36.99) ; v2(105.38,123.92) 105.38,123.86 v2(103.73,122.21) ; v2(86.39,24.42) 86.88,23.93 87.56,23.93 89.57,25.94 89.57,29.75 88.17,31.15 88.17,31.78 v2(87.79,32.16) ; v2(108.11,189.01) 108.11,188.09 107.5,187.48 v2(99.22,187.48) ; v2(2.95,36.99) 2.47,37.47 2.47,55 7.91,60.43 v2(7.91,60.99) 7.91,62.77 7.35,63.33 7.35,69.96 8.14,70.74 8.14,71.4 5.13,74.4 4.45,74.4 3.74,75.11 3.74,83.7 6.23,86.19 6.23,96.38 8.92,99.07 v2(8.92,107.6) 6.89,107.6 6.23,108.26 6.23,122.38 8.52,124.67 8.52,125.43 8.26,125.69 v2(8.26,129.93) 8.26,131.35 9.3,132.39 9.3,135.41 v2(9.94,136.05) 9.94,138.88 9.02,139.79 9.02,145.17 8.06,146.13 8.06,150.78 6.92,151.92 6.92,152.84 9.01,154.93 9.28,155.2 9.28,158.98 7.24,161.02 ME_TEST.2 ; v2(91.35,113.57) 98.2,120.43 98.2,123.35 98.81,123.95 v2(99.19,123.95) ; v2(107.6,173.51) 103.49,177.63 v2(102.39,177.63) ; v2(81.16,39.76) 79.94,40.98 79.94,44.33 78.65,45.63 78.65,60.87 78.02,61.49 78.02,65.53 78.92,66.43 78.92,72.65 74.99,76.59 74.99,81.85 77.83,84.69 77.83,87.21 v2(78.75,88.12) ; v2(236,135.92) 236,134.78 236.84,133.94 236.84,126.83 237.01,126.65 237.01,124.94 236.91,124.84 236.91,124.39 v2(236.63,124.11) 236.63,123.6 237.14,123.1 237.14,116.11 227.11,106.08 227.11,93.76 v2(227.62,93.25) ; v2(230.28,54.64) 231.27,53.65 231.27,51.26 229.97,49.96 229.97,41 228.89,39.92 228.89,36.36 226.17,33.64 225.72,33.64 223.01,30.92 217.84,30.92 216.04,29.12 209.66,29.12 206.92,26.37 v2(206.92,25.94)
SLP_S3_L_QB_1: length 5.5
  TOP w0.102: QN3.B 234.27,127.34 235.95,127.34 236.18,127.11 236.18,127.01 236.89,126.3 R61.2 237.32,125.77 v1(237.32,125.23)
SLP_S4_L: length 439.3
  TOP w0.102: R400.2 6.19,58.63 7.42,58.63 7.42,58.75 7.53,58.86 8.78,58.86 10.91,60.99 13.3,60.99 v2(13.49,61.18) ; v2(64.09,13.98) 65.26,13.98 67.62,16.34 78.02,16.34 78.63,16.95 80.02,16.95 v2(80.35,16.62) ; v2(208.29,19.46) 209.98,17.77 U21.77 ; v2(4.3,85.83) 3.74,85.27 3.74,72.49 4.49,71.74 5.57,71.74 6.45,72.61 8.94,72.61 9.56,71.99 12.73,71.99 12.94,71.79 v2(13.49,71.79) 13.6,71.89 16.42,71.89 16.58,71.72 17.94,71.72 21.28,75.06 25.53,75.06 26.22,75.75 26.22,79.82 28.63,82.23 31.05,82.23 31.49,82.67 31.49,83.62 33.05,85.18 33.05,86.63 35.23,88.81 36.48,88.81 36.67,89 37.08,89 37.12,88.96 37.44,88.96 37.75,89.28 PCH1.AT35
  BOTTOM w0.102: v2(80.35,16.62) 80.54,16.43 82.09,16.43 83.82,18.17 87.83,18.17 90.3,20.63 91.64,20.63 92.1,21.09 103.33,21.09 106.58,17.84 143.24,17.84 144.86,16.21 146.54,16.21 v1(146.59,16.16) 147.2,15.55 154.62,15.55 155.76,16.7 167.46,16.7 168.24,17.48 179.12,17.48 180.51,18.88 187.54,18.88 188.81,17.61 190.34,17.61 191.46,16.49 199.97,16.49 202.79,19.31 205.23,19.31 205.49,19.06 207.88,19.06 v2(208.29,19.46) ; ME_TEST.4 6.1,159.34 4.07,159.34 3.56,158.84 3.56,158.12 4.37,157.31 5,157.31 5.8,156.51 5.8,151.75 7.28,150.26 7.28,145.04 7.5,144.82 7.5,134.75 6.76,134.02 6.76,131.6 3.1,127.94 3.1,87.03 v2(4.3,85.83) ; v2(64.09,13.98) 61.52,13.98 60.45,15.05 57.81,17.69 49.69,17.69 48.06,16.06 48.06,8.9 45.9,6.74 18.37,6.74 17.49,7.62 11.43,7.62 10.22,8.83 10.22,15.38 11.07,16.24 11.21,16.37 11.21,21.26 11.51,21.56 11.51,26.46 11.21,26.76 11.21,32.14 11.84,32.77 11.84,36.61 11.72,36.74 11.72,44.75 12.53,45.57 12.53,57.23 13.49,58.2 v2(13.49,61.18) 13.49,62.58 14.57,63.66 14.57,67.28 14.96,67.67 14.96,69.31 13.49,70.77 v2(13.49,71.79)
SLP_S4_L_R: length 3.9
  TOP w0.102: v1(10.09,59.37) 8.9,58.17 QN44.G
  TOP w0.254: QN44.G R400.1
SLP_S4_L_R_D: length 16.5
  TOP w0.102: QN42.E 15.4,55.3 15.4,58.2 QN41.E 13.16,60.43 v1(11.78,60.43) 11.78,59.56 10.4,58.17 QN44.D 10.14,56.9 R401.2
SLPSUS_L: length 254.7
  TOP w0.102: v2(119.79,35.08) 119.86,35.08 120.78,34.16 120.78,32.93 120.45,32.6 119.08,32.6 118.27,31.78 116.97,31.78 R630.2 115.73,32 115.73,30.86 R627.1 ; v2(215.53,30.32) 216.38,30.32 217.2,31.15 219.74,31.15 219.98,31.39 U21.6 ; v2(88.04,45.75) 81.15,45.75 78.65,48.26 78.65,56.99 76.57,59.06 72.39,59.06 71.57,59.87 66.09,59.87 65.5,59.29 52.79,59.29 49.75,56.25 43.15,56.25 42.78,56.63 42.55,56.85 41.23,56.85 38.11,59.97 38.11,67.55 37.75,67.9 37.75,74.67 37.95,74.88 37.95,79.21 37.75,79.41 37.75,81.83 41.7,85.77 41.7,86.77 41.74,86.81 41.74,87.37 PCH1.AK38
  BOTTOM w0.102: v2(88.04,45.75) 88.04,45.5 89.57,43.97 90.88,43.97 93.63,41.23 93.63,38.77 97.64,34.75 100.16,34.75 101,33.92 106.57,33.92 108.14,35.49 119.39,35.49 v2(119.79,35.08) 120.17,35.47 125.19,35.47 128.47,32.19 128.47,31.17 131.25,28.38 140.67,28.38 142.53,26.52 149.72,26.52 152.95,23.3 177.61,23.3 178.27,23.96 196.53,23.96 199.55,26.98 199.55,28.67 200.03,29.14 v1(201.28,29.14) 202.38,30.25 215.45,30.25 v2(215.53,30.32)
SLS3_B1: length 10.1
  TOP w0.102: v1(228.35,126.52) QN2.B 229.78,127.54 230.36,128.12 236,128.12 R60.2
SLS3_B2: length 3.9
  TOP w0.102: R63.2 236.89,130.21 236.46,129.78 234.6,129.78 v2(234.47,129.9) 234.02,129.9 QN4.B
SLS3_B3: length 11
  TOP w0.102: R65.2 236.79,131.22 235.9,131.22 235.52,131.6 230.92,131.6 QN5.B 229.47,130.46 229.05,130.88 227.15,130.88 v1(226.88,130.61)
SLS3_BF: length 7.4
  TOP w0.102: R59.1 234.73,129.06 QN3.C ; R59.1 236.92,128.27 v1(236.99,128.2) 237.82,127.37 R60.1 ; R59.1 237.87,130.02 R63.1 R65.1
SLS3_C2: length 4.1
  TOP w0.102: QN4.C 234.6,132.62 236.79,132.62 R62.1 236.92,133.48 v1(236.53,133.87)
SLS3_C3: length 2.9
  TOP w0.102: QN5.C 229.87,133.67 R64.1 229.9,134.12 v1(230.97,134.12)
SMBALERT_L: length 328.7
  TOP w0.102: v2(76.69,88.09) 77.4,88.81 81.06,88.81 82.46,90.2 82.46,107.74 78.3,111.89 78.3,114.35 77.5,115.15 77.5,124.37 76,125.86 75.42,125.86 74.94,126.35 74.94,129.01 76.87,130.94 76.87,149.63 77.49,150.25 77.49,167.53 76.13,168.89 76.13,169.65 76.84,170.36 76.84,173.92 71.05,179.71 68.07,179.71 65.13,182.66 64.27,182.66 63.25,183.67 59.77,183.67 58.67,184.78 57.6,184.78 56.93,185.45 54.13,185.45 53.02,186.57 53.02,189.68 52.41,190.29 50.76,190.29 47.47,193.58 v2(46.97,193.58) ; RLAN.22 52.84,235.34 v1(53.12,235.62) 53.63,236.13 R454.2 54.13,237.3 54.13,238.76 R953.2 53.21,239.68 43.9,239.68 43.16,238.94 43.16,238.42 42.42,237.67 41.21,237.67 v2(40.93,237.4) ; v2(35.21,216.95) 36.84,215.32 36.84,213.09 v2(36.58,212.83) ; v2(21.37,200.58) 20.28,199.49 17.75,199.49 16.21,197.95 16.21,195.41 16.9,194.72 18.32,194.72 18.86,195.27 19.82,195.27 21.35,193.74 22.4,193.74 23.39,194.72 30.03,194.72 31.55,193.2 33.31,193.2 33.94,193.83 v2(35.47,193.83) ; v2(64.74,60.36) 64.41,60.03 52.8,60.03 49.48,56.71 43.34,56.71 43.1,56.95 42.74,57.31 41.42,57.31 38.72,60.01 38.72,65.97 40.14,67.39 40.14,70.38 C247.1 R232.1
  BOTTOM w0.102: v2(21.37,200.58) 21.37,203.64 25.84,208.11 29.3,208.11 32.53,211.34 34.98,211.34 36.48,212.83 v2(36.58,212.83) ; v2(76.69,88.09) 76.69,84.69 74.3,82.3 74.3,76.28 76.99,73.59 76.99,70.59 70.67,64.27 68.91,64.27 64.99,60.36 v2(64.74,60.36) ; v2(35.47,193.83) 36.58,192.72 37.67,192.72 38.94,193.99 40.26,193.99 41.66,195.38 43.14,195.38 44.46,194.06 46.49,194.06 v2(46.97,193.58) ; v2(40.93,237.4) 40.67,237.14 40.67,220.86 36.76,216.95 v2(35.21,216.95)
SMBALERT_STBY_R: length 22.6
  TOP w0.102: v2(38.51,80.55) 38.89,80.55 39.15,80.3 39.15,79.03 38.64,78.52 38.64,74.43 v1(38.84,74.23) 38.93,74.14 38.93,73.18 R423.2 R232.2 ; v3(42.15,91.14) 42.52,91.52 PCH1.AG31
  BOTTOM w0.102: v3(42.15,91.14) 42.15,90.93 41.89,90.68 41.89,89.71 41.64,89.46 41.64,89.17 41.21,88.74 41.21,86.68 40.82,86.3 40.82,84.86 40.01,84.05 40.01,81.85 38.71,80.55 v2(38.51,80.55)
SMBCLK_MAIN: length 391.3
  TOP w0.102: R304.1 111.54,36.48 QN36.S 113.95,34.07 113.95,33.05 113.7,32.8 112.54,32.8 111.95,32.21 111,32.21 109.53,30.74 109.53,28.72 106.83,26.03 106.83,20.01 105.75,18.93 105.75,8.72 107.61,6.85 107.61,4.59 108.11,4.1 109.51,4.1 110.19,4.78 111.61,4.78 111.72,4.68 111.72,4.68 v2(112.3,4.1) ; R304.1 110.11,37.12 103.16,37.12 102.52,36.48 101.57,36.48 99.85,38.19 99.85,39.2 99.25,39.81 99.25,41.34 99.71,41.79 99.71,43.85 99.93,44.08 DIMM1.118 99.93,45.19 99.65,45.47 99.65,50.17 99.24,50.58 99.24,51.39 99.62,51.77 99.62,53.82 99.93,54.14 DIMM3.118 99.35,55.41 99.35,59.98 99.62,60.25 99.62,62.12 99.25,62.49 99.25,63.94 99.75,64.44 99.75,66.15 99.93,66.34 DIMM2.118 99.93,67.36 99.58,67.72 99.01,67.72 98.02,68.71 98.02,69.57 99.19,70.75 99.19,71.53 99.93,72.27 DIMM4.118 ; R304.1 110.74,36.29 R303.1 ; v2(229.01,5.18) 228.51,5.68 227.87,5.68 226.92,6.64 226.92,8.12 226.05,8.99 R417.1
  BOTTOM w0.102: v2(112.3,4.1) 114.64,1.75 221.6,1.75 223.11,3.27 225,3.27 226.35,4.62 228.45,4.62 v2(229.01,5.18) 229.48,5.65 229.74,5.65 230.78,6.69 230.78,9.04 240.28,18.54 240.28,25.58 242.3,27.6 242.3,48.17 241.89,48.57 241.89,49.81 242.3,50.21 242.3,67.81 238.7,71.41 235.93,71.41 231.12,76.21 231.12,86.26 228.38,89 228.38,91.57 226.73,93.23 226.73,106.08 236.58,115.93 236.58,122.85 236,123.43 236,128.43 236.61,129.04 236.61,133.57 236.13,134.05 235.47,134.71 235.47,136.13 233.85,137.75 229.19,137.75 226.85,135.41 223.86,135.41 223.22,134.77 223.22,133.26 222.88,132.92 SJ1.53
SMBCLK_STBY: length 659
  TOP w0.102: v2(5.87,146.95) 6.03,146.79 11.13,146.79 14,149.66 14,150.91 v2(14.45,151.35) 15.15,152.05 15.15,152.5 17.19,154.55 17.93,154.55 18.96,155.57 22.66,155.57 23.58,156.49 34.58,156.49 36.26,154.81 38.17,154.81 39.41,153.57 42,153.57 PCI.A40 ; R957.2 64.04,237.42 64.42,237.8 64.42,239.45 63.74,240.14 43.65,240.14 42.45,238.94 v2(42.45,238.79) ; QN36.D 111.41,35.34 R303.2 109.79,34.39 R301.1 109.48,34.2 v2(109,33.71) 109,33.51 109.61,32.9 109.61,31.81 109.07,31.27 109.07,28.91 106.29,26.13 106.29,20.12 105.29,19.11 105.29,8.41 107.13,6.57 107.13,4.39 v2(106.59,3.84) ; PCIE16X_1.B5 80.21,194.27 73.4,194.27 72.72,193.58 70.39,193.58 69.27,194.7 64.27,194.7 63.41,193.83 60.91,193.83 PCIE1X.B5 59.89,194.27 57.88,194.27 57.55,193.94 54.92,193.94 54.64,194.22 53.44,194.22 52.84,194.82 52.84,195.83 51.79,196.88 50.38,196.88 49.98,196.48 44.13,196.48 43.03,195.37 41.8,195.37 40.95,196.22 39.12,196.22 38.01,195.1 36.89,195.1 36,194.21 36,193.43 35.17,192.59 28.52,192.59 26.62,194.49 23.48,194.49 22.48,193.49 21.2,193.49 20.14,194.55 PCIE16X_2.B5 19.24,194.27 15.6,194.27 v2(15.53,194.34) 15.53,197.72 17.62,199.82 19.82,199.82 v2(20.58,200.58) ; v2(5.49,63.53) 5.87,63.53 7.7,65.36 14.75,65.36 17.3,67.91 18.23,67.91 C231.1 R212.1
  BOTTOM w0.102: SR56.2 199.93,24.16 198.64,22.87 194.64,22.87 194.08,22.31 192.46,22.31 191.73,23.04 178.66,23.04 177.26,21.65 166.61,21.65 166.41,21.85 164.92,21.85 164.47,21.39 161.48,21.39 160.49,22.38 152.56,22.38 149.33,25.61 142.15,25.61 140.29,27.46 130.85,27.46 127.55,30.76 127.55,31.81 124.88,34.49 122.94,34.49 122.06,33.61 112.51,33.61 112.26,33.87 111.37,33.87 110.46,32.95 109.78,32.95 109.02,33.71 v2(109,33.71) ; v2(106.59,3.84) 103.53,0.79 3.55,0.79 2.48,1.86 0.79,3.55 0.79,55.76 5.93,60.9 5.93,62.19 5.67,62.44 5.67,63.35 v2(5.49,63.53) 5.7,63.74 5.7,65.64 5.06,66.28 4.83,66.28 2.36,68.74 2.36,128.35 6.03,132.01 6.03,134.32 6.71,135.01 6.71,144.57 6.55,144.74 6.55,146.27 v2(5.87,146.95) ; v2(42.45,238.79) 43.14,238.11 43.14,235.09 41.97,233.92 41.97,220.48 37.03,215.55 36.38,215.55 29.37,208.54 25.92,208.54 20.58,203.21 v2(20.58,200.58) ; v2(14.45,151.35) 14.45,157.96 15.56,159.07 15.56,172.09 14.51,173.15 14.51,174.99 14.51,174.99 14.51,176.16 15.02,176.67 15.02,178.6 15.02,192.17 15.76,192.91 15.76,194.11 v2(15.53,194.34)
SMBCLK_STBY_IO: length 12.8
  TOP w0.102: v2(204.38,24.09) 204.38,17.99 204.07,17.69 203.3,17.69 203.2,17.78 203.11,17.88 203.11,18.29 202.98,18.41 U21.63
  BOTTOM w0.102: SR56.1 SC51.2 202.68,23.73 204.02,23.73 v2(204.38,24.09)
SMBCLK_STBY_R: length 42.7
  TOP w0.102: v3(41.99,88.6) 42.77,88.6 PCH1.AG36 ; R212.2 21.55,66.75 25.73,66.75 v2(25.94,66.96)
  BOTTOM w0.102: v2(25.94,66.96) 26.58,66.96 26.83,66.71 26.83,66.33 27.72,65.44 v1(28.48,65.44) 30.78,65.44 33.24,67.9 33.51,68.17 33.51,71 31.66,72.85 31.66,74.33 34.23,76.91 36.39,76.91 39.8,80.32 41.31,81.82 41.31,86.14 41.61,86.44 41.61,87.94 41.97,88.3 41.97,88.58 41.99,88.6 v3(41.99,88.6)
SMBCLK_STBY_R1: length 11.9
  TOP w0.102: RLAN.17 55.34,234.29 v1(56.12,235.06) 56.93,235.87 59.82,235.87 59.9,235.95 60.83,236.88 62.01,236.88 62.87,236.03 R762.1 R957.1 C823.2
SMBDATA_MAIN: length 401.4
  TOP w0.102: v2(228.25,5.15) 228.02,5.15 226.66,6.51 226.66,8.05 226.23,8.48 223.58,8.48 R410.1 ; DIMM4.238 99.41,70.46 99.34,70.46 98.25,69.37 98.25,68.8 99.05,68 99.92,68 100.62,67.31 100.62,66.58 100.06,66.03 100.06,63.35 DIMM2.238 100.06,63.1 100.06,60.05 99.58,59.57 99.58,56.27 100.62,55.22 100.62,54.32 99.85,53.54 99.85,51.11 DIMM3.238 99.93,45.67 100.64,44.97 100.64,44.13 99.93,43.42 DIMM1.238 99.93,39.53 100.11,39.36 100.11,38.26 101.64,36.74 102.39,36.74 103.03,37.37 115.32,37.37 R305.1 R308.1 117.54,36.45 118.14,35.85 QN38.S 118.78,35.21 119.67,34.32 120.3,34.32 120.56,34.07 120.56,33.06 120.38,32.87 119.04,32.87 118.17,32.01 117.06,32.01 116.77,32.3 116.77,32.77 116.49,33.05 115.2,33.05 114.71,32.57 112.63,32.57 112.05,31.99 111.1,31.99 109.76,30.65 109.76,28.63 107.06,25.93 107.06,19.92 105.98,18.83 105.98,8.82 107.84,6.95 107.84,4.74 108.16,4.43 109.51,4.43 110.1,5.01 112.15,5.01 v2(113.06,4.1)
  BOTTOM w0.102: SJ1.51 222.84,132.41 223.45,133.03 223.45,134.68 223.93,135.16 227.11,135.16 229.47,137.52 233.75,137.52 235.24,136.04 235.24,134.53 236.38,133.38 236.38,129.13 235.77,128.52 235.77,123.34 236.35,122.75 236.35,116.09 226.35,106.08 226.35,92.87 228.12,91.09 228.12,88.93 230.89,86.16 230.89,76.12 235.83,71.18 238.5,71.18 242.07,67.61 242.07,50.31 241.66,49.9 241.66,48.45 242.07,48.04 242.07,27.69 240.05,25.67 240.05,18.63 230.55,9.13 230.55,6.78 229.64,5.87 228.98,5.87 v2(228.25,5.15) 227.95,4.85 226.26,4.85 225.1,3.68 223.2,3.68 221.5,1.98 115.18,1.98 v2(113.06,4.1)
SMBDATA_STBY: length 656.8
  TOP w0.102: R302.1 117.41,34.29 118.14,33.56 QN38.D ; R302.1 117,34.29 116.62,33.92 114.89,33.92 v2(114.66,34.14) ; R302.1 R308.2 ; v2(19.77,200.6) 19.22,200.06 17.48,200.06 15.02,197.59 15.02,193.58 v2(15.27,193.33) 17.3,193.33 PCIE16X_2.B6 17.81,193.83 20.48,193.83 21.05,193.27 22.58,193.27 23.58,194.27 26.52,194.27 28.43,192.36 35.26,192.36 36.23,193.33 36.23,194.12 36.99,194.88 38.11,194.88 39.22,195.99 40.86,195.99 41.71,195.14 43.12,195.14 44.23,196.25 50.07,196.25 50.45,196.63 51.72,196.63 52.61,195.74 52.61,194.72 53.35,193.99 54.55,193.99 54.83,193.71 58.03,193.71 PCIE1X.B6 58.66,194.04 59.7,194.04 59.89,193.85 60.57,193.85 60.81,193.61 63.5,193.61 64.36,194.47 68.61,194.47 69.76,193.33 72.93,193.33 73.57,193.96 78.09,193.96 PCIE16X_1.B6 ; v2(107.35,3.84) 107.39,3.88 107.39,6.7 105.52,8.57 105.52,19.02 106.52,20.02 106.52,26.03 109.3,28.82 109.3,31.1 110.17,31.96 v2(110.17,33.43) ; v2(41.82,238.16) 42.58,238.16 42.93,238.51 42.93,239.1 43.75,239.91 61.14,239.91 61.5,239.55 R958.2 ; v2(5.87,146.06) 6.38,146.57 11.31,146.57 14.64,149.89 v2(14.64,150.4) 15.4,151.16 15.4,152.43 17.29,154.32 18.03,154.32 19.05,155.34 22.76,155.34 23.68,156.27 34.48,156.27 36.17,154.58 38.07,154.58 39.33,153.32 40.8,153.32 42.21,151.91 PCI.A41 ; v2(5.11,62.9) 5.56,62.9 7.8,65.13 7.93,65.13 7.93,65.13 8.12,65.13 8.12,65.13 14.9,65.13 15.66,65.89 18.24,65.89 C232.1 R214.1
  BOTTOM w0.102: v2(14.64,150.4) 13.96,151.07 13.96,159.35 15.34,160.73 15.34,172 14.28,173.05 14.28,174.89 14.28,176.26 14.79,176.76 14.79,192.84 v2(15.27,193.33) ; v2(110.17,33.43) 111.06,34.32 114.48,34.32 v2(114.66,34.14) 114.97,33.84 121.97,33.84 122.88,34.75 124.93,34.75 127.78,31.91 127.78,30.88 130.97,27.69 140.39,27.69 142.24,25.84 149.43,25.84 152.65,22.61 160.59,22.61 161.58,21.62 164.37,21.62 164.83,22.08 166.5,22.08 166.71,21.88 177.17,21.88 178.57,23.27 191.83,23.27 192.56,22.54 193.99,22.54 194.55,23.1 198.53,23.1 199.42,23.98 199.42,24.64 SR55.2 ; v2(107.35,3.84) 104.06,0.56 3.46,0.56 2.25,1.76 0.56,3.46 0.56,55.85 0.69,55.99 0.69,55.99 5.7,60.99 5.7,62.06 5.11,62.64 v2(5.11,62.9) 4.95,63.06 4.95,64.31 5.47,64.83 5.47,65.54 4.96,66.05 4.74,66.05 2.13,68.65 2.13,128.5 5.8,132.16 5.8,134.42 6.48,135.1 6.48,144.48 6.32,144.64 6.32,145.61 v2(5.87,146.06) ; v2(19.77,200.6) 19.77,202.75 25.94,208.92 29.37,208.92 36.25,215.8 36.96,215.8 41.74,220.58 41.74,234.02 42.78,235.06 42.78,237.19 v2(41.82,238.16)
SMBDATA_STBY_IO: length 15.8
  TOP w0.102: U21.64 202.83,17.84 203.23,17.43 204.25,17.43 205.19,18.37 v2(205.19,24.37)
  BOTTOM w0.102: v1(201.3,26.35) 201.04,26.09 SR55.1 SC50.2 202.25,25.31 202.68,25.74 203.86,25.74 204.46,25.14 204.63,24.97 204.63,24.92 v2(205.19,24.37)
SMBDATA_STBY_R: length 45.2
  TOP w0.102: PCH1.AG32 42.62,90.81 42.35,90.53 v3(42.32,90.53) ; v2(26.32,66.25) 25.83,66.25 25.56,66.52 21.5,66.52 21.31,66.33 R214.2
  BOTTOM w0.102: v3(42.32,90.53) 42.76,90.1 42.76,89.61 42.48,89.33 42.48,88.52 41.82,87.86 41.82,86.27 41.56,86.01 41.56,81.75 40.03,80.22 36.49,76.68 34.33,76.68 31.88,74.23 31.88,72.94 33.74,71.09 33.74,67.52 v1(31.78,65.56) 31.02,64.8 27.77,64.8 v2(26.32,66.25)
SMBDATA_STBY_R1: length 11.5
  TOP w0.102: v1(63.74,238.19) C824.2 R958.1 61.5,237.9 60.39,236.79 R763.1 59.03,236.1 56.27,236.1 54.84,234.68 RLAN.18
SML0_ALERT: length 22.7
  TOP w0.102: PCH1.AG35 42.14,89.38 v3(42.04,89.29) ; R456.2 38.26,69.41 38.26,74.45 38.41,74.61 38.41,79.69 v2(38.51,79.79)
  BOTTOM w0.089: 40.93,83.47 41.03,83.57 41.03,86.21 41.41,86.59 41.41,88.65 v3(42.04,89.29)
  BOTTOM w0.102: v2(38.51,79.79) 40.7,81.97 v1(40.7,83.24) 40.93,83.47
SML0_CLK: length 305.1
  TOP w0.102: v2(71.69,223.86) 71.69,223.81 72.45,223.04 73.66,223.04 R430.1 ; v2(34.07,65.23) 33.59,64.76 C233.1 33.59,64.14 33.69,64.04 R223.2 33.59,63.5 33.05,64.04 32.4,64.04 32.04,63.67 22.64,63.67 22.45,63.86 16.75,63.86 15.78,62.9 13.26,62.9 12.52,62.16 10.16,62.16 8,60 v2(3.33,60) ; v2(16.03,202.98) 14.26,202.98 10.95,199.68 10.95,188.75 14.1,185.6 14.1,177.24 11.65,174.78 8.41,174.78 v2(7.78,175.42) ; PCH1.AE32 43.97,90.81 43.42,90.25 v3(43.42,90.28)
  BOTTOM w0.089: 41.97,85.61 42.02,85.66 42.02,87.77 42.68,88.43 42.68,89.25 42.96,89.52 42.96,89.82 v3(43.42,90.28)
  BOTTOM w0.102: v2(34.07,65.23) v1(34.07,66.07) 34.07,71.08 32.11,73.04 32.11,74.14 34.36,76.39 36.53,76.39 41.97,81.83 41.97,85.61 ; v2(16.03,202.98) 19.17,199.84 21.93,199.84 24.43,202.33 24.43,205.86 26.05,207.48 29.32,207.48 32.69,210.85 35.29,210.85 36.15,211.72 39.28,211.72 40.14,210.85 48.91,210.85 49.16,210.6 51.22,210.6 52.92,212.3 52.92,215.1 54.47,216.65 62.51,216.65 63.66,217.8 63.66,219.55 65.21,221.1 65.21,223.97 66.26,225.03 70.52,225.03 v2(71.69,223.86) ; v2(3.33,60) 3.33,60.43 0.56,63.2 0.56,170.36 3.46,173.26 5.62,173.26 v2(7.78,175.42)
SML0_CLK_R: length 4.2
  TOP w0.102: R430.2 74.21,220.79 73.74,220.33 v1(73.74,219.87) 73.74,219.16 72.91,218.33 ILAN.28
SML0_DATA: length 301
  TOP w0.102: v3(43.36,89.64) 43.63,89.38 PCH1.AE35 ; v2(35.47,66.96) 36.23,66.96 36.61,66.58 R222.2 C234.1 34.21,66.17 31.94,63.9 22.74,63.9 22.55,64.09 16.65,64.09 15.69,63.13 13.17,63.13 12.43,62.39 10.07,62.39 7.91,60.23 4.35,60.23 v2(3.97,60.61) ; v2(16.03,202.22) 13.88,202.22 11.21,199.55 11.21,188.88 14.36,185.73 14.36,177.17 11.74,174.56 v2(7.78,174.56) ; R432.1 70.14,223.15 70.9,223.91 v2(70.9,223.88)
  BOTTOM w0.089: 42.21,85.36 42.21,87.69 42.87,88.35 42.87,89.15 v3(43.36,89.64)
  BOTTOM w0.102: v2(3.97,60.61) 0.79,63.79 0.79,169.81 3.99,173.01 6.23,173.01 v2(7.78,174.56) ; 42.21,85.36 42.21,81.68 36.63,76.1 34.4,76.1 32.34,74.05 32.34,73.13 34.3,71.18 34.3,68.13 v2(35.47,66.96) ; v2(16.03,202.22) 16.35,202.22 18.96,199.61 22.03,199.61 24.78,202.36 24.78,205.78 26.14,207.14 29.3,207.14 32.78,210.62 35.41,210.62 36.25,211.46 39.15,211.46 39.99,210.62 48.81,210.62 49.07,210.37 51.31,210.37 53.14,212.2 53.14,215.01 54.56,216.43 62.61,216.43 64.32,218.14 v1(64.32,219.3) 64.32,219.77 65.44,220.89 65.44,223.88 66.36,224.8 69.98,224.8 v2(70.9,223.88)
SML0_DATA_R: length 3.7
  TOP w0.102: ILAN.31 71.71,219.21 70.93,220 v2(70.64,220) 70.14,220.5 R432.2
SML1_ALERT: length 12
  TOP w0.102: PCH1.AJ39 42.07,86.95 42.18,86.83 42.33,86.69 42.34,86.65 42.37,86.63 42.37,86.37 42.11,86.12 42.11,85.56 41.65,85.09 41.65,83.9 39.53,81.78 39.53,77.88 v1(39.28,77.63) R235.2
SML1_CLK: length 349.6
  TOP w0.102: PCH1.AK36 41.51,88.99 v3(41.03,89.47) ; v2(211.74,19.97) 211.61,20.1 211.61,22.51 212.12,23.02 212.12,27.33 209.06,30.39 207.93,30.39 207.48,30.84 U21.31 ; v2(12.42,65.88) 12.92,66.39 15.08,66.39 17.06,68.37 18.46,68.37 18.7,68.13 21.04,68.13 R228.2 22.21,69.3 23.51,69.3 C235.1 24.37,69.3 25.26,69.3 v2(25.74,68.82)
  BOTTOM w0.089: 39.82,84.45 39.83,84.45 40.42,85.05 40.42,86.56 40.8,86.94 40.8,89.24 v3(41.03,89.47)
  BOTTOM w0.102: v2(12.42,65.88) 12.42,65.56 11.69,64.84 11.69,58.76 11.56,58.63 9.56,56.63 9.56,56.51 9.56,50.05 10.47,49.13 10.47,46.82 9.74,46.08 9.74,37.56 8.8,36.62 8.8,16.86 8.24,16.3 8.24,8.01 11.5,4.75 51.05,4.75 53.82,7.53 59.82,7.53 63.69,3.66 71.58,3.66 72.42,4.5 72.42,9.56 72.51,9.65 72.51,9.68 77.16,14.33 84.4,14.33 85.18,15.11 90.97,15.11 92.81,16.95 102.53,16.95 104.51,14.97 141,14.97 142.85,13.11 155.81,13.11 157.01,14.31 168.58,14.31 169.36,15.09 178.87,15.09 178.87,15.09 179.06,15.09 179.06,15.09 182.24,15.09 182.72,15.58 200.35,15.58 201.95,17.18 203.87,17.18 204.48,17.79 v1(206.53,17.79) 207.12,18.37 208.17,18.37 208.29,18.5 209.49,18.5 209.7,18.7 210.85,18.7 211.74,19.59 v2(211.74,19.97) ; v2(25.74,68.82) 27.34,67.22 27.34,66.5 27.57,66.28 30.97,66.28 33.05,68.36 33.05,70.81 32.07,71.79 31.2,72.66 31.2,74.52 34.1,77.42 35.42,77.42 35.62,77.62 35.62,78.06 35.82,78.26 35.82,79.46 37.52,81.16 37.98,81.16 38.26,81.44 38.89,81.44 39.58,82.13 39.58,84.22 39.82,84.45
SML1_DATA: length 346.9
  TOP w0.102: PCH1.AK33 41.56,90.93 v3(41.45,91.04) ; U21.53 202.86,23.41 203.72,22.56 v2(203.72,18.17) ; v2(13.19,65.88) 14.94,65.88 17.2,68.14 18.32,68.14 18.56,67.9 21.48,67.9 R227.2 22.4,66.98 23.45,66.98 C236.1 24.37,67.04 25.25,67.04 25.68,67.47 25.69,67.47 v2(25.69,67.98)
  BOTTOM w0.089: 39.96,84.31 40.62,84.97 40.62,86.43 41,86.81 41,88.82 41.43,89.25 41.43,89.54 41.69,89.79 41.69,90.8 v3(41.45,91.04)
  BOTTOM w0.102: v2(13.19,65.88) 11.92,64.61 11.92,58.67 11.65,58.4 9.79,56.54 9.79,50.14 10.7,49.23 10.7,46.64 9.96,45.9 9.96,37.47 9.02,36.53 9.02,16.71 8.47,16.15 8.47,8.1 11.59,4.98 50.95,4.98 53.73,7.75 59.92,7.75 63.79,3.89 69.55,3.89 70.8,5.14 70.8,7.87 arc(70.96,8.03) 71.13,7.87 71.13,4.27 arc(71.28,4.12) 71.43,4.27 71.43,7.89 arc(71.6,8.06) 71.76,7.89 71.76,4.83 arc(71.91,4.68) 72.07,4.83 72.07,9.53 72.28,9.74 72.28,9.78 77.07,14.56 84.31,14.56 85.16,15.41 90.95,15.41 92.72,17.18 102.62,17.18 104.6,15.2 109.89,15.2 v1(110.29,15.6) 110.7,15.2 141.09,15.2 142.94,13.34 155.71,13.34 156.91,14.54 168.48,14.54 169.27,15.32 182.14,15.32 182.62,15.81 200.26,15.81 202.62,18.17 v2(203.72,18.17) ; 39.96,84.31 39.78,84.13 39.78,81.95 39.05,81.21 38.36,81.21 38.08,80.93 37.62,80.93 36.05,79.36 36.05,78.17 35.85,77.96 35.85,77.53 35.51,77.19 34.2,77.19 31.43,74.42 31.43,72.75 33.28,70.9 33.28,68.26 33.15,68.13 31.06,66.05 27.47,66.05 27.11,66.41 27.11,67 26.13,67.98 v2(25.69,67.98)
SMRCOMP0: length 8.9
  TOP w0.305: CPU1.R1 138.95,132.52 138.08,133.38 137.07,133.38 135.67,134.78 135.67,136.72 R26.2
SMRCOMP1: length 7.3
  TOP w0.305: CPU1.P1 139.67,133.43 138.61,134.5 137.35,134.5 136.66,135.19 136.66,136.69 R29.2
SMRCOMP2: length 8.9
  TOP w0.305: R31.2 136.16,137.47 136.16,134.98 137.27,133.88 138.42,133.88 139.32,132.98 141.05,132.98 CPU1.R2
SPI_CLK: length 102
  TOP w0.102: R221.1 49.56,75.42 51.72,73.26 51.72,70.14 50.45,68.87 50.45,66.55 48.8,64.9 v2(48.8,63.79) ; R324.2 34.45,12.28 33.87,12.86 32.5,12.86 31.81,12.17 31.81,12 30.54,10.73 27.19,10.73 v2(26.7,11.21) 26.25,10.75 23.21,10.75 R323.2
  BOTTOM w0.102: v2(26.7,11.21) 26.7,11.87 23.27,15.3 23.27,23.41 24.21,24.35 24.21,32.85 20.86,36.21 20.86,41.95 28.66,49.75 34.29,49.75 42.74,58.2 v1(43.47,58.2) 44.25,58.2 45.35,59.3 45.35,60.71 48.42,63.79 v2(48.8,63.79)
SPI_CLK0: length 32.6
  TOP w0.102: SPIROM1.6 22.17,6.45 22.17,6.45 arc(22.17,6.45) 22.17,6.45 22.4,6.23 arc(22.45,6.1) 22.4,5.97 22.16,5.74 arc(22.16,5.49) 22.41,5.49 22.65,5.72 arc(22.77,5.77) 22.9,5.72 23.15,5.47 23.48,5.47 23.63,5.62 23.63,5.85 24.23,6.45 arc(24.48,6.45) 24.48,6.2 24.03,5.75 arc(24.03,5.5) 24.28,5.5 24.77,5.99 24.77,7.23 24.37,7.63 23.93,7.63 23.62,7.94 23.62,8.57 23.49,8.69 22.98,8.69 v2(22.7,8.41) 22.64,8.48 R323.1 ; v2(18.96,8.29) 18.83,8.16 17.44,8.16 16.31,7.03 16.31,4.57 15.59,3.84 12.54,3.84 12.3,4.08 12.3,7.83 11.72,8.41 SPI_DEBUG.8
  BOTTOM w0.102: v2(22.7,8.41) 22.58,8.29 v2(18.96,8.29)
SPI_CLK1: length 13.3
  TOP w0.102: R324.1 34.45,8.76 34.04,8.35 33.14,8.35 32.77,7.98 32.77,7.02 arc(32.6,6.84) 32.42,7.02 32.42,7.88 arc(32.24,8.06) 32.06,7.88 32.06,7.02 arc(31.88,6.84) 31.71,7.02 31.71,7.88 arc(31.53,8.06) 31.35,7.88 31.35,6.59 32.04,5.9 33.03,5.9 33.58,6.45 SPIROM2.6
SPI_CS_L0: length 115.3
  TOP w0.102: SPI_DEBUG.3 15.37,5.87 15.63,6.13 15.63,7.4 17.41,9.17 17.41,9.6 17.64,9.84 20.58,9.84 20.78,10.04 20.78,10.26 21.48,10.95 v2(21.5,10.95) ; v2(51.29,65.41) 51.59,65.71 51.59,68.1 53.08,69.59 53.08,75.59 51.01,77.65 50.63,77.65 50.18,78.1 50.18,78.63 50.4,78.85 50.4,81.03 48.88,82.56 48.88,86.13 49.29,86.54 49.29,86.65 49.43,86.78 49.43,87.1 49.11,87.42 PCH1.R38 ; R325.1 24.41,9.91 v2(24.92,9.91)
  BOTTOM w0.102: v1(23.78,11.03) 23.71,10.95 v2(21.5,10.95) ; v1(23.78,11.03) 24.21,11.46 24.21,13.47 22.82,14.87 22.82,23.71 23.76,24.65 23.76,32.54 20.4,35.89 20.4,42.14 28.47,50.21 34.1,50.21 48.44,64.55 49.06,64.55 49.31,64.29 49.71,64.29 50.83,65.41 v2(51.29,65.41) ; v1(23.78,11.03) 23.78,11.01 24.87,9.91 v2(24.92,9.91)
SPI_CS_L1: length 113.6
  TOP w0.102: PCH1.R35 48.96,89.38 v3(48.71,89.63) ; v2(50.32,75.92) 50.32,74.98 51.98,73.33 51.98,70.01 50.68,68.71 50.68,66.45 49.51,65.28 v2(49.51,64.78) ; SPI_DEBUG.12 12.1,10.95 12.95,11.81 15.17,11.81 15.53,12.17 15.53,13.08 16.45,14 22.79,14 v2(23.27,13.52) 23.34,13.59 R326.1
  BOTTOM w0.102: v2(49.51,64.78) 48.35,64.78 34.01,50.43 28.38,50.43 20.17,42.23 20.17,35.79 23.53,32.44 23.53,31.55 22.49,30.51 22.49,14.31 v2(23.27,13.52) ; v2(50.32,75.92) 49.77,76.47 v1(49.77,77.71) 49.77,78.82 49.44,79.15 49.44,81.26 48.19,82.51 48.19,83.6 48.71,84.12 48.71,88.35 48.33,88.73 48.33,89.24 v3(48.71,89.63)
SPI_IO2: length 106
  TOP w0.102: R319.2 R321.2 R765.2 27.75,10.03 v2(27.62,9.91) ; PCH1.U40 48.49,86.37 48.47,86.34 48.47,82.34 48.8,82.01 48.8,80.71 C262.1 48.17,80.07 48.17,78.96 49.63,77.5 50.14,77.5 50.44,77.2 50.82,77.2 52.62,75.4 52.62,69.9 51.14,68.41 51.14,66.26 50.5,65.63 v2(50.5,64.32)
  BOTTOM w0.102: v2(27.62,9.91) 27.19,10.34 25.25,10.34 24.59,11.01 24.59,13.47 23.04,15.02 23.04,23.51 23.98,24.45 23.98,32.63 20.63,35.98 20.63,42.04 28.57,49.98 34.2,49.98 43.84,59.62 v1(44.74,59.62) 44.74,60.52 48.54,64.32 48.96,64.32 49.22,64.07 50.25,64.07 v2(50.5,64.32)
SPI_IO2_0: length 17.7
  TOP w0.102: SPIROM1.3 26.83,6.45 26.7,6.58 v2(26.7,8.97) ; R319.1 R317.2 31.6,9.51 31.6,10.5 v2(31.96,10.85)
  BOTTOM w0.102: v2(31.96,10.85) 31.96,9.99 31.38,9.41 30.42,9.41 arc(30.33,9.44) 30.3,9.53 30.3,10.05 arc(30.09,10.26) 29.89,10.05 29.89,9.61 arc(29.69,9.41) 29.48,9.61 29.48,10.05 arc(29.28,10.26) 29.08,10.05 29.08,9.61 arc(28.87,9.41) 28.67,9.61 28.67,10.05 arc(28.47,10.26) 28.26,10.05 28.26,9.61 arc(28.21,9.46) 28.06,9.41 26.93,9.41 26.7,9.18 v2(26.7,8.97)
SPI_IO2_1: length 16.2
  TOP w0.102: v2(33.79,10.88) 33.62,10.71 33.62,9.53 R318.2 32.72,8.62 30.21,8.62 R321.1 ; SPIROM2.3 40.58,6.45 38.91,8.12 v2(38.91,8.85)
  BOTTOM w0.102: v2(38.91,8.85) 38.42,9.33 v1(36.58,9.33) 35.25,9.33 34.98,9.6 34.96,9.6 33.79,10.78 v2(33.79,10.88)
SPI_IO3: length 123.9
  TOP w0.102: PCH1.U37 48.8,87.72 48.8,86.35 48.67,86.22 48.67,82.43 49.69,81.41 C264.1 50.17,80.04 50.17,79 49.96,78.79 49.96,78.01 50.54,77.43 50.92,77.43 52.85,75.49 52.85,69.74 51.37,68.26 51.37,66.17 50.81,65.61 50.81,64.75 v2(51.57,63.99) ; R322.2 41.82,10.1 41.82,11.21 v2(41.18,11.84) ; R764.2 36.74,11.72 36.99,11.97 37.62,11.97 38.39,11.21 v2(39.61,11.21) 39.02,10.62 R320.2
  BOTTOM w0.102: v2(41.18,11.84) 40.55,11.21 v2(39.61,11.21) 38.64,11.21 37.65,12.2 36.13,12.2 35.62,11.69 33.31,11.69 32.54,12.45 31.88,12.45 30.95,11.51 28.62,11.51 27.39,12.75 27.08,12.75 23.96,15.86 23.96,22.94 24.9,23.88 24.9,33.29 21.55,36.64 21.55,41.66 28.86,48.98 34.49,48.98 41.4,55.89 42.91,55.89 46.07,59.05 46.07,60.42 48.43,62.77 49.44,62.77 49.54,62.87 50.53,62.87 v1(50.93,63.28) 50.93,63.28 51.57,63.91 v2(51.57,63.99)
SPI_IO3_0: length 27.6
  TOP w0.102: R314.2 R320.1 39.5,9.11 v2(39.5,8.26) ; R422.1 20.19,5.18 SPIROM1.7 24.54,5.18 25,5.65 25,7.32 v2(24.21,8.11)
  BOTTOM w0.102: v2(24.21,8.11) 24.49,7.83 39.07,7.83 v2(39.5,8.26)
SPI_IO3_0_R: length 14.8
  TOP w0.102: SPI_DEBUG.6 11.82,7.14 12.07,6.89 12.07,3.99 12.44,3.61 15.68,3.61 16.54,4.47 16.54,6.91 17.18,7.55 18.07,7.55 v1(18.19,7.42) 18.38,7.24 R422.2
SPI_IO3_1: length 24.4
  TOP w0.102: SPIROM2.7 35.8,5.18 36.42,4.55 37.19,4.55 37.47,4.83 37.47,6.15 arc(37.65,6.33) 37.83,6.15 37.83,4.99 arc(38.01,4.81) 38.18,4.99 38.18,6.38 36.53,8.03 36.53,8.95 36.29,9.19 36.29,13.02 v2(36.3,13.04) 36.3,13.57 36.74,14 39.53,14 40.16,13.37 R316.2 R322.1
SPI_MISO: length 125.5
  TOP w0.102: v2(50.32,76.68) 50.47,76.68 C251.1 52.39,74.75 52.39,70.05 50.91,68.56 50.91,66.36 49.99,65.44 49.99,63.48 v2(49.87,63.35) ; v2(32.29,11.97) 32.16,11.97 30.69,10.5 26.15,10.5 R311.2 ; R313.2 42.45,11.46 v2(42.32,11.59) ; v3(48.73,88.94) 49,88.67 PCH1.R36
  BOTTOM w0.102: v2(49.87,63.35) 49.51,63.35 49.18,63.02 48.36,63.02 45.84,60.51 45.84,59.15 42.81,56.12 41.31,56.12 34.4,49.21 28.77,49.21 21.32,41.76 21.32,36.54 24.67,33.19 24.67,24.16 23.73,23.22 23.73,15.77 26.98,12.52 27.3,12.52 28.53,11.29 31.23,11.29 31.91,11.97 v2(32.29,11.97) 32.8,11.46 35.72,11.46 36.23,11.97 37.55,11.97 38.95,10.57 41.31,10.57 v2(42.32,11.59) ; v3(48.73,88.94) 48.91,88.76 48.91,83.56 v1(48.75,83.4) 48.75,82.38 49.77,81.36 49.77,79.43 50.32,78.87 v2(50.32,76.68)
SPI_MISO0: length 22.2
  TOP w0.102: v2(26.63,9.84) 26.47,9.84 25.85,9.21 R311.1 25.76,9.16 25.76,4.78 arc(25.94,4.6) 26.12,4.78 26.12,7.6 arc(26.3,7.78) 26.47,7.6 26.47,6.23 arc(26.53,6.11) 26.65,6.05 26.78,6.05 arc(26.96,5.88) 26.78,5.7 26.59,5.7 arc(26.51,5.67) 26.47,5.58 26.47,5.47 26.76,5.18 SPIROM1.2 ; v2(20.2,10.34) 20.1,10.45 R415.2
  BOTTOM w0.102: v2(20.2,10.34) 20.23,10.37 23.78,10.37 24.9,9.25 25.58,9.25 26.17,9.84 v2(26.63,9.84)
SPI_MISO0_R: length 6.6
  TOP w0.102: v2(18.14,11.26) 18.1,11.21 R415.1 17.69,10.45 17.18,9.94 17.18,9.27 15.05,7.14 SPI_DEBUG.5
SPI_MISO1: length 13.8
  TOP w0.102: SPIROM2.2 42.93,5.18 43.15,5.4 43.15,6.03 arc(43.33,6.21) 43.5,6.03 43.5,3.84 arc(43.68,3.66) 43.86,3.84 43.86,5.42 arc(44.04,5.6) 44.22,5.42 44.22,5.09 arc(44.39,4.91) 44.57,5.09 44.57,6.1 43.15,7.52 43.15,8.89 R313.1
SPI_MOSI: length 117.2
  TOP w0.102: PCH1.P40 49.6,82.77 49.93,82.44 50.46,82.44 51.44,81.46 51.67,81.46 52.18,80.96 52.18,78.47 C249.1 53.31,77.34 53.31,69.44 51.85,67.98 51.85,64.98 v2(51.59,64.73) ; R310.2 21.96,10.64 22.4,10.64 22.74,10.98 25.77,10.98 26.5,11.72 27.34,11.72 v2(27.53,11.53) 28.1,10.95 30.44,10.95 31.58,12.09 31.58,12.27 32.4,13.09 34.14,13.09 35.59,11.63 R312.2
  BOTTOM w0.102: v2(27.53,11.53) 23.5,15.55 23.5,23.32 24.44,24.26 24.44,33.03 21.09,36.38 21.09,41.85 28.68,49.44 34.3,49.44 41.54,56.67 v1(42.35,56.67) 43.05,56.67 45.62,59.24 45.62,60.61 48.29,63.28 49.05,63.28 49.61,63.84 50.71,63.84 v2(51.59,64.73)
SPI_MOSI0: length 15.2
  TOP w0.102: R310.1 21.94,8.78 21.94,8.4 22.69,7.65 22.69,7.43 22.42,7.16 arc(22.42,6.91) 22.67,6.91 23.27,7.51 arc(23.52,7.51) 23.52,7.26 22.92,6.66 arc(22.92,6.4) 23.17,6.4 24.05,7.28 arc(24.3,7.28) 24.3,7.03 23.25,5.98 22.97,5.98 22.09,6.85 22.09,7.36 21.73,7.72 SPIROM1.5 20.51,7.72 R419.1
SPI_MOSI0_R: length 19.1
  TOP w0.102: R419.2 16.09,7.16 16.09,4.71 15.45,4.07 12.76,4.07 12.53,4.3 12.53,9.13 11.97,9.68 SPI_DEBUG.10 v2(7.65,9.68)
SPI_MOSI1: length 14.8
  TOP w0.102: SPIROM2.5 35.52,7.72 35.85,7.4 35.85,5.62 arc(36.02,5.44) 36.2,5.62 36.2,7.07 arc(36.38,7.25) 36.56,7.07 36.56,5.09 arc(36.74,4.91) 36.91,5.09 36.91,7.25 36.1,8.06 36.1,8.59 R312.1 34.98,9.71 v2(34.98,10.9)
SPI_WP: length 46.4
  TOP w0.381: R317.1 R318.1 33.18,10.45 32.95,10.68 32.95,11.61 v2(33.56,12.22) ; v2(31.4,13.24) 31.4,12.73 30.04,11.38 28.8,11.38 27.69,12.48 26.4,12.48 25.51,11.59 21.09,11.59 20.58,11.08 19.23,11.08 18.35,11.97 17.3,11.97 16.69,11.36 16.69,9.71 v2(16.54,9.56)
  TOP w0.508: SPI_DEBUG.7 15.23,8.41 16.15,9.33 16.16,9.33 16.34,9.51 16.49,9.51 v2(16.54,9.56) ; v2(14.42,14.08) 14.42,14.45 v2(16.21,16.24)
  BOTTOM w0.381: v2(31.4,13.24) 32.54,13.24 v2(33.56,12.22)
  BOTTOM w0.508: v2(14.42,14.08) 13.04,14.08 12,15.11 SR48.2 11.18,15.11 10.88,14.82 10.88,13.38 11.3,12.95 SR49.1 11.81,12.86 SQP1.E ; v2(16.21,16.24) 16.78,15.67 16.78,11.96 16.67,11.84 16.67,9.68 v2(16.54,9.56)
SPKR_B: length 9.1
  TOP w0.102: R387.2 C411.2 233.71,102.14 233.31,102.55 233.31,107.35 v2(233.2,107.45) 233.2,107.91 232.75,108.36 QN40.B
SPKR_C:
  vias: v2(232.42,105.9)
SRTCRST_L: length 13.1
  TOP w0.102: R252.1 34.58,77.66 34.3,77.93 34.3,79.71 35.07,80.49 C240.2 34.7,80.89 34.7,82.71 35.77,83.78 37.05,83.78 38.92,85.65 38.96,85.65 39.16,85.85 39.16,86.21 38.9,86.46 PCH1.AR39
STOP_L: length 9.4
  TOP w0.127: PCI.A38 42.52,155.86 45.88,155.86 46.51,155.23 47.75,155.23 R969.1 49.31,154.59 49.81,154.09 U11.67
SUSACK_L: length 247.8
  TOP w0.102: v2(89.06,46.64) 88.17,46.64 87.59,46.06 81.17,46.06 78.87,48.35 78.87,57.08 76.67,59.29 72.48,59.29 71.67,60.1 66.05,60.1 65.31,60.84 63.89,60.84 63.34,60.29 52.74,60.29 49.39,56.94 43.43,56.94 43.26,57.11 42.83,57.54 41.51,57.54 38.94,60.11 38.94,65.88 40.37,67.3 40.37,74.43 39.83,74.96 39.83,81.8 41.87,83.83 41.87,84.97 42.32,85.42 42.32,86.03 42.57,86.28 42.57,86.71 42.51,86.77 42.5,86.81 42.41,86.89 42.38,86.92 42.38,87.71 PCH1.AJ37 ; v2(214.41,34.32) 214.28,34.45 214.28,36.23 214.54,36.48 R353.1 R959.2 214.98,35.18 U21.16
  BOTTOM w0.102: v2(89.06,46.64) 91.23,46.64 91.49,46.38 95.1,42.78 95.56,42.32 95.56,39.11 98.55,36.13 100.73,36.13 101.57,35.29 105.95,35.29 107.52,36.86 127.41,36.86 130.46,33.81 130.46,31.3 132.01,29.75 143.29,29.75 145.14,27.9 150.38,27.9 153.6,24.67 177.05,24.67 177.73,25.36 194.19,25.36 195.94,27.11 195.94,28.99 v1(196.45,29.5) 196.81,29.85 196.81,32.29 197.67,33.15 199.5,33.15 200.19,32.47 203.45,32.47 205.66,34.68 214.05,34.68 v2(214.41,34.32)
SUSCLK: length 23.3
  TOP w0.102: R226.1 49.18,68.52 49.18,69.98 46.95,72.22 46.95,73.04 46.69,73.3 46.69,75.52 47,75.83 47,75.82 v2(47,75.82) ; v3(46.64,88.33) 46.98,88.67 PCH1.W36
  BOTTOM w0.102: v2(47,75.82) 47,75.82 47,75.83 47.53,76.36 47.53,76.72 46.77,77.48 v1(46.77,78.65) 46.19,79.23 46.19,84.2 46.16,84.23 46.16,86.53 46.57,86.93 46.57,88.26 v3(46.64,88.33)
SUSWARN_L: length 235.6
  TOP w0.102: v2(88.42,47.28) 87.43,46.29 81.26,46.29 79.1,48.45 79.1,57.22 76.81,59.52 72.58,59.52 71.76,60.33 66.14,60.33 65.41,61.07 63.73,61.07 63.19,60.53 52.66,60.53 49.29,57.17 43.53,57.17 43.42,57.27 42.93,57.77 41.61,57.77 39.17,60.2 39.17,65.78 40.6,67.2 40.6,74.52 40.06,75.06 40.06,81.71 42.09,83.74 42.09,84.88 42.76,85.55 PCH1.AG41 ; U21.15 215.48,33.49 216.95,34.96 R352.1 216.92,35.34 R959.1 215.81,35.31 v2(215.81,34.58)
  BOTTOM w0.102: v2(215.81,34.58) 215.48,34.91 204.71,34.91 v1(204.25,34.45) 203.79,34.91 202.56,34.91 201.46,36 179.59,36 178.49,34.91 174.02,34.91 172.93,36 160.78,36 159.02,34.24 130.42,34.24 127.57,37.09 107.43,37.09 105.89,35.55 101.63,35.55 100.83,36.35 98.64,36.35 95.79,39.21 95.79,42.41 90.92,47.28 v2(88.42,47.28)
SVR_EN_N: length 7.5
  TOP w0.102: v1(67.62,207.09) 67.68,207.09 R434.1 68.71,208.12 R431.1 69.24,209.73 70.43,209.73 71.56,210.86 71.56,211.49 71.71,211.64 ILAN.6
SW1_R: length 1.5
  TOP w1.016: C800.2 73.44,49.31 R926.2
SW2_R: length 1.7
  TOP w1.016: C788.2 46.79,13.75 R913.2
SWN1: length 20.7
  TOP w0.102: P11.1 64.14,45.78 L14.1
  TOP w0.178: 52.99,36.61 52.99,36.35 52.72,36.08 U41.19
  TOP w0.508: v2(57.97,43.25) 54.66,43.25 53.91,42.5 53.91,40.06 53.44,39.59 C794.2 52.69,38.26 52.99,37.95 52.99,36.61
  BOTTOM w0.508: v2(61.75,42.7) 61.21,43.25 v2(57.97,43.25)
  vias: v2(62.52,45.63) v2(63.15,44.36) v2(63.79,43.21) v2(65.06,47.66) v2(65.44,44.23) v2(65.44,42.32) v2(66.96,42.32) v2(67.22,47.02) v2(67.22,45.75) v2(67.22,44.48) v2(67.34,55.4) v2(67.34,54.13) v2(67.34,52.86) v2(67.34,51.59) v2(68.74,50.2) v2(68.74,48.42) v2(70.26,49.44)
SWN2: length 22.2
  TOP w0.102: P10.1 59.47,11.72 58.49,11.72 L13.1
  TOP w0.178: 52.23,30.39 52.72,30.87 U41.3
  TOP w0.508: 52.23,30.39 51.98,30.13 C784.2 51.98,27.91 52.42,27.91 52.99,27.34 v2(52.99,26.7)
  TOP w0.635: QD5L2.D5 51.21,18.03 50.45,18.79 v2(50.45,21.75)
  BOTTOM w0.635: SR54.2 v2(50.45,21.75) 51.21,22.51 51.21,25.31 52.61,26.7 v2(52.99,26.7)
  vias: v2(50.32,13.37) v2(51.09,14.13) v2(51.09,12.61) v2(52.61,14.13) v2(52.61,12.61) v2(53.75,16.03) v2(53.75,14.76) v2(53.88,11.97) v2(53.88,11.08) v2(53.88,10.19) v2(54.67,13.42) v2(54.77,16.03) v2(55.79,16.03) v2(55.76,11.88) v2(56.93,16.03) v2(59.09,14.13) v2(59.09,13.24) v2(61.75,17.18) v2(62.64,17.18) v2(63.53,17.18)
SYS_FAN_P2: length 0.7
  TOP w0.508: v2(114.81,186.25) R380.2
SYS_FAN_P3: length 18.3
  TOP w0.508: SYS_FAN.3 119.29,179.11 R382.1 R379.2 v2(120.43,181.77) ; D6.P 125.64,185.45 125,184.82 122.71,184.82 v2(122.46,185.07)
  BOTTOM w0.508: v2(120.43,181.77) 120.43,181.26 120.68,181.01 121.95,181.01 122.46,181.52 v2(122.46,185.07)
SYS_FAN_P4: length 10.2
  TOP w0.102: R384.2 116.75,182.4 118.4,180.75 118.4,177.98 118.9,177.48 120.95,177.48 SYS_FAN.4
SYS_THERM: length 12.8
  TOP w0.254: U21.90 216.48,14.49 216,14 216,10.61 R339.2 213.04,10.13 RT1.2 212.25,12.26 C385.2 C383.1
SYS_VSB: length 6
  TOP w0.102: R943.2 R942.1 203.7,13.93 204.82,13.93 205.13,14.24 205.82,14.24 206.48,14.9 U21.70
TACH0: length 19.6
  TOP w0.102: RN45.3 25.82,84.61 v2(25.56,84.87) ; PCH1.AP28 39.01,92.9 v3(39.63,92.28)
  BOTTOM w0.102: v2(25.56,84.87) 25.94,84.87 v1(26.58,85.5) 27.52,86.44 30.06,86.44 30.51,86.9 30.51,87.72 33.5,90.71 35.61,90.71 36.97,92.07 39.43,92.07 v3(39.63,92.28)
TACH3: length 12.6
  TOP w0.089: 35.96,89.89 35.97,89.88 36.84,89.88 PCH1.AV34
  TOP w0.102: RN45.1 26.45,85.5 26.6,85.66 27.99,85.66 29.08,86.75 31.06,86.75 31.85,87.54 32.66,87.54 35.03,89.9 35.96,89.9 35.96,89.89
TACH5: length 15.5
  TOP w0.102: RN45.7 26.45,83.35 26.7,83.09 27.97,83.09 28.28,82.79 30.84,82.79 30.98,82.93 30.98,83.83 32.54,85.39 32.54,86.84 35.17,89.47 36.15,89.47 36.18,89.5 36.47,89.5 36.7,89.27 PCH1.AV35
TCM_33M: length 338
  TOP w0.102: R148.1 25.97,110.01 25.97,109.79 25.66,109.48 25.66,106.77 25.23,106.34 25.23,103.79 18.56,97.12 18.56,91.92 17.56,90.91 v2(17.56,90.84) ; TPM.1 197.26,4.86 195.59,6.53 C431.2 R409.1 193.99,6.53 193.66,6.19 v2(193.66,3.92)
  BOTTOM w0.102: v2(193.66,3.92) 193.37,3.63 152.01,3.63 151.47,4.17 151.47,6.13 150.83,6.76 144.3,6.76 143.01,5.47 141.77,5.47 139.93,3.63 121.83,3.63 120.42,5.04 115.04,5.04 114.08,6 113.56,6 112.04,7.53 105.37,7.53 102.55,4.71 93.28,4.71 90.19,7.8 90.19,9.83 90.56,10.2 90.56,10.98 87.94,13.6 85.68,13.6 84.99,12.91 84.99,12.91 84.96,12.88 77.73,12.88 73.93,9.09 73.93,9.06 73.84,8.97 73.84,3.45 72.63,2.24 63.08,2.24 59.23,6.08 54.42,6.08 51.67,3.33 10.73,3.33 3.49,10.57 3.49,27.67 5.85,30.04 5.85,35.92 7.03,37.11 7.25,37.11 8.31,38.17 8.31,57.24 10.47,59.4 10.47,63.47 9.66,64.29 9.66,68.63 11.36,70.33 11.36,72.78 7.96,76.18 7.96,81.06 11.69,84.79 12.28,84.79 12.28,84.79 13.61,84.79 15.55,86.73 15.55,89.21 15.81,89.47 16.52,89.47 16.92,89.87 16.92,90.33 17.43,90.84 v2(17.56,90.84)
TD_IREF: length 2.8
  TOP w0.102: PCH1.C3 55.13,106.29 v3(55.06,106.36)
  BOTTOM w0.102: v3(55.06,106.36) 55.39,106.68 SR20.2 56.01,106.68 v1(56.8,107.47)
TEST/UBGND: length 8.5
  TOP w0.102: v1(41.46,232.65) 41.05,232.24 41.05,231.08 41.56,230.57
  TOP w0.254: RLAN.39 45.76,230.02 45.37,230.41 44.48,230.41 44.1,230.79 41.91,230.79 R952.1 41.56,230.57
TEST_EN: length 2.8
  TOP w0.102: R284.1 49.76,145.07 49.94,144.89 U11.90
TESTLO_N5: length 23.3
  TOP w0.381: R51.2 129.24,138.72 v2(134.4,133.56) ; CPU1.N5 v4(143.79,133.89)
  BOTTOM w0.381: v2(134.4,133.56) 134.4,133.56 134.4,133.56 142.35,133.56 142.59,133.32 143.22,133.32 v4(143.79,133.89)
TESTLO_P6: length 27
  TOP w0.254: R13.2 127.41,137.57 132.66,132.33 v2(135.63,132.33)
  TOP w0.305: CPU1.P6 v4(144.71,133.89)
  BOTTOM w0.254: v2(135.63,132.33) 136.48,131.48 138.46,131.48 139.12,132.14 140.57,132.14 140.98,131.73 144.2,131.73 145.22,132.75 145.22,133.38 v4(144.71,133.89)
THERMAL_SD: length 271.8
  TOP w0.102: v2(29.37,61.75) 29.52,61.91 32.39,61.91 38.64,55.66 42.32,55.66 42.64,55.34 50.19,55.34 53.2,58.35 64.14,58.35 64.65,57.84 66.27,57.84 67.85,59.42 71.38,59.42 72.2,58.6 76.31,58.6 78.19,56.73 78.19,48.07 81.62,44.63 87.81,44.63 v2(88.93,45.75) ; U21.13 216.48,31.33 216.25,31.1 214.74,31.1 v2(214.47,30.83) ; v2(25.56,84.11) RN45.5 ; v3(40.27,92.29) 40.43,92.45 PCH1.AM28
  BOTTOM w0.102: v3(40.27,92.29) 39.85,91.87 37.06,91.87 35.69,90.51 34.42,90.51 v1(33.1,89.19) 32.3,89.19 30.77,87.65 30.77,86.77 30.21,86.21 28.18,86.21 26.07,84.11 v2(25.56,84.11) 23.91,84.11 21.57,81.77 21.57,74.06 22.38,73.25 22.38,72.68 21.99,72.28 21.99,70.41 22.21,70.2 22.21,67.77 23.62,66.36 24.13,66.36 24.67,65.82 24.67,64.94 27.47,62.14 28.99,62.14 v2(29.37,61.75) ; v2(88.93,45.75) 88.93,45.32 90,44.25 90.93,44.25 93.86,41.32 93.86,38.86 97.74,34.98 100.26,34.98 101.09,34.14 106.47,34.14 108.05,35.72 125.26,35.72 128.7,32.29 128.7,31.26 131.35,28.61 140.77,28.61 142.62,26.75 149.9,26.75 153.13,23.53 177.52,23.53 178.18,24.19 196.43,24.19 199.32,27.08 199.32,28.76 201.05,30.49 214.13,30.49 v2(214.47,30.83)
TP0: length 5.5
  TOP w0.102: U11.105 55.64,140.1 54.39,138.84 v1(52.99,138.84) 52.66,138.84 52.1,138.28 R282.1
TP1: length 4.9
  TOP w0.102: R283.1 55.77,139.3 v1(56.27,139.3) 56.81,139.3 57.24,139.73 U11.109
TP_VGA: length 11.3
  TOP w0.102: R740.2 28.12,89.29 31.5,89.29 32.39,90.18 TP_VGA.1 34,91.35 36.47,91.35 36.68,91.57 37.01,91.57 37.08,91.49 37.41,91.49 37.49,91.53 PCH1.AT30
TPM_33M: length 391.8
  TOP w0.102: U23.21 233.4,25.93 232.44,26.89 C422.1 233.24,27.12 v2(233.97,26.39) ; v2(16.26,90.08) 16.47,90.28 16.52,90.28 16.87,90.64 16.87,91.02 17.48,91.62 17.77,91.62 18.21,92.06 18.21,97.27 24.87,103.94 24.87,106.49 25.31,106.92 25.31,110.01 25.61,110.32 25.61,110.92 R154.1
  BOTTOM w0.102: v2(233.97,26.39) 233.97,25.18 233.08,24.29 233.08,21.95 234.09,20.94 234.09,19.72 v1(234.47,19.34) 234.93,18.88 234.93,17.7 230.69,13.46 230.58,13.46 229.66,12.54 229.66,11.89 226.6,8.83 226.6,7.35 224.86,5.61 223.15,5.61 220.82,3.28 121.68,3.28 120.27,4.69 114.89,4.69 113.93,5.65 113.41,5.65 111.89,7.17 105.51,7.17 102.69,4.35 93.13,4.35 89.69,7.79 89.69,9.84 90.18,10.32 90.18,10.86 87.87,13.16 85.75,13.16 85.14,12.55 85.14,12.55 85.11,12.53 77.87,12.53 74.29,8.95 74.29,8.91 74.2,8.82 74.2,3.3 72.99,2.09 72.78,1.88 62.93,1.88 59.09,5.72 54.57,5.72 51.82,2.97 10.58,2.97 10.37,3.18 3.13,10.42 3.13,27.82 5.49,30.18 5.49,36.07 6.89,37.46 7.1,37.46 7.96,38.32 7.96,57.39 10.12,59.55 10.12,63.33 9.3,64.14 9.3,68.78 11.01,70.48 11.01,72.63 7.6,76.03 7.6,81.21 11.54,85.15 13.46,85.15 15.2,86.88 15.2,89.62 15.65,90.08 v2(16.26,90.08)
TPM_IC_P5: length 2.4
  TOP w0.254: R404.1 232.32,17.5 231.45,18.36 U23.5
TPM_IC_P7: length 3.7
  TOP w0.102: U23.7 232.75,18.2 233.01,17.94 233.01,16.48 RJ5.2
TPM_IC_P10: length 2.4
  TOP w0.254: U23.10 234.7,18.31 234.86,18.16 R406.1
TPM_IC_P19: length 2.3
  TOP w0.254: R407.2 234.7,27.24 U23.19
TPM_P5: length 52.9
  TOP w0.102: v2(226.32,6.17) 225.97,6.52 C432.2 225.74,6.92 225.08,6.26 221.11,6.26 220.22,5.37 213.71,5.37 213.13,5.94 203.79,5.94 TPM.5 ; R412.1 237.71,26.48 v2(237.71,23.46)
  BOTTOM w0.102: v2(237.71,23.46) 238.92,22.26 238.92,19.03 227.74,7.85 227.74,7.08 226.83,6.17 v2(226.32,6.17)
TPM_P6: length 21.8
  TOP w0.102: R410.2 R411.2 221.43,6.89 220.16,5.62 213.84,5.62 213.29,6.17 203.21,6.17 TPM.6
TPM_P15: length 7.5
  TOP w0.102: TPM.15 216.03,3.51 221.98,3.51 R413.1
TPM_P18: length 3.9
  TOP w0.102: R421.1 215.96,6.92 216.19,6.7 217.25,6.7 TPM.18
TPM_P19: length 3.1
  TOP w0.102: R416.1 R420.1 222.06,4.66 221.9,4.5 TPM.19
TPM_RSV2: length 5.3
  TOP w0.102: R417.2 224.41,8.73 223.49,8.73 223.12,8.36 221.72,8.36 220.4,7.04 TPM.20
TRDY_L: length 18.8
  TOP w0.127: PCI.A36 39.65,158.26 38.73,157.35 38.73,156.64 39.51,155.86 40.55,155.86 41.75,154.66 42.77,154.66 43.87,153.55 45.6,153.55 46.13,154.08 47.75,154.08 R966.1 48.39,153.46 48.62,153.69 U11.68
TS_D-: length 26.9
  TOP w0.254: v2(219.72,26.4) 219.43,26.11 219.43,22.58 214.98,18.13 U21.87 214.98,14.83 213.2,13.05 R937.1 ; R941.1 227.36,28.23 v2(227.36,27.34)
  BOTTOM w0.254: v2(219.72,26.4) 219.96,26.64 225.39,26.64 v1(225.97,27.21) 226.09,27.34 v2(227.36,27.34)
UAV33/TEST: length 5.4
  TOP w0.102: RLAN.42 43.89,228.52 R949.1 42.48,227.87 v1(42.17,228.18)
UGND1: length 7.1
  TOP w0.457: C495.2 100.27,221.74 C496.1
  TOP w0.508: C493.2 v2(107.86,218.22) ; C494.2 v2(106.71,218.22) ; v2(101.25,222.54) C496.1
  vias: v2(91.7,210.12) v2(93.68,211.08) v2(104.05,235.24) v2(104.78,233.97) v2(106.2,242.98) v2(106.2,240.19) v2(108.36,213.37) v2(109,242.98) v2(109,240.19) v2(109.13,213.37) v2(109.51,236.38) v2(111.92,243.08) v2(111.92,240.19) v2(113.32,236.38) v2(115.73,243.08) v2(115.73,240.19) v2(117.13,236.38) v2(117.63,213.14) v2(119.41,213.14) v2(119.54,243.08) v2(119.54,240.19) v2(123.35,243.08) v2(123.35,240.19)
UHSDN/TEST: length 3.9
  TOP w0.127: R950.1 43.82,229.26 43.99,229.43 44.9,229.43 45.22,229.12 46.48,229.12 46.58,229.02 RLAN.41
UHSDP/TEST: length 3.9
  TOP w0.127: R951.1 43.82,229.9 43.98,229.74 45.03,229.74 45.35,229.42 46.48,229.42 46.58,229.52 RLAN.40
USB3_RX_N0: length 153.9
  TOP w0.102: v3(53.91,97.75) 53.91,97.64 PCH1.F20
  TOP w0.127: CMK30.1 110.95,210.54 110.67,210.27 110.67,209.68 108.24,207.25 108.24,201.2 v1(108.62,200.82) 108.24,200.44 108.24,197.56 v2(108.53,197.26)
  BOTTOM w0.102: v3(53.91,97.75) 53.68,97.97 53.68,98.14 53.79,98.25 54.69,98.25 55.15,98.71 56.96,98.71 58.77,100.51 59.57,100.51 63.6,104.54 64.24,104.54 64.28,104.5 64.29,104.5
  BOTTOM w0.127: 64.29,104.5 69.78,104.5 75.58,110.29 83.02,110.29 87.06,114.33 87.06,184.28 97.32,194.55 106.46,194.55 108.24,196.32 108.24,196.97 v2(108.53,197.26)
USB3_RX_N0_R: length 29.4
  TOP w0.127: USB3_LAN.5 110.29,231.63 110.83,231.63 111.06,231.86 111.06,232.82 111.54,233.31 111.54,234.09 110.95,234.68 109.86,234.68 108.74,233.56 108.74,231.55 109.4,230.89 109.4,229.46 109.11,229.16 109.11,226.87 109.63,226.35 109.63,224.19 110.83,222.99 110.83,216.34 110.91,216.26 D17.9 D17.2 110.91,214.34 110.81,214.24 110.81,213.9 110.67,213.76 110.67,213.65 110.95,213.37 CMK30.2
