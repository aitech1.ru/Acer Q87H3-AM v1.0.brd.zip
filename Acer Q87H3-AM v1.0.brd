# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Nets (continued)
SPI_IO2_1: R318.2 R321.1 SPIROM2.3
SPI_IO3: C264.1 PCH1.U37 R320.2 R322.2 R764.2
SPI_IO3_0: R314.2 R320.1 R422.1 SPIROM1.7
SPI_IO3_0_R: R422.2 SPI_DEBUG.6
SPI_IO3_1: R316.2 R322.1 SPIROM2.7
SPI_MISO: C251.1 PCH1.R36 R311.2 R313.2
SPI_MISO0: R311.1 R415.2 SPIROM1.2
SPI_MISO0_R: R415.1 SPI_DEBUG.5
SPI_MISO1: R313.1 SPIROM2.2
SPI_MOSI: C249.1 PCH1.P40 R310.2 R312.2
SPI_MOSI0: R310.1 R419.1 SPIROM1.5
SPI_MOSI0_R: R419.2 SPI_DEBUG.10
SPI_MOSI1: R312.1 SPIROM2.5
SPI_WP: R317.1 R318.1 SPI_DEBUG.7 SQP1.E SR48.2 SR49.1
SPKR_B: C411.2 QN40.B R387.2
SPKR_C: QN40.C RN28.1(A) RN28.3(A) RN28.5(A) RN28.7(A)
SRTCRST_L: C240.2 PCH1.AR39 R252.1
STOP_L: PCI.A38 R969.1 U11.67
SUSACK_L: PCH1.AJ37 R353.1 R959.2 U21.16
SUSCLK: PCH1.W36 R226.1
SUSWARN_L: PCH1.AG41 R352.1 R959.1 U21.15
SVR_EN_N: ILAN.6 R431.1 R434.1
SW1_R: C800.2 R926.2
SW2_R: C788.2 R913.2
SWN1: C794.2 L14.1 P11.1 QD3H1.S1 QD3H1.S2 QD3H1.S3 QD3L1.D1 QD3L1.D2 QD3L1.D3 QD3L1.D4 QD3L1.D5 QD3L2.D1 QD3L2.D2 QD3L2.D3 QD3L2.D4 QD3L2.D5 R923.2 R926.1 U41.19
SWN2: C784.2 L13.1 P10.1 QD5H1.S1 QD5H1.S2 QD5H1.S3 QD5H2.S1 QD5H2.S2 QD5H2.S3 QD5L1.D1 QD5L1.D2 QD5L1.D3 QD5L1.D4 QD5L1.D5 QD5L2.D1 QD5L2.D2 QD5L2.D3 QD5L2.D4 QD5L2.D5 R913.1 SR54.2 U41.3
SYS_FAN_P2: C408.1 EC13.1 QP2.C R375.1 R380.2 SYS_FAN.2
SYS_FAN_P3: D6.P R379.2 R382.1 SYS_FAN.3
SYS_FAN_P4: R384.2 SYS_FAN.4
SYS_THERM: C383.1 C385.2 R339.2 RT1.2 U21.90
SYS_VSB: R942.1 R943.2 U21.70
TACH0: PCH1.AP28 RN45.3(A)
TACH3: PCH1.AV34 RN45.1(A)
TACH5: PCH1.AV35 RN45.7(A)
TCM_33M: C431.2 R148.1 R409.1 TPM.1
TD_IREF: PCH1.C3 SR20.2
TEST/UBGND: R952.1 RLAN.39
TEST_EN: R284.1 U11.90
TESTLO_N5: CPU1.N5 R51.2
TESTLO_P6: CPU1.P6 R13.2
THERMAL_SD: PCH1.AM28 RN45.5(A) U21.13
TP0: R282.1 U11.105
TP1: R283.1 U11.109
TP_VGA: PCH1.AT30 R740.2 TP_VGA.1
TPM_33M: C422.1 R154.1 U23.21
TPM_IC_P5: R404.1 U23.5
TPM_IC_P7: RJ5.2 U23.7
TPM_IC_P10: R406.1 U23.10
TPM_IC_P19: R407.2 U23.19
TPM_P5: C432.2 R412.1 TPM.5
TPM_P6: R410.2 R411.2 TPM.6
TPM_P15: R413.1 TPM.15
TPM_P18: R421.1 TPM.18
TPM_P19: R416.1 R420.1 TPM.19
TPM_RSV2: R417.2 TPM.20
TRDY_L: PCI.A36 R966.1 U11.68
TS_D-: R937.1 R941.1 U21.87
UAV33/TEST: R949.1 RLAN.42
UGND1: C491.2 C493.2 C494.2 C495.2 C496.1 R467.2 R469.1 R470.1 USB3_LAN.4 USB3_LAN.7 USB3_LAN.13 USB3_LAN.16 USB3_LAN.G1 USB3_LAN.G2 USB3_LAN.G3 USB3_LAN.G4 USB3_LAN.G5 USB3_LAN.G6 USB3_LAN.G7 USB3_LAN.G8
UHSDN/TEST: R950.1 RLAN.41
UHSDP/TEST: R951.1 RLAN.40
USB3_RX_N0: CMK30.1 PCH1.F20 RN39.3(A)
USB3_RX_N0_R: CMK30.2 D17.2 D17.9 RN39.4(B) USB3_LAN.5
USB3_RX_N1: CMK32.4 PCH1.G18 RN39.5(A)
USB3_RX_N1_R: CMK32.3 D17.4 D17.7 RN39.6(B) USB3_LAN.14
USB3_RX_N4: CMK23.4 PCH1.K20 RN24.1(A)
USB3_RX_N4_R: CMK23.3 D3.1 D3.10 RN24.2(B) USB3F1.2
USB3_RX_N5: CMK26.4 PCH1.L18 RN24.5(A)
USB3_RX_N5_R: CMK26.3 D3.4 D3.7 RN24.6(B) USB3F1.18
USB3_RX_P0: CMK30.4 PCH1.G20 RN39.1(A)
USB3_RX_P0_R: CMK30.3 D17.1 D17.10 RN39.2(B) USB3_LAN.6
USB3_RX_P1: CMK32.1 PCH1.H18 RN39.7(A)
USB3_RX_P1_R: CMK32.2 D17.5 D17.6 RN39.8(B) USB3_LAN.15
USB3_RX_P4: CMK23.1 PCH1.L20 RN24.3(A)
USB3_RX_P4_R: CMK23.2 D3.2 D3.9 RN24.4(B) USB3F1.3
USB3_RX_P5: CMK26.1 PCH1.K18 RN24.7(A)
USB3_RX_P5_R: CMK26.2 D3.5 D3.6 RN24.8(B) USB3F1.17
USB3_TX_N0: C500.1 PCH1.B18
USB3_TX_N0_C: C500.2 CMK29.1 RN40.7(A)
USB3_TX_N0_R: CMK29.2 D16.1 D16.10 RN40.8(B) USB3_LAN.8
USB3_TX_N1: C503.1 PCH1.B15
USB3_TX_N1_C: C503.2 CMK31.4 RN40.1(A)
USB3_TX_N1_R: CMK31.3 D16.5 D16.6 RN40.2(B) USB3_LAN.17
USB3_TX_N4: C364.1 PCH1.D15
USB3_TX_N4_C: C364.2 CMK21.4 RN25.1(A)
USB3_TX_N4_R: CMK21.3 D2.1 D2.10 RN25.2(B) USB3F1.5
USB3_TX_N5: C366.1 PCH1.B14
USB3_TX_N5_C: C366.2 CMK25.4 RN25.5(A)
USB3_TX_N5_R: CMK25.3 D2.4 D2.7 RN25.6(B) USB3F1.15
USB3_TX_P0: C501.1 PCH1.C18
USB3_TX_P0_C: C501.2 CMK29.4 RN40.5(A)
USB3_TX_P0_R: CMK29.3 D16.2 D16.9 RN40.6(B) USB3_LAN.9
USB3_TX_P1: C504.1 PCH1.B16
USB3_TX_P1_C: C504.2 CMK31.1 RN40.3(A)
USB3_TX_P1_R: CMK31.2 D16.4 D16.7 RN40.4(B) USB3_LAN.18
USB3_TX_P4: C365.1 PCH1.C15
USB3_TX_P4_C: C365.2 CMK21.1 RN25.3(A)
USB3_TX_P4_R: CMK21.2 D2.2 D2.9 RN25.4(B) USB3F1.6
USB3_TX_P5: C367.1 PCH1.A14
USB3_TX_P5_C: C367.2 CMK25.1 RN25.7(A)
USB3_TX_P5_R: CMK25.2 D2.5 D2.6 RN25.8(B) USB3F1.14
USB+3: CMK37.3 F_USB3.3 U26.6
USB+6: CMK14.3 F_USB1.6 RN19.6(B) U14.6
USB+7: CMK13.3 F_USB1.5 RN19.2(B) U14.4
USB+8: CMK17.3 RN21.2(B) U17.4 USB2X4.A3
USB+9: CMK18.3 RN21.6(B) U17.6 USB2X4.B3
USB+10: CMK19.3 RN22.6(B) U18.3 USB2X4.C3
USB+11: CMK20.3 RN22.2(B) U18.1 USB2X4.D3
USB+12: CMK16.3 F_USB2.6 RN20.6(B) U15.3
USB+13: CMK15.3 F_USB2.5 RN20.2(B) U15.1
USB-3: CMK37.2 F_USB3.2 U26.1
USB-6: CMK14.2 F_USB1.4 RN19.8(B) U14.1
USB-7: CMK13.2 F_USB1.3 RN19.4(B) U14.3
USB-8: CMK17.2 RN21.4(B) U17.3 USB2X4.A2
USB-9: CMK18.2 RN21.8(B) U17.1 USB2X4.B2
USB-10: CMK19.2 RN22.8(B) U18.4 USB2X4.C2
USB-11: CMK20.2 RN22.4(B) U18.6 USB2X4.D2
USB-12: CMK16.2 F_USB2.4 RN20.8(B) U15.4
USB-13: CMK15.2 F_USB2.3 RN20.4(B) U15.6
USB_EN: R294.2 R295.1 R359.1 RJ3.2 RJ4.2
USB_EN1: C405.1 R359.2 U12.4 U13.4 U19.2 U25.4
USB_EN2: C355.1 R295.2 U16.4 U29.2
USB_N0: CMK28.1 PCH1.AV10 RN38.7(A)
USB_N0_R: CMK28.2 RN38.8(B) U28.3 USB3_LAN.2
USB_N1: CMK27.4 PCH1.AV11 RN38.1(A)
USB_N1_R: CMK27.3 RN38.2(B) U28.1 USB3_LAN.11
USB_N2: PCH1.AN14 R950.2
USB_N3: CMK37.1 PCH1.AJ16
USB_N4: CMK22.4 PCH1.AU15 RN23.1(A)
USB_N4_R: CMK22.3 RN23.2(B) U20.1 USB3F1.8
USB_N5: CMK24.4 PCH1.AU12 RN23.5(A)
USB_N5_R: CMK24.3 RN23.6(B) U20.3 USB3F1.12
USB_N6: CMK14.1 PCH1.AV14 RN19.7(A)
USB_N7: CMK13.1 PCH1.AU17 RN19.3(A)
USB_N8: CMK17.1 PCH1.AW16 RN21.3(A)
USB_N9: CMK18.1 PCH1.AN16 RN21.7(A)
USB_N10: CMK19.1 PCH1.AJ18 RN22.7(A)
USB_N11: CMK20.1 PCH1.AP18 RN22.3(A)
USB_N12: CMK16.1 PCH1.AW18 RN20.7(A)
USB_N13: CMK15.1 PCH1.AP20 RN20.3(A)
USB_OC0_L: PCH1.AE40 RN14.2(B)
USB_OC2_L: PCH1.AD39 RN14.6(B)
USB_OC3_L: PCH1.AD40 RN14.4(B)
USB_OC4_L: PCH1.AF39 RN13.4(B)
USB_OC5_L: PCH1.AC41 RN14.8(B)
USB_OC6_L: PCH1.AF40 RN13.6(B)
USB_OC7_L: PCH1.AG40 RN13.2(B)
USB_P0: CMK28.4 PCH1.AU10 RN38.5(A)
USB_P0_R: CMK28.3 RN38.6(B) U28.4 USB3_LAN.3
USB_P1: CMK27.1 PCH1.AW11 RN38.3(A)
USB_P1_R: CMK27.2 RN38.4(B) U28.6 USB3_LAN.12
USB_P2: PCH1.AP14 R951.2
USB_P3: CMK37.4 PCH1.AK16
USB_P4: CMK22.1 PCH1.AV15 RN23.3(A)
USB_P4_R: CMK22.2 RN23.4(B) U20.6 USB3F1.9
USB_P5: CMK24.1 PCH1.AT12 RN23.7(A)
USB_P5_R: CMK24.2 RN23.8(B) U20.4 USB3F1.11
USB_P6: CMK14.4 PCH1.AW14 RN19.5(A)
USB_P7: CMK13.4 PCH1.AT17 RN19.1(A)
USB_P8: CMK17.4 PCH1.AV16 RN21.1(A)
USB_P9: CMK18.4 PCH1.AP16 RN21.5(A)
USB_P10: CMK19.4 PCH1.AK18 RN22.5(A)
USB_P11: CMK20.4 PCH1.AN18 RN22.1(A)
USB_P12: CMK16.4 PCH1.AV18 RN20.5(A)
USB_P13: CMK15.4 PCH1.AN20 RN20.1(A)
USBRBIAS: PCH1.AU20 PCH1.AV20 R138.1
V_0P9_LAN: C443.2 C444.2 C447.2 ILAN.8 ILAN.11 ILAN.16 ILAN.22 ILAN.37 ILAN.40 ILAN.43 ILAN.46 ILAN.47 L1.2 R441.1 SC37.2 SC38.2 SC39.2 SC40.2
V_1P05_ME_5V_IN: C584.1 C585.1 C586.1 L5.2 U33.6 U33.7 U33.8
V_ME_COMP: C591.1 R618.2 U33.10
V_ME_FB: R616.2 R620.2 U33.9
V_ME_PHASE: L6.1 U33.3 U33.4
VCORE_VCC_SEN: CPU1.E40 R851.1
VCORE_VSS_SEN: CPU1.F40 R854.1
VGA_B: C118.1 FB5.2 FB6.2
VGA_BLUE: C123.1 C192.1 FB5.1 PCH1.AC3 R112.2 R146.2
VGA_BLUE_CONN: C120.1 FB6.1 U7.4 VGA.3
VGA_DDCSCL_5V: MN2.D R802.2 R805.1
VGA_DDCSDA_5V: MN1.D R801.2 R804.1
VGA_G: C119.1 FB3.2 FB4.2
VGA_GREEN: C125.1 C191.1 FB3.1 PCH1.AE2 R111.2 R145.2
VGA_GREEN_CONN: C121.1 FB4.1 U7.6 VGA.2
VGA_H_SYNC: C128.1 R799.2 R954.2 U35.4
VGA_H_SYNC_R: C708.1 R954.1 U24.1 VGA.13
VGA_HSYNC: C245.1 R142.1 R799.1 U35.1 U35.2
VGA_PCH_DDCSCL: MN2.S PCH1.AL2 R803.1
VGA_PCH_DDCSDA: MN1.S PCH1.AL3 R978.1
VGA_R: C117.1 FB1.2 FB2.2
VGA_RED: C126.1 C190.1 FB1.1 PCH1.AC2 R110.2 R144.2
VGA_RED_CONN: C122.1 FB2.1 U7.3 VGA.1
VGA_V_SYNC: C127.1 R800.2 R955.2 U36.4
VGA_V_SYNC_R: C709.1 R955.1 U24.3 VGA.14
VGA_VSYNC: C246.1 R143.1 R800.1 U36.1 U36.2
VI_SID_ARL: R6.1 R9.1 R12.1
VID_ALERT_L_R: CPU1.B37 R10.2 R12.2
VID_CK_R: CPU1.C38 R7.1 R11.1
VR_B: QN78.B R890.2
VR_EN: C6.2 C737.1 QN2.C QN77.C QN78.C R810.2 R815.1 U39.1
VR_GC: QN79.C R886.1 R890.1
VR_GR: QN79.B R894.2
VR_HOT_L: C680.1 R35.1 R38.1 R824.1
VR_HOT_L_95820: R819.2 R824.2 U39.4
VR_READY: R62.2 R255.2 R820.2 R988.1 U39.2
VR_SVID_ALERT_L: R9.2 R818.2 U39.39
VR_SVID_CK: R7.2 R814.2 U39.40
VR_SVID_DATAOUT: R8.2 R816.2 U39.38
VR_SVID_DATAOUT_R: CPU1.C37 R5.1 R8.1
VRD_THERMDA: C815.1 C816.1 QN81.B QN81.C U21.89
VRD_THERMDC: C815.2 C816.2 QN81.E R937.2
VREF: C507.1 CODEC.27
VSUM+: C761.1 C762.1 C764.1 R823.2 R845.2 R867.2 R868.2 R873.2 R898.2 R939.1 U39.16
VSUM+_RC: R867.1 RT3.1
VSUM-: C741.2 C755.2 C764.2 C766.2 C767.2 C775.2 R832.2 R835.2 R855.2 R859.2 R868.1 R872.1 R874.1 R875.1 R879.2 R881.2 R902.2 R904.2 RT3.2
WAKE_B_L: R278.1 U11.1
WRST_L: C390.1 R345.1 U21.50
XDP_P39: R982.2 R983.2 SJ1.39
XDP_P40: SJ1.40 SR33.2
XDP_P41: R984.2 SJ1.41
XDP_P42: SJ1.42 SR34.2
XDP_P45: SJ1.45 SR30.2
XDP_P46: R986.2 SJ1.46
XDP_P60: SJ1.60 SR40.2
XDP_VR_READY: R988.2 R989.2 SC43.2 SJ1.47
XTAL_25M_PCH_IN: C198.2 PCH1.N7 R162.1 X1.2
XTAL_25M_PCH_OUT: C199.2 PCH1.N6 R162.2 X1.1
N23497998: C854.1 R991.2 R994.1 R995.1
N23498029: QN83.B QN84.C R990.2
N23498035: QN84.B R994.2
N23702339: QN35.C R998.1
N23702342: QN35.B R999.1
N23713553: C856.1 C857.2 QP9.G R1001.2

Pads without a net: ATX_POWER 7; BIOS_WP 1; CODEC 2 18 19 20 31 33 37 43 44 45 46 48; COM1 10; CPU1 A4 AB33 AB36 AC8 AK20 AL25 AL26 AM25 AM26 AN25 AN26 AP25 AP26 AR25 AR26 AT31 AT33 AT40 AU1 AU27 AU31 AU32 AU33 AU39 AV1 AV2 AV24 AV29 AV31 AV32 AV33 AW2 AW23 AW24 AW31 AW33 AY18 B3 C2 C39 D1 H12 H14 H15 H16 J8 J9 J10 J13 J15 J16 J17 J40 K8 K12 K13 L10 L12 M10 M11 M38 N36 N38 P33 P37 R33 R34 R36 T34 T35 U8 W8 Y8; DIMM1 39 40 42 43 45 46 48 49 53 68 79 126 135 144 153 158 159 162 164 165 167 187 198 204 213 222 231; DIMM2 39 40 42 43 45 46 48 49 53 68 79 126 135 144 153 158 159 162 164 165 167 187 198 204 213 222 231; DIMM3 39 40 42 43 45 46 48 49 53 68 79 126 135 144 153 158 159 162 164 165 167 187 198 204 213 222 231; DIMM4 39 40 42 43 45 46 48 49 53 68 79 126 135 144 153 158 159 162 164 165 167 187 198 204 213 222 231; DVI-D 4 5 8 12 13 20 21 C1 C2 C3 C4 C5 C6; F_PANEL 9 13; F_USB1 10; F_USB2 10; ME_DISABLE 1; PCH1 A2 A3 AC6 AC7 AE6 AE7 AE10 AE11 AG10 AG11 AH24 AJ14 AJ31 AK14 AL31 AL39 AM31 AM34 AN9 AP1 AP2 AP31 AT2 AT9 AT22 AV8 AV9 AV22 AV30 AW23 B1 B2 B11 B12 B27 C27 F28 G28 K5 K14 K16 K22 K33 K34 L5 L14 L16 L22 N12 P5 R4 R12 R40 U10 U11 U34 U35 U36 Y2 Y4; PCI A9 A11 B4 B9 B10 B11 B14; PCIE1X A1 A5 A6 A7 A8 B9 B12 B17; PCIE16X_1 A1 A5 A6 A7 A8 A19 A32 A33 A50 B9 B12 B17 B30 B31 B48 B81 B82; PCIE16X_2 A1 A5 A6 A7 A8 A19 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 A62 A63 A64 A65 A66 A67 A68 A69 A70 A71 A72 A73 A74 A75 A76 A77 A78 A79 A80 A81 A82 B9 B12 B17 B30 B31 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 B63 B64 B65 B66 B67 B68 B69 B70 B71 B72 B73 B74 B75 B76 B77 B78 B79 B80 B81 B82; PSKM 2 6 8 12; RLAN 34 35 50 51 55; RN15 7 8; SATA1 8 9; SATA2 8 9; SATA3 8 9; SATA4 8 9; SATA5 8 9; SJ1 55; TPM 13 14; U3 3; U6 3; U7 1; U9 4; U11 8 24 25 26 27 28 29 32 93 103 106 114 118 119 120 121 127 128; U12 6; U13 6; U16 6; U19 6; U21 18 78 100 101 102 103 121; U22 7; U23 1 2 3 6 8 9 12 13 14 15; U25 6; U26 3 4; U34 1; U41 11; USB3F1 10; VGA 4 11 G1

## Via types
v1: diameter 0.762, hole 0.381, TOP to BOTTOM, 695 vias
v2: diameter 0.61, hole 0.305, TOP to BOTTOM, 3943 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 364 vias
v4: diameter 0.559, hole 0.305, TOP to BOTTOM, 870 vias
v5: diameter 0.762, hole 0.406, TOP to BOTTOM, 21 vias
v6: diameter 1.016, hole 0.508, TOP to BOTTOM, 41 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3VR_GO: length 4.4
  TOP w0.102: R894.1 C773.2 R896.2 R889.1 226.63,125.88 v1(226.6,125.91)
3VSBSW_L: length 101.1
  TOP w0.102: U21.79 210.98,17.53 v2(209.05,19.46) ; R588.1 127.85,28.61 126.8,27.56 R586.2 126.14,26.92 126.14,24.42 126.52,24.04 135.14,24.04 135.62,23.55 v2(135.62,20.4)
  BOTTOM w0.102: v2(209.05,19.46) 208.57,19.95 207.96,19.95 207.3,19.29 205.58,19.29 205.3,19.57 202.66,19.57 199.82,16.72 192.14,16.72 189.75,19.11 180.42,19.11 179.02,17.71 168.15,17.71 167.39,16.95 155.89,16.95 155.46,17.37 154.74,18.09 144.81,18.09 142.86,20.05 140.04,20.05 v1(139.68,20.4) v2(135.62,20.4)
5V_LDO: length 30.2
  TOP w0.178: 50.32,31.97 50.45,32.1 50.45,32.42 50.79,32.76 U41.27
  TOP w0.381: C781.2 45.5,30.39 45.75,30.64 ; 50.32,31.97 49,30.64 v2(46.39,30.64)
  TOP w0.508: v2(46.39,30.64) 45.5,30.64 45.02,31.12 R934.2 R905.2 ; v2(60.64,30.26) 60.87,30.48 60.87,31.68 60.41,32.13 R911.2 60.23,32.88 R924.2
  BOTTOM w0.508: v2(60.64,30.26) 59.75,31.15 50.39,31.15 49.88,30.64 v1(47.38,30.64) v2(46.39,30.64)
5VDLSB: length 5.6
  TOP w0.508: QN48.C 137.99,26.8 C827.1 R580.2 143.19,26.8 QSW1.G
12VR_B: length 5.3
  TOP w0.102: v1(236.91,117.56) 236.91,116.55 R892.2 235.33,116.24 234.86,116.24 234.09,117 QN77.B
12VR_GO: length 5.3
  TOP w0.102: R891.1 R897.2 C774.2 227.58,118.1 v1(228.58,117.1) 228.58,116.21 228.54,116.16 R895.1
12VR_GR: length 3.9
  TOP w0.102: R895.2 229.78,115.89 QN80.B 229.78,117.71 v1(228.61,118.88)
12VRC: length 9.6
  TOP w0.102: v1(237.07,115.68) 236.56,115.17 235.47,115.17 235.03,115.6 R892.1 R887.1 233.3,116.11 233.08,116.11 232.9,116.29 232.9,118.67 232.28,119.29 QN80.C
+1.8V_AUXA: length 30.3
  TOP w0.152: 70.9,153.32 68.84,153.32 68.1,152.58 68.1,150.2 67.59,149.69 U11.19
  TOP w0.381: C338.1 75.15,147.51 75.7,148.06 75.7,150.03 76.33,150.66 76.33,153.17 75.95,153.55 71.76,153.55 v1(71.53,153.32) 70.9,153.32
  TOP w0.508: v2(74.58,138.84) 74.2,139.22 PFB4.1 ; C338.1 74.58,146.95 v2(74.35,146.72)
  BOTTOM w0.508: v2(74.35,146.72) 73.82,146.18 73.82,144.05 74.58,143.29 v2(74.58,138.84)
+1.8V_AUXD: length 6.4
  TOP w0.203: U11.7 68.16,144.89 v1(68.87,144.18)
  TOP w0.305: PFB5.1 70.93,142.94 C339.1 70.83,143.95 69.1,143.95 v1(68.87,144.18)
+1.8VA:
  vias: v1(69.93,147.48)
+1.8VD: length 89
  TOP w0.203: U11.125 63.64,140 63.91,139.73 ; U11.23 v2(64.4,151.29) ; U11.112 58.44,138.97 57.89,138.41 57.45,138.41 C341.1 ; U11.78 51.93,149.69 ; 61.88,157.51 61.64,157.27 U11.41
  TOP w0.305: C341.1 57.67,137.15 57.67,136.57 58.06,136.18 v2(58.83,136.18) ; 51.93,149.69 52.04,149.58 52.04,142.65 51.82,142.44 U11.96 50.36,142.44 49.56,141.64
  TOP w0.381: 64.04,137.8 64.04,139.61 63.91,139.73 v2(64.4,139.73) ; 64.04,137.8 v1(64.02,137.78) ; 64.04,137.8 64.04,137.78 63.13,136.86 v2(61.35,136.86) 61.35,135.89 60.73,135.26 60.73,134.83 59.3,133.41 50.38,133.41 47.22,136.57 47.22,137.63 45.88,138.97 45.88,139.22 v2(45.88,139.22) ; v2(64.4,158.81) 63.53,158.81 63.41,158.94 C342.1 63.06,159.58 62.64,159.16 62.64,158.27 61.88,157.51 ; PFB7.1 62.58,164.43 C340.1 63.79,163.23 v2(63.79,162.85) ; 49.56,141.64 v2(48.8,140.88)
  BOTTOM w0.381: v2(58.83,136.18) 60.66,136.18 v2(61.35,136.86) ; v2(45.88,139.22) 47.72,141.06 48.61,141.06 v2(48.8,140.88) ; v2(63.79,162.85) 63.66,162.72 63.66,159.04 63.88,158.81 v2(64.4,158.81) 64.5,158.71 64.5,151.39 v2(64.4,151.29) 63.76,150.65 63.76,144.58 64.4,143.95 v2(64.4,139.73)
+3VSB: length 1321.4
  TOP w0.203: U11.4 67.45,143.69 67.85,143.29 ; v3(35.08,94.57) 35.39,94.57 35.69,94.27 PCH1.AW26
  TOP w0.254: R424.2 198.28,16.42 197.11,15.25 197.11,13 196.08,11.97 195.7,11.97 194.72,10.99 v2(194.72,10.95) ; R353.2 216.79,36.48 R352.2 v2(217.74,36.32) ; v2(242.86,49.05) 242.86,49.44 241.46,50.83 v2(240.7,50.83) ; R258.2 198.44,15.27 197.96,14.8 197.96,12.67 196.25,10.95 v2(196.12,10.95) ; v2(239.81,38.01) 239.55,37.75 231.6,37.75 230.92,37.07 227.46,37.07 227,37.52 226.4,37.52 225.83,36.96 R354.2 222.25,36.96 v2(222.03,36.74)
  TOP w0.305: PCH1.AP35 39.12,89.31 39.12,88.84 v3(39.11,88.83) ; R963.2 46.52,65.22 46.13,64.83 R552.1 46.13,64.21 45.83,63.91 44.74,63.91 43.97,64.68 R561.1 ; 67.85,143.29 68.84,142.3 68.84,139.55 C330.1 69.6,138.4 R277.2 R278.2 69.6,135.92 68.89,135.21 65.08,135.21 v2(64.77,135.52) ; R244.2 12.22,70.9 12.43,70.7 14.24,70.7 v2(14.45,70.9) ; v2(57.49,130.51) 57.31,130.33 50.96,130.33 49.82,129.19 46.27,129.19 45.16,130.31 44.15,130.31 43.11,131.35 41.77,131.35 41.21,130.78 41.21,130.46 40.76,130.02 39.46,130.02 38.01,131.48 36.74,131.48 35.29,132.93 35.29,143.75 34.98,144.05 33.84,144.05 33.36,143.57 31.63,143.57 31.15,144.05 31.15,144.56 30.03,145.68 25.33,145.68 24.42,146.59 23.53,146.59 22.89,145.96 22.89,143.54
  TOP w0.356: v3(50.07,96.79) 49.65,97.21 PCH1.P20 ; PCH1.AH18 PCH1.AH20 42.56,97.16 v3(42.22,96.82) ; v3(42.22,96.82) 41.85,97.18 PCH1.AJ20 ; v3(42.22,96.82) 42.56,96.47 PCH1.AH22 ; v3(41.49,97.75) 41.14,97.4 PCH1.AK20
  TOP w0.381: v3(41.49,97.75) 41.85,97.38 PCH1.AJ20 ; v2(16.29,87.41) 16.93,88.05 R998.2 17.28,87.82 17.28,87.78 17.47,87.6 17.5,87.6 18.03,87.07 R997.2 ; v2(196.12,10.95) 196.12,9.68 v2(195.36,8.92) ; v2(45.87,72.63) 45.77,72.52 45.77,70.43 45.8,70.39 45.8,68.05 46.23,67.63 R551.1 46.74,67.53 46.74,65.89 R963.2
  TOP w0.508: v2(22.89,77.76) 22.82,77.68 20.66,77.68 ; 20.66,77.68 20.66,77 v2(18.88,75.22) ; 20.66,77.68 20.66,81.26 16.56,85.36 v2(15.29,85.36) 14.02,86.63 14.02,89.83 14.51,90.33 14.51,94.52 14.26,94.77 v2(14.26,95.41) 14.33,95.41 18.96,100.03 18.96,105.95 20.38,107.37 20.38,109.58 18.57,111.39 16.86,111.39 16.18,110.71 15.11,110.71 v2(14.89,110.93) ; R606.2 106.08,118.43 106.08,117.08 106.71,116.44 106.71,111.16 105.44,109.89 105.44,107.35 v2(105.98,106.81) ; R127.1 36.73,74.23 36.73,73.22 v2(36.8,73.15) 36.8,72.3 R224.2 R208.2 R191.2 ; R586.1 R583.1 128.22,25.53 129.19,26.5 v2(129.19,27.34) ; RJ6.1 v2(20.73,211.49) ; v2(35.36,64.32) 36.18,64.32 36.61,64.75 R222.1 ; R403.2 224.73,4.45 224.73,3.72 C436.1 ; ME_TEST.3 5.75,159.8 7.53,159.8 8.52,160.8 R181.2 ; QSW3.D 114.54,31.63 v2(115.35,32.44) ; v2(48.67,73.54) 48.67,72.17 49.72,71.12 R197.2 50.71,71.5 R211.2 ; R886.2 236.22,123.22 237.14,123.22 v2(237.9,123.98) ; R307.2 126.78,28.81 v2(126.93,28.66) ; R355.2 206.47,12.51 206.47,11.53 206.1,11.16 v2(205.2,11.16) 205.2,11.34 204.82,11.72 204.82,12.76 R942.2 ; EC29.1 108,20.12 106.48,18.6 106.48,9.27 v2(106.89,8.86) ; v2(45.96,186.88) 46.06,186.98 C354.1 48.04,185.59 v2(48.04,185.39) ; R639.2 96.54,201.07 94.6,199.13 94.6,196.02 96.27,194.34 99.35,194.34 100.36,195.36 101.25,195.36 101.25,192.44 99.73,190.91 99.09,190.91 98.71,190.53 97.95,190.53 v2(97.7,190.79) 95.89,190.79 R637.2 ; v2(228.84,17.88) 229.46,17.88 230.16,17.18 230.16,16.29 230.7,15.75 C426.1 231.14,15.78 R404.2 232.32,15.02 233.2,14.13 237.09,14.13 238.26,15.3 238.67,15.3 239.02,15.65 C425.1 241.08,15.65 v2(241.21,15.53) ; v2(15.78,188.25) 17.09,189.55 PCIE16X_2.B10 ; R420.2 R413.2 C436.1 ; R356.2 209.14,12.38 209.14,11.86 v2(209.01,11.73) ; R228.1 22.99,68.61 v2(22.99,68.18) 22.99,67.6 R227.1 ; R59.2 v2(237.87,128.3) ; R423.1 39.9,73.21 39.9,73.72 v2(39.81,73.82) 39.81,74.38 v2(39.17,75.01) 39.28,75.12 R235.1 ; R242.2 R887.2 232.86,115.48 233.59,114.74 237.42,114.74 v2(238.03,115.35) ; v2(236.51,112.05) 236.79,112.33 R996.2 ; v2(212.88,137.95) 207.55,143.29 R53.2 ; R262.2 26.86,142.11 26.45,142.53 23.4,142.53 22.89,143.03 22.89,143.54 18.96,143.54 18.05,142.64 v2(16.03,142.64) ; v2(15.4,157.89) 12.99,157.89 12.05,156.95 10.62,156.95 10.44,157.13 9.18,157.13 8.95,156.91 R185.2 8.03,156.5 v2(7.91,156.62) ; R239.2 42.28,72.63 42.28,72.6 42.5,72.38 42.5,71.43 v2(42.43,71.36) 42.9,70.88 R215.2 ; R205.2 R456.1 39.66,69.28 v2(39.66,70.01) ; v6(27.59,62.99) 27.81,63.2 32.47,63.2 v2(32.67,63.41) 32.67,63.33 33.36,62.64 33.59,62.64 R223.1 34.4,61.84 34.4,61.3 35.34,60.36 R253.2 ; v2(111.87,32.93) 111.87,33.61 111.28,34.2 R301.2 ; v2(99.85,95.28) 100.08,95.06 R591.2 ; R476.1 32.67,209.51 33.03,209.86 33.03,212.1 33.05,212.12 32.8,212.38 v2(32.04,212.38) ; C436.1 224.85,2.92 225.08,2.7 v2(227.17,2.7) ; v2(117.38,32.54) R302.2
  TOP w0.762: 84.11,188.5 84.61,188.5 85.63,187.48 v5(85.63,187.13)
  TOP w1.016: v6(93.28,25.81) 93.28,37.4 94.9,39.02 v6(94.9,46.13) ; v6(27.59,62.99) 24.25,62.99 23.34,62.07 v6(17.13,62.07) ; v6(52.74,24.54) 46.87,24.54 46.36,25.05 v6(45.5,25.05) ; C52.1 74.04,189.42 71.91,191.55 69.88,191.55 66.74,188.41 C305.1 66.04,188.25 v6(64.68,188.25) ; v6(85.61,92.23) 85.61,109.71 88.68,112.78 v6(90.08,112.78) ; v6(80.78,20.86) 77.83,20.86 76.64,19.67 v6(72.3,19.67) ; v6(18.37,29.58) 18.87,29.07 41.84,29.07 v6(43.42,27.49)
  TOP w1.524: QSW3.D 112.5,31 111.44,31 110.7,30.26 110.7,28.13 EC29.1
  BOTTOM w0.254: v2(239.81,38.01) 239.28,38.54 239.28,44.58 239.05,44.81 239.05,48.8 v1(239.94,49.69) 239.94,50.07 v2(240.7,50.83) ; v2(217.74,36.32) 217.87,36.46 221.75,36.46 v2(222.03,36.74) ; v2(196.12,10.95) v2(194.72,10.95) ; SC33.1 36.69,88.44 38.75,88.44 39.11,88.81 v3(39.11,88.83)
  BOTTOM w0.305: v3(50.07,96.79) 50.02,96.74 SC31.2 SC30.2 48.64,93.76 47.15,93.76 47.02,93.89 45.18,93.89 45.18,93.88 44.75,93.88 44.75,93.89 44.74,93.89 44.36,94.27 44.36,94.68 42.22,96.82 v3(42.22,96.82)
  BOTTOM w0.381: v2(64.77,135.52) 64.77,135.52 64.77,135.52 64.77,135.52 64.77,135.51 64.77,135.51 64.77,135.51 64.76,135.51 64.76,135.51 64.78,135.51 64.78,135.5 64.76,135.5 64.76,135.49 64.79,135.49 64.79,135.48 64.74,135.48 64.74,132.05 63.15,130.46 57.54,130.46 v2(57.49,130.51) ; v2(15.29,85.36) 16.29,86.36 v2(16.29,87.41)
  BOTTOM w0.508: v2(94.16,183.8) 94.9,183.8 98.08,186.98 98.08,190.41 v2(97.7,190.79) ; 114.97,32.44 114.99,32.42 117.25,32.42 v2(117.38,32.54) 123.22,32.54 124.11,31.66 124.87,31.66 126.78,29.75 126.78,28.81 v2(126.93,28.66) 127.45,28.14 128.39,28.14 v2(129.19,27.34) ; 114.97,32.44 112.35,32.44 v2(111.87,32.93) ; 114.97,32.44 v2(115.35,32.44) ; v2(106.89,8.86) 121.3,8.86 121.57,8.59 160.31,8.59 160.66,8.24 181.57,8.24 183.17,6.64 185.96,6.64 186.47,6.13 187.66,6.13 188.76,7.22 193.02,7.22 194.72,8.92 v2(195.36,8.92) 195.99,8.92 196.25,8.67 199.17,8.67 200.06,9.56 203.94,9.56 205.2,10.81 v2(205.2,11.16) 208.44,11.16 v2(209.01,11.73) 209.01,11.78 211.61,14.38 221.65,14.38 223.4,16.14 224.04,16.14 224.78,16.89 227.45,16.89 228.44,17.88 v2(228.84,17.88) ; v2(227.17,2.7) 228.82,1.05 240.7,1.05 243.24,3.59 243.24,15.46 ; v2(32.67,63.41) 34.45,63.41 v2(35.36,64.32) 36.23,65.18 36.23,69.63 36.8,70.21 v2(36.8,73.15) 38.66,75.01 v2(39.17,75.01) 39.17,76.26 41.31,78.39 v2(41.69,78.39) ; 243.24,15.46 243.17,15.53 v2(241.21,15.53) ; 243.24,15.46 243.24,48.67 v2(242.86,49.05) 243.24,49.44 243.24,68.18 238.92,72.5 236.11,72.5 233.13,75.48 232.04,76.57 232.04,83.37 232.9,84.23 232.9,84.75 232.52,85.13 232.52,86.95 229.78,89.69 229.78,92.36 229.39,92.74 229.39,98.46 228.3,99.55 228.3,104.4 231.3,107.4 231.3,108.62 233.26,110.57 235.03,110.57 v2(236.51,112.05) 236.51,113.82 v2(238.03,115.35) 238.41,115.73 238.41,123.48 v2(237.9,123.98) 238.16,124.24 238.16,128.02 v2(237.87,128.3) 238.28,128.72 238.28,135.03 236.51,136.81 235.87,136.81 233.46,139.22 226.47,139.22 225.91,138.67 224.14,138.67 223.43,137.95 v2(212.88,137.95) ; ME_TEST.3 5.16,157.74 5.17,157.74 5.78,157.13 7.4,157.13 v2(7.91,156.62) ; 90.41,87.41 91.98,87.41 v2(99.85,95.28) 104.32,99.75 104.32,105.16 v2(105.98,106.81) ; v3(35.08,94.57) 35.07,94.58 ; 35.07,94.58 34.51,94.58 34.5,94.57 32.85,94.57 31.99,93.71 27.73,93.71 27.02,93 24.29,93 23.15,94.14 23.15,94.67 22.33,95.49 14.33,95.49 v2(14.26,95.41) ; 35.07,94.58 35.07,95.54 SC32.1 ; v2(18.88,75.22) 18.07,75.22 14.45,71.59 v2(14.45,70.9) ; v2(14.89,110.93) 13.67,112.15 13.67,115.67 15.25,117.24 15.25,125.28 16.16,126.19 16.16,142.52 v2(16.03,142.64) 16.16,142.76 16.16,155.1 15.4,155.86 v2(15.4,157.89) 16.12,158.62 16.12,172.14 14.94,173.33 14.94,175.72 15.6,176.38 15.6,188.07 v2(15.78,188.25) 15.78,192.29 16.29,192.79 16.29,192.82 16.36,192.89 16.36,194.9 14.32,196.95 14.32,204.76 14.84,205.28 20.29,205.28 21.69,206.67 21.69,208.57 22.77,209.65 23.85,209.65 24.67,210.47 30.13,210.47 v2(32.04,212.38) 31.4,213.01 25.31,213.01 24.42,212.12 22.51,212.12 21.88,211.49 v2(20.73,211.49) ; v2(45.96,186.88) 45.28,186.2 PCI.A14 ; PCIE1X.B10 56.21,189.56 53.75,187.1 53.75,184.16 52.38,182.79 49.05,182.79 48.04,183.8 v2(48.04,185.39) ; v2(48.67,73.54) 46.78,73.54 v2(45.87,72.63) 44.43,72.63 43.16,71.36 v2(42.43,71.36) 42.37,71.36 41.03,70.01 v2(39.66,70.01) 39.81,70.16 v2(39.81,73.82)
  BOTTOM w1.016: v6(43.42,27.49) 42.45,26.52 42.45,25.05 43.59,23.91 44.36,23.91 v6(45.5,25.05) ; v6(72.3,19.67) 70.06,19.67 68.18,21.55 63.12,21.55 61.57,23.1 54.19,23.1 v6(52.74,24.54) ; 32.93,85.48 30.82,83.37 27.56,83.37 25.53,81.34 25.02,81.34 24.86,81.19 23.78,81.19 22.89,80.3 v2(22.89,77.76) 22.89,77.5 23.5,76.89 23.5,72.82 22.68,72 22.68,70.7 22.89,70.48 22.89,68.28 v2(22.99,68.18) 22.99,68.07 23.78,67.28 24.23,67.28 25.37,66.14 25.37,65.69 27.59,63.47 v6(27.59,62.99) ; v6(94.9,46.13) 92.62,48.42 92.62,53.25 91.35,54.52 91.35,60.05 88.44,62.96 88.44,73.15 89.72,74.42 89.72,85.83 90.41,86.52 90.41,90 88.17,92.23 v6(85.61,92.23) ; v6(80.78,20.86) 81.34,20.86 81.97,21.5 86.14,21.5 90.46,25.81 v6(93.28,25.81) ; v6(18.37,29.58) 16.95,31 16.95,37.85 16.11,38.69 16.11,46.52 16.36,46.77 16.36,59.71 17.13,60.48 v6(17.13,62.07)
  BOTTOM w1.524: v6(93.28,25.81) 107.62,25.81 EC29.1
  vias: v3(38.89,89.95) v3(40.37,91.22)
+5VA: length 13.2
  BOTTOM w1.016: 10.83,224.44 v1(14,224.44) 19.46,224.44 22.26,227.24 22.26,227.87
  vias: v2(9.94,224.82) v2(9.94,224.06) v2(22.38,229.52) v2(22.38,228.76)
+5VSB: length 522.9
  TOP w0.102: 81.19,51.18 C835.1
  TOP w0.305: v2(12.45,37.88) 11.18,37.88 R429.1 ; v2(12.86,32.67) 13.11,32.93 U19.5
  TOP w0.457: v2(9.3,125.89) 10.04,126.63 11.06,126.63 11.26,126.42 U13.2 ; 14.13,106.97 13.8,106.64 U12.2 v2(11.64,106.64) ; U16.2 142.2,208.64 ; U25.2 11.65,133.95 9.99,132.29 v2(9.99,131.83)
  TOP w0.508: RJ4.1 14.38,107.98 14.13,107.73 14.13,106.97 ; R648.2 102.17,188.66 102.52,189.01 v2(104.17,189.01) 104.45,189.01 105.28,189.84 R652.2 ; R614.2 82.71,49.82 81.34,51.18 81.19,51.18 ; 15.72,32.61 15.4,32.93 U19.5 ; v2(105.44,98.94) 105.93,98.94 106.68,99.7 R593.2 ; QP8.E 87.54,66.71
  TOP w0.762: v6(125.13,203.61) 126.27,204.76 133.89,204.76 134.2,204.45 139.78,204.45 142.2,206.87 142.2,208.64 ; v6(20.69,30.47) 20.56,30.59 17.73,30.59 15.72,32.61
  TOP w1.016: v6(21.24,32.42) 21.24,41.97 24.29,45.01 v6(24.29,47.91) ; v6(82.71,52.86) 83.09,52.48 84.87,52.48 85.59,53.2 85.59,54.18 ; v6(46.95,40.61) 44.61,40.61 43.97,39.97 43.97,33.69 40.75,30.47 v6(20.69,30.47) ; v6(128.18,203.49) 126.91,202.22 119.67,202.22 109.38,191.93 v2(109.38,190.66) 109.38,187.48 108.74,186.85 108.74,184.18 104.55,179.99 104.55,127.69 107.63,124.61 107.63,124.26 112.55,119.33 v6(112.55,112.68) ; v6(9.94,87.28) 9.94,84.51 8.03,82.61 8.03,75.47 10.26,73.25 17.3,73.25 v6(17.88,72.68) ; v6(91.73,75.47) 89.31,75.47 87.54,73.69 87.54,62.13 88.14,61.52 88.14,60.56 87.28,59.7 87.28,58.33 87.03,58.07 ; v6(86.39,39.78) 83.85,37.24 81.9,37.24 v6(81.59,36.94)
  BOTTOM w0.305: v2(12.86,32.67) 13.15,32.96 13.15,36.57 12.45,37.26 v2(12.45,37.88)
  BOTTOM w0.508: v2(109.38,190.66) 105.82,190.66 v2(104.17,189.01)
  BOTTOM w0.762: 9.94,106.64 v2(11.64,106.64)
  BOTTOM w1.016: v6(128.18,203.49) 125.25,203.49 v6(125.13,203.61) ; v6(21.24,32.42) 21.24,31.02 v6(20.69,30.47) ; v6(81.59,36.94) 80.7,36.05 78,36.05 77.21,36.84 71.89,36.84 71.28,36.23 64.42,36.23 63.71,35.52 52.04,35.52 v6(46.95,40.61) ; v6(9.94,87.28) 9.94,90.35 12.02,92.44 12.02,96.63 9.94,98.71 9.94,108.72 9.05,109.61 9.05,124.13 9.3,124.38 v2(9.3,125.89) 9.3,131.15 v2(9.99,131.83) ; v6(112.55,112.68) 108.36,108.49 108.36,107.47 105.44,104.55 v2(105.44,98.94) 91.09,84.59 91.09,76.11 v6(91.73,75.47) ; v6(24.29,47.91) 24.06,48.14 24.06,59.21 18.32,64.95 18.32,72.23 v6(17.88,72.68)
  BOTTOM w1.524: v6(82.71,52.86) 84.67,52.86 85.53,52 85.53,50.81 84.11,49.38 84.11,42.07 v6(86.39,39.78) 86.9,39.28 86.92,39.28 92.06,34.13 92.06,32.61 92.3,32.37 92.3,32.35 94.24,30.41 118.02,30.41 119.09,29.34 123.06,29.34 127.35,25.05 v6(138.34,25.05)
+12V: length 616.5
  TOP w0.254: R589.1 140.11,4.38 140.89,3.61 191.89,3.61 193.2,4.91 193.2,6.6 193.85,7.25 196.07,7.25 197.13,8.31 201.3,8.31 201.79,8.8 206.66,8.8 206.94,8.52 209.4,8.52 209.95,7.98 213.14,7.98 213.77,7.34 213.77,6.51 214.28,6 218.47,6 219.17,6.7 219.17,7.68 220.16,8.67 R333.1
  TOP w0.508: v2(224.82,118.9) 224.82,119.79 225.46,120.43 R891.2 ; v2(91.47,18.7) 91.38,18.8 C683.2 ; R306.2 125.64,29.88 v2(126.09,29.42) ; R589.1 139.7,4.89 139.22,5.37 v2(139.22,10.07) ; 234.98,94.27 234.44,93.73 R369.2 ; R592.2 89.82,95.85 89.82,97 R603.2 92.55,97.89 v2(93,97.44) 94.52,97.44 95.16,98.08 95.16,99.98 96.55,101.38 U32.8 ; R78.1 v2(224.44,209.2) R82.1 ; v2(13.29,144.23) 15.65,146.59 18.07,146.59 19.08,147.61 22.51,147.61 23.4,148.5 25.31,148.5 26.45,149.64 26.45,150.27 28.13,151.96 32.23,151.96 32.39,151.8 R261.2 ; v2(223.31,110.26) 223.56,110.01 233.68,110.01 EC12.1 ; v2(103.54,14) 104.05,14 104.43,13.62 C685.2 ; v2(46.71,36.42) 45.82,36.42 45.5,36.74 R908.1 ; v2(183.67,201.45) 183.55,201.33 169.02,201.33 168.72,201.63 C704.1 R798.2 ; R632.2 96.49,198.98 96.13,198.62 96.13,196.78 v2(96.3,196.61) ; v2(11.23,175.93) 11.85,175.93 13.22,177.29 13.22,184.72 9.68,188.25 9.68,202.34 10.41,203.07 C666.2 10.41,204.79 11.27,205.65 14.7,205.65 15.27,205.07 v2(15.27,204.31) ; v2(211.51,206.33) 211.51,207.7 206.76,212.46 C807.1 206.76,214.08 D29.P ; R81.1 216.06,208.46 v2(216.06,206.28) ; R379.1 120.71,183.9 121.32,183.29 v2(121.32,181.77) ; R790.1 186.34,206.79 187.14,205.99 R789.1 187.14,204.22 v2(187.23,204.12)
  TOP w0.762: QP2.E 122.33,196.12 R375.2 132.62,196.63 135.95,199.96 142.27,199.96 143.26,200.95 147.73,200.95 v2(149.38,199.3)
  BOTTOM w0.508: QP2.E 122.33,192.35 122.21,192.22 122.21,190.91 119.92,188.63 119.92,184.31 121.32,182.91 v2(121.32,181.77) ; v2(223.31,110.26) 223.31,110.28 223.33,110.3 223.33,110.87 223.31,110.89 223.31,112.42 224.82,113.93 v2(224.82,118.9) ; v2(122.28,10.22) 122.44,10.07 v2(139.22,10.07) ; v2(46.71,36.42) 47.85,35.28 47.85,31.91 48.29,31.47 49.18,31.47 49.5,31.78 68.74,31.78 70.14,30.39 75.6,30.39 76.99,31.78 81.57,31.78 v2(84.36,28.99) ; v2(15.27,204.31) 15.27,198.41 16.12,197.55 PCIE16X_2.B2 ; EC12.1 236.4,107.3 238.92,107.3 242.3,110.67 242.3,200.74 238.67,204.38 233.46,204.38 228.63,209.2 v2(224.44,209.2) ; v2(11.23,175.93) 11.23,175.78 11.72,175.29 11.72,171.87 13.11,170.48 13.11,161.77 11.72,160.37 11.72,147.89 13.29,146.31 v2(13.29,144.23)
  BOTTOM w0.762: 187.99,201.45 187.61,201.84 187.61,203.74 v2(187.23,204.12) ; 187.99,201.45 v2(183.67,201.45) 181.52,199.3 v2(149.38,199.3) ; 187.99,201.45 189.47,199.98 200.74,199.98 207.09,206.33 v2(211.51,206.33) 216.01,206.33 v2(216.06,206.28) 221.9,206.28 224.44,208.82 v2(224.44,209.2) ; QP2.E 122.14,193.33 121.36,194.11 121.36,194.3 120.48,195.18 117.2,195.18 113.57,191.55 v2(103.92,191.55)
  vias: v2(53.37,198.03) v2(54.13,198.03) v2(56.29,196.12) v2(57.06,196.88) v2(82.46,29.62) v2(82.46,26.96) v2(82.46,25.94) v2(82.46,25.05) v2(82.46,24.04) v2(82.84,33.56) v2(82.84,32.42) v2(83.98,33.56) v2(83.98,25.94) v2(83.98,25.05) v2(83.98,24.04) v2(84.36,27.34) v2(85.12,33.56) v2(85.12,32.42) v2(85.25,30.64) v2(85.88,29.88) v2(85.88,26.07) v2(87.92,106.59) v2(87.92,105.7) v2(88.17,190.53) v2(88.17,27.72) v2(88.68,191.17) v2(88.93,106.59) v2(88.93,105.7) v2(89.44,191.93) v2(89.44,191.17) v2(90.08,106.59) v2(90.71,74.07) v2(90.96,69.76) v2(90.96,66.45) v2(91.47,74.07) v2(91.73,62.14) v2(91.73,61.12) v2(93.61,110.93) v2(94.39,111.67) v2(94.37,110.93) v2(95.16,112.43) v2(95.16,111.67) v2(96.81,13.49) v2(96.81,10.95) v2(98.08,13.49) v2(98.08,10.95) v2(101.76,13.49) v2(101.76,11.08) v2(113.32,12.86) v2(113.32,11.97) v2(117.13,12.86) v2(117.13,11.97) v2(121.44,12.86) v2(121.44,11.97)
+12V_4P: length 80.9
  TOP w0.635: R883.1 150.91,188.18 v2(150.91,188.75)
  BOTTOM w0.635: v2(224.95,193.83) 223.17,192.06 217.96,192.06 214.85,195.17 161.26,195.17 153.64,187.55 152.12,187.55 v2(150.91,188.75)
  vias: v2(223.04,195.74) v2(224.95,197.64) v2(226.85,198.28) v2(226.85,195.74) v2(226.85,193.33) v2(228.25,198.28) v2(228.25,196.63) v2(228.25,194.98) v2(228.25,193.33) v2(229.78,196.63) v2(231.68,198.66) v2(231.68,194.85) v2(233.84,198.66) v2(233.84,196.63) v2(233.84,194.85) v2(236,198.66) v2(236,194.85) v2(237.78,196.63)
+12VIN:
  vias: v2(55.76,25.25) v2(57.06,25.25) v2(58.33,25.25) v2(59.85,24.42) v2(61.12,25.25) v2(62.39,25.25) v2(63.66,25.25) v2(64.42,29.12) v2(64.93,25.25) v2(65.18,33.94) v2(65.95,30.51) v2(66.58,24.67) v2(66.58,23.78) v2(66.58,22.94) v2(66.96,33.94) v2(67.47,29.12) v2(68.23,33.94) v2(69.76,34.96) v2(71.53,22.51) v2(71.66,33.69) v2(73.06,23.78) v2(73.18,35.21) v2(73.18,32.16) v2(74.71,33.69) v2(74.71,22.51) v2(78.9,29.75) v2(78.9,26.19) v2(79.53,25.05) v2(80.55,25.69) v2(80.55,24.42) v2(80.8,28.86) v2(80.8,27.21)
+A3VSB: length 17.1
  TOP w0.254: 226.85,14.76 221.21,14.76 220.98,15 U21.99
  TOP w0.508: R956.1 227.65,7.94 228,7.59 PFB8.1 229.01,7.72 228.38,8.35 228.38,8.73 228.82,9.18 228.82,10.13 C382.2 228.51,11.4 228,11.91 C381.2 227.62,12.67 227.62,14 226.85,14.76
+AVDD12: length 34.7
  TOP w0.254: 52,224.06 52.34,224.41 RLAN.58 ; RLAN.5 56.7,227.52 56.95,227.77 57.95,227.77 C473.2 ; C472.2 57.6,230.41 57.16,230.41 57.06,230.52 RLAN.11 ; RLAN.8 56.55,229.02 56.86,228.71 57.8,228.71 C492.2 ; C470.2 58.66,232.24 56.93,232.24 56.71,232.02 RLAN.14
  TOP w0.381: v2(57.31,230.99) 58.03,230.99 C472.2 ; C473.2 57.7,227.21 v2(57.31,227.21) ; C492.2 57.85,229.27 v2(57.31,229.27)
  TOP w0.508: 52,224.06 50.32,222.39 C471.2 50.75,221.74 v2(51.09,222.08) ; C470.2 58.74,232.57 58.36,232.95 v2(57.94,232.95)
  BOTTOM w0.508: SR44.2 58.52,232.38 v2(57.94,232.95) 57.31,232.32 v2(57.31,230.99) v1(57.31,230.16) v2(57.31,229.27) v2(57.31,227.21) 57.31,226.82 55.11,224.62 53.63,224.62 v2(51.09,222.08)
+DVDD12: length 88.1
  TOP w0.254: C468.2 54.13,236.28 54.13,235.62 53.34,234.83 RLAN.21 ; RLAN.38 46.51,230.52 46.11,230.92 44.7,230.92 C467.2 ; 49.05,224.06 49.34,224.35 RLAN.52 ; C469.2 44.97,235.97 46.49,234.45 47.68,234.45 47.84,234.29 RLAN.32 ; RLAN.15 56.65,232.52 57.72,233.59 C465.2 ; 47.53,223.93 47.84,224.25 RLAN.49
  TOP w0.381: C465.2 58.74,233.43 59.21,232.95 60.87,232.95 61.12,233.2 61.12,233.84 v2(60.48,234.47) ; C468.2 54.77,236.67 v2(54.77,236) ; C469.2 44.96,236.32 44.55,236.32 44.42,236.19 44.42,235.71 45.59,234.54 v2(45.59,234.47)
  TOP w0.508: C466.2 46.01,222.24 47.53,223.77 47.53,223.93 ; C466.2 C464.2 47.15,222.16 49.05,224.06 ; C466.2 v2(45.21,221.74) ; v2(60.48,234.47) 61.12,235.11 64.74,235.11 66.14,233.71 72.42,233.71 73.57,232.57 73.57,231.3 70.07,227.81 R455.2 ; C467.2 44.32,231.55 v2(44.99,231.55)
  BOTTOM w0.508: v2(45.21,221.74) 45.88,222.41 SR43.1 46.64,225.65 46.64,228.12 45.75,229.01 v1(45.75,230.16) 45.75,230.79 v2(44.99,231.55) 46.01,232.57 46.01,234.06 v2(45.59,234.47) 45.59,235.46 46.45,236.33 SR1.1 47.15,236.51 47.66,236 v2(54.77,236) 58.96,236 v2(60.48,234.47) 60.23,234.47 59.53,233.78 SR44.1
+V95820: length 34.1
  TOP w0.203: 231.54,151.13 U39.17
  TOP w0.254: 231.54,151.13 232.43,151.13 233.13,150.43 235.02,150.43 235.55,149.89 C735.1 236.81,150.13 236.81,151.43 R811.2 236.38,151.67 v2(235.62,150.91) ; v2(219.23,149.64) 219.74,150.15 R828.1 R831.1 ; v2(232.16,145.45) R858.2
  BOTTOM w0.254: v2(235.62,150.91) 235.03,150.32 235.03,147.81 v1(234.27,147.05) 232.67,145.45 v2(232.16,145.45) 230.16,145.45 229.14,146.46 225.9,146.46 222.72,149.64 v2(219.23,149.64)
+VBAT_IO: length 292.4
  TOP w0.254: v2(200.88,11.15) 200.95,11.21 C386.1 202.22,11.21 202.66,11.65 202.66,13.94 202.99,14.27 204.63,14.27 204.9,14.54 205.61,14.54 205.98,14.91 U21.69 ; v2(10.32,67.98) 9.13,69.17 8.43,69.17 8.41,69.15 R251.2 8.03,68.87 8.41,68.49 8.41,67.91 C237.2 7.59,68.36 6.26,68.36 5.62,67.72 CLR_CMOS.2
  BOTTOM w0.229: 11.08,3.99 5.82,9.24 5.82,29.01 7.42,30.61
  BOTTOM w0.254: 7.42,30.61 7.42,34.5 6.87,35.06 6.87,36.01 7.31,36.45 7.52,36.45 8.97,37.9 8.97,56.8 11.16,58.99 11.16,64.22 10.95,64.42 10.95,67.34 v2(10.32,67.98) ; v2(200.88,11.15) 199.74,11.15 198.53,9.94 196.85,9.94 196.65,10.14 189.87,10.14 189.57,10.45 187.66,10.45 186.65,9.43 185.58,9.43 185.2,9.05 183.17,9.05 182.33,9.89 161.28,9.89 160.95,10.22 144.34,10.22 140.64,13.93 112.1,13.93 110.62,12.45 102.62,12.45 102.13,11.97 90.72,11.97 88.36,14.33 85.48,14.33 84.72,13.57 84.72,13.57 84.69,13.55 77.45,13.55 73.27,9.37 73.27,9.33 73.18,9.24 73.18,4.02 72.06,2.9 63.38,2.9 59.51,6.76 54.14,6.76 51.36,3.99 11.08,3.99
+VCC: length 356.2
  TOP w0.102: L13.2 62.32,9.08 P9.1
  TOP w0.178: 50.9,31.83 50.9,32.06 U41.28
  TOP w0.254: v2(10.57,26.07) 9.95,26.69 U43.20
  TOP w0.381: v2(52.36,164.37) 51.66,163.67 PFB10.2 ; v2(196.12,3.97) 195.99,3.84 194.72,3.84 194.37,4.19 C845.1 ; 47.15,27.21 47.15,27.21 47.53,27.59 47.53,28.86 C782.2 47.28,30 49.08,30 50.9,31.83 ; R392.2 10.51,39.59 11.46,38.64 v2(12.45,38.64)
  TOP w0.508: R411.1 223.04,6.92 C433.2 224.23,6.83 v2(224.9,6.83) ; PCI.A5 45.16,197.39 C351.1 ; C726.1 v2(44.32,26.29) ; v2(235.62,103.66) 235.62,104.6 233.99,106.23 233.99,108.34 232.95,109.38 228.3,109.38 D7.N 227.21,109.35 222.74,109.35 221.72,110.37 BZ.P ; R916.2 46.61,26.92 v2(46.9,27.21) 47.15,27.21 ; v2(154.46,17.41) 154.46,19.18 155.06,19.78 R563.1 157.55,19.78 158.88,21.11 D20.2 ; D11.P 184.31,9.8 185.34,8.77 v2(185.81,8.77) 185.58,8.54 C696.2 C809.2 ; v2(10.4,178.72) 9.84,178.16 C526.2 8.28,177.7 R516.2 ; R334.1 218.06,8.26 218.6,7.72 v2(218.6,7.53) ; v2(107.35,188.5) 107.35,188.48 101.96,183.09 101.96,178.65 101.66,178.34 101.66,126.63 109.94,118.35 109.94,115.4 v2(109.13,114.59) ; v2(50.45,173.39) 50.45,174.66 46.64,178.47 44.2,178.47 42.91,179.76 39.93,179.76 PCI.B19 ; R391.2 4.02,56.61 5.35,55.28 v2(6.56,55.28) ; R385.1 v2(231.55,99.22) ; F5.1 179.97,205.77 179.99,205.77 181.64,207.42 QN22.G ; v2(239.81,153.07) 238.2,153.07 237.97,152.84 R811.1 ; v2(205.14,214.66) v2(205.14,210.6) ; v2(122.87,5.26) R808.1 ; v2(105.82,111.79) 105.7,111.67 104.71,111.67 R629.2 ; v2(46.26,192.18) 46.48,192.41 C350.1 ; v2(53.12,192.56) 53.12,192.06 54.64,190.53 54.64,188.35 55.13,187.87 56.57,187.87 v2(57.08,187.36) ; v2(16.42,102.9) 16.26,102.74 C663.2 ; QN6.G v2(224.95,219.74) 224.44,219.23 R75.2 ; QN68.G 193.49,217.04 R783.2 193.49,215.81 193.96,215.33 193.96,215.04 v2(194.09,214.92)
  TOP w1.016: v6(89.57,16.92) 89.06,17.43 89.06,18.96 91.09,20.99 95.03,20.99
  BOTTOM w0.381: v2(52.36,164.37) 52.36,171.48 v2(50.45,173.39)
  BOTTOM w0.508: v2(109.13,114.59) 108.65,114.59 105.82,111.76 v2(105.82,111.79) ; v2(17.94,109.13) 18.61,109.13 SC16.2 ; v2(50.45,173.39) 49.69,174.15 49.69,177.96 55.28,183.55 55.28,184.67 57.08,186.47 v2(57.08,187.36) ; v2(205.14,214.66) 194.34,214.66 v2(194.09,214.92) ; v2(224.95,219.74) 231.01,213.68 231.01,208.79 234.41,205.39 239.94,205.39 v2(241.4,203.93) ; v2(154.46,17.41) 154.21,17.66 149.71,17.66 v2(148.9,16.85) ; v2(122.87,5.26) 119.98,8.16 105.21,8.16 103.05,6 v2(101.82,6) ; v2(46.9,27.21) 48.61,28.93 50.52,28.93 51.47,29.88 54.01,29.88 55.28,28.61 55.28,26.58 55.79,26.07 74.79,26.07 76.82,24.04 76.84,24.04 77.76,23.12 77.76,20.86 74.71,17.81 73.46,17.81 EC57.1 ; PCI.A16 42.38,183.1 39.84,180.56 PCI.B19
  vias: v2(6.51,34.2) v2(6.51,33.43) v2(6.51,32.67) v2(9.96,135.19) v2(9.96,134.35) v2(10.88,123.37) v2(10.88,122.61) v2(13.62,103.74) v2(13.88,104.55) v2(14.41,103.74) v2(16.03,122.97) v2(16.03,122.08) v2(16.03,121.32) v2(16.03,120.56) v2(16.03,119.67) v2(16.03,118.78) v2(16.03,117.89) v2(64.04,10.83) v2(64.04,9.68) v2(64.04,8.41) v2(65.06,8.41) v2(66.71,7.53) v2(66.71,6.64) v2(67.22,13.88) v2(67.34,8.92) v2(67.34,7.02) v2(67.98,13.24) v2(68.1,10.45) v2(68.74,15.15) v2(68.74,14.26) v2(69.63,13.37) v2(95.66,8.54) v2(95.66,6) v2(97.31,8.54) v2(97.31,6) v2(101.82,8.54) v2(113.57,7.14) v2(116.62,207.42) v2(116.62,206.66) v2(116.75,7.14) v2(116.75,5.75) v2(117.38,207.42) v2(117.38,206.66) v2(117.76,7.14) v2(117.76,5.75) v2(118.14,207.42) v2(118.14,206.66) v2(121.06,5.75) v2(121.83,7.78) v2(125.38,7.78) v2(125.38,6.89) v2(141.36,211.06) v2(142.17,211.06) v2(145.32,6) v2(145.32,5.11) v2(145.32,4.22) v2(146.08,6) v2(146.08,5.11) v2(146.08,4.22) v2(146.84,6) v2(146.84,5.11) v2(146.84,4.22) v2(149.77,6) v2(149.77,5.24) v2(149.77,4.35) v2(150.65,6) v2(150.65,5.24) v2(150.65,4.35) v2(176.89,205.82) v2(205.87,210.6)
+VCC3: length 1171.7
  TOP w0.102: L14.2 57.48,51.52 58.27,51.52 P12.1
  TOP w0.178: PCH1.AW9 36.33,103.36 v3(36.02,103.66)
  TOP w0.203: v2(63.76,143.42) 63.63,143.42 62.84,142.62 U11.123 ; U11.110 57.64,139.46 56.83,138.64 55.84,138.64 55.66,138.46 C333.1 ; U11.47 59.24,155.25 58.96,154.97 v2(58.76,154.97) ; U11.35 64.04,157.51 64.42,157.89 64.8,157.89 ; v2(48.67,148.11) 48.67,147.86 48.95,147.58 49.71,147.58 50.01,147.29 U11.84 ; U11.57 55.24,157.93 ; v2(49.65,143.35) 49.71,143.29 U11.94 ; v2(49.31,152.09) U11.72
  TOP w0.254: v2(193.2,10.95) 193.2,11.01 196.02,13.82 196.02,15.91 195.51,16.42 RJ7.1 195.64,16.67 196.32,16.67 RJ17.1 ; v2(65.53,76.99) 65.53,76.97 65.4,76.84 R173.2 ; v2(115.86,34.7) 115.86,34.79 116.24,35.17 R305.2 ; v2(18.19,156.62) 15.91,156.62 15.15,155.86 15.15,153.45 13.01,151.31 R646.1 ; R196.2 R192.1 25.76,92.51 25.93,92.34 ; 231.45,26.98 U23.24 ; PCH1.AG1 42.93,108.64 42.06,109.52 42.06,110.32 40.33,112.05 v2(39.4,112.05)
  TOP w0.305: R194.1 24.35,88.71 R177.2 ; v2(52.86,135.8) 53.25,135.8 54.39,136.94 R283.2 54.55,136.97 55.5,137.92 C333.1 ; PCH1.U30 47.69,92.71 v3(47.54,92.71) 47.11,92.27 PCH1.W30 ; PCH1.AF26 43.68,93.98 44.09,93.58 v3(44.1,93.58) ; 66.93,79.41 66.78,79.56 65.69,79.56 64.95,78.82 v2(64.8,78.82) ; R282.2 51.72,136.59 51.72,136.18 v2(51.47,135.92)
  TOP w0.381: R293.1 R292.1 47.75,132.35 46.79,133.31 v2(46.31,133.31) ; RJ1.1 63.28,138.51 v2(63.05,138.28) ; C332.1 65.31,158.78 64.42,159.67 v2(64.37,159.67) ; C332.1 65.31,158.4 64.8,157.89 ; C332.1 66.9,158.72 C331.1 ; v2(53.73,163.55) PFB11.1 54.9,162.78 54.9,161.83 54.55,161.48 C349.1 54.9,160.85 54.9,159.45 ; C846.1 16.67,92.51 v2(16.67,93.96) ; v2(18.7,88.93) 17.96,88.93 C664.2
  TOP w0.508: v2(140.75,6.76) 140.75,17.56 v2(142.4,19.21) ; 68.23,81.31 71.41,84.49 v2(71.41,85.07) ; 68.23,81.31 68.76,80.78 68.76,80.22 68.08,79.53 67.06,79.53 66.93,79.41 R165.2 ; 68.23,81.31 R170.2 ; R193.2 66.77,82.96 69.17,85.36 v2(69.17,86.14) ; PCIE16X_2.B8 15.77,191.55 14.38,192.95 14.38,194.28 v2(13.75,194.91) ; 162.34,204.25 165.26,204.25 165.51,203.99 165.51,202.72 164.47,201.68 164.47,201.07 ; 162.34,204.25 162.47,204.12 MN1.G 162.47,202.12 R978.2 ; 162.34,204.25 159.67,204.25 MN2.G ; v2(229.78,121.95) 231.99,121.95 v2(232.34,122.31) ; QN21.G 148.53,206.76 R106.1 148.53,206.25 149.13,205.65 152.18,205.65 ; 85.61,87.64 84.87,86.9 75.93,86.9 v2(75.57,86.54) ; C850.2 70.04,161.04 v2(70.26,160.81) ; 54.9,159.45 54.9,159.16 55.24,158.82 55.24,157.93 ; Q7.1 101.12,201.2 100.43,200.5 C610.2 98.9,199.8 96.17,199.8 95.31,198.94 v2(95.31,196.3) ; C660.2 27.59,105.27 v2(27.95,104.91) ; R741.2 v2(207.93,37.01) ; RJ10.1 197.14,18.96 196.37,18.19 RJ9.1 196.36,17.93 195.63,17.93 v2(195.61,17.94) ; v2(86.52,65.69) 84.31,65.69 83.4,66.61 v2(83.4,66.83) ; PCIE16X_1.A10 86.31,188.25 C54.1 86.93,188.49 86.93,189.24 v2(87.21,189.52) ; v2(91.85,184.84) 91.73,184.72 R95.2 ; TPM.9 206.49,5.43 v2(206.28,5.43) ; C851.2 67.44,163.83 v2(68.23,164.62) ; 152.18,205.65 152.08,205.74 R104.1 152.08,207.52 QN20.G ; 152.18,205.65 155.73,205.65 ; R171.2 54.9,65.97 55.53,65.34 v2(55.53,64.68) 54.86,64.68 R206.2 ; v2(217.96,11.72) 217.96,12.32 R340.2 ; v2(10.38,201.2) 10.89,201.2 v2(12.61,202.92) 12.67,202.98 12.67,203.3 D34.2 ; QN23.G 155.77,207.77 R107.1 155.77,205.68 155.73,205.65 ; 155.73,205.65 158.02,203.36 MN2.G ; PCIE1X.B8 58.07,191.45 C302.1 ; v2(237.78,110.52) 238.16,110.9 238.16,113.57 237.62,114.1 234.6,114.1 ; C306.1 55.53,183.67 55.91,184.06 v2(56.29,184.06) ; MN2.G 158.78,202.38 R803.2 ; C849.2 v2(71.66,168.4) ; PCIE16X_1.B8 78.4,191.45 C53.1 ; v2(231.55,67.22) 231.91,66.86 231.91,62.42 232.95,61.38 232.95,52.74 237.27,48.42 237.65,48.42 v2(238.03,48.04) ; C848.2 71.5,174.28 v2(70.9,174.28) ; v2(237.14,28.86) 236.76,29.24 236,29.24 235.49,28.73 233.52,28.73 233.14,29.12 233.14,29.94 232.86,30.23 C429.1 232.16,30.23 230.79,28.86 230.79,27.64 231.45,26.98 ; v2(237.45,34.73) 236.48,34.73 235.49,35.72 231.99,35.72 231.53,35.26 226.17,35.26 225.8,34.9 225.77,34.9 225.76,34.91 R341.2 ; v2(64.75,136.56) 66.48,136.56 67.09,137.17 RJ2.1 ; v2(232.57,135.92) 229.5,139 223.7,139 222.66,137.95 221.27,137.95 220.03,139.19 R820.1 ; v2(105.57,20.48) 105.57,26.45 108.36,29.24 108.36,32.65 107.7,33.31 107.7,34.35 108.11,34.75 v2(109.02,34.75) 109.02,35.71 R304.2 109.64,36.63 104.45,36.63 103.87,36.05 101.3,36.05 99.85,37.5 v2(99.47,37.5) ; 234.6,114.1 233.33,114.1 232.59,114.84 231.17,114.84 230.54,114.21 228.38,114.21 v2(227.87,114.71) ; 234.6,114.1 R241.2 ; v2(62.19,38.64) 62.19,37.8 61.88,37.5 R927.2 ; C307.1 65.9,191.45 64.68,190.23 PCIE1X.A10 ; C301.1 24.04,189.55 PCIE16X_2.A10 ; PCI.A27 45.16,169.45 C348.1 ; 26.07,89.44 25.85,89.66 R177.2 ; 26.07,89.44 v2(26.07,88.93) ; 26.07,89.44 26.76,89.44 R740.1 ; C521.1 13.75,213.77 14.26,213.77 v2(14.38,213.65) ; v2(199.8,7.4) 199.8,6 v2(199.93,5.87) ; R390.2 12.17,47.69 R389.2 R397.2 14.33,47.36 D9.2 14.99,46.03 15.63,45.4 15.63,45.37 15.65,45.35 15.65,40.8 16.67,39.78 v2(17.18,39.78) ; v2(18.7,88.93) 19.21,88.93 19.62,89.35 C659.2 ; v2(28.35,211.87) 28.23,211.74 28.23,211.36 27.85,210.98 27.41,210.98 27.08,210.65 R471.2 27.5,209.17 28.04,208.63 28.04,208.12 28.48,207.68 30.13,207.68 31.27,208.82 32.98,208.82 33.69,209.53 33.69,211.2 33.94,211.46 33.94,213.65 35.08,214.79 v2(35.08,215.81) ; v2(233.33,85.58) 232.26,85.58 230.16,83.48 230.16,75.97 236.15,69.98 v2(236.15,67.22) ; C434.2 v2(209.2,9.18) 209.71,9.18 210.4,8.48 213.49,8.48 R330.1 ; R458.2 R459.2 42.32,235.87 v2(41.94,235.49) ; R136.2 28.73,87.41 v2(28.51,87.18) 27.75,86.42 R180.2 ; v2(232.06,88.84) 232.32,88.58 R378.1 ; R889.2 v2(229.27,125) ; RJ6.3 v2(18.7,211.49) ; R517.1 v2(5.72,180.91) ; R243.2 v2(229.81,101.35) ; R595.2 v2(107.6,103.54) ; v2(41.82,71.99) 41.74,71.91 41.74,69.75 R202.2 R195.2 ; QN30.D 28.99,150.27 32.19,150.27 32.37,150.1 32.47,150.1 32.99,149.58 R260.1 v2(33.94,149.51) ; RJ5.1 234.28,14.89 R406.2 236.44,15.46 C427.1 237.17,16.07 C428.1 238.44,16.07 238.79,16.42 238.79,19.78 237.27,21.31 v2(236.76,21.31) ; v5(111.41,184.44) 112.9,182.94 R370.1 ; RJ8.1 v2(196.36,21.58) ; R168.2 56.2,66.68 56.55,66.33 v2(56.67,66.33) 56.55,66.2 R172.2
  TOP w0.635: 63.28,66.58 63.91,65.95 69.25,65.95 v2(70.34,64.85)
  TOP w0.762: v2(186.34,200.57) 164.98,200.57 164.47,201.07 163.96,200.57 151.8,200.57 149.13,203.23 142.53,203.23 141.38,202.09 132.24,202.09 130.21,200.06 120.68,200.06 111.54,190.91 111.54,184.56 v5(111.41,184.44)
  BOTTOM w0.254: v2(64.8,78.82) 65.53,78.09 v2(65.53,76.99) ; v2(109.02,34.75) 109.23,34.96 113.95,34.96 113.95,34.96 115.6,34.96 v2(115.86,34.7)
  BOTTOM w0.381: v2(199.93,5.87) 194.55,5.87 192.81,4.13 185.68,4.13 184.18,5.63 152.67,5.63 151.02,7.27 144.05,7.27 143.54,6.76 v2(140.75,6.76) ; v3(28.73,97.85) 29.47,97.11 32.4,97.11 SC35.2 ; SC27.2 43.4,94.41 44.1,93.71 v3(44.1,93.58) 44.36,93.32 46.94,93.32 v3(47.54,92.71)
  BOTTOM w0.508: v2(55.53,64.68) 56.55,65.69 56.55,66.2 v2(56.67,66.33) ; v2(217.96,11.72) 217.96,12.48 217.16,13.28 213.79,13.28 212.48,11.97 212.45,11.97 210.22,9.74 209.77,9.74 v2(209.2,9.18) 208.69,8.67 201.71,8.67 200.44,7.4 v2(199.8,7.4) ; v2(41.82,71.99) 41.76,72.04 41.76,74.51 v2(41.92,74.66) 41.92,75.01 42.35,75.45 43.47,75.45 44.52,74.39 47.44,74.39 47.86,74.81 47.86,76.05 48.5,76.69 48.5,77.55 47.91,78.14 47.91,81.31 47.15,82.07 47.15,84.13 47.58,84.56 47.58,86.44 47.17,86.85 47.17,87.72 47.51,88.05 47.51,91.14 47.9,91.54 SC29.2 47.9,92.36 v3(47.54,92.71) ; v2(87.69,188.96) 88.09,189.36 88.65,189.36 95.31,196.02 v2(95.31,196.3) ; v2(5.72,180.91) 7.56,180.91 10.38,183.74 v2(10.38,201.2) 10.38,201.67 9.43,202.62 9.43,204.78 10.76,206.12 10.76,210.03 v2(14.38,213.65) 15.15,213.65 17.3,211.49 v2(18.7,211.49) 19.59,210.6 22.13,210.6 22.89,211.36 24.8,211.36 25.69,212.25 27.97,212.25 v2(28.35,211.87) ; SC52.2 26.37,94.95 v2(25.81,94.39) 25.78,94.36 SC41.2 ; v2(238.03,48.04) 238.03,44.41 238.39,44.05 238.39,37.88 238.03,37.52 238.03,35.31 v2(237.45,34.73) ; SR57.2 26.19,88.81 v2(26.07,88.93) ; v2(86.52,65.69) 86.52,62.34 89.06,59.8 89.06,53.3 88.5,52.74 88.5,51.14 96.81,42.83 96.81,39.66 98.97,37.5 v2(99.47,37.5) 99.6,37.37 v2(101.89,37.37) ; v2(232.57,135.92) 232.06,135.41 232.06,134.27 232.62,133.71 232.62,131.53 231.93,130.84 SR36.1 231.52,129.48 233.03,127.97 233.03,125.61 232.34,124.92 v2(232.34,122.31) ; v2(142.4,19.21) 139.1,19.21 138.51,19.79 136.41,19.79 135.57,18.96 107.09,18.96 v2(105.57,20.48) ; v2(39.4,112.05) SC25.1 40.2,111.56 41,110.75 41,108.97 39.99,107.96 39.99,106.98 SC26.1 ; v2(35.08,215.81) 35.54,216.26 36.68,216.26 41.18,220.76 41.18,234.6 42.07,235.49 v2(41.94,235.49) ; v2(69.17,86.14) 70.37,86.14 71.41,85.1 v2(71.41,85.07) 72.88,86.54 v2(75.57,86.54) ; SC15.2 v2(33.54,83.24) ; v2(199.93,5.87) 205.84,5.87 v2(206.28,5.43) ; v2(227.87,114.71) 229.78,116.62 v2(229.78,121.95) 230.03,122.21 230.03,124.06 229.27,124.82 v2(229.27,125) ; SR58.2 28.4,87.28 v2(28.51,87.18) ; v2(13.75,194.91) 12.67,195.99 12.67,202.85 v2(12.61,202.92) ; v2(47.53,43.09) 47.02,42.58 47.02,41.94 50.52,38.44 62.01,38.44 62.19,38.62 v2(62.19,38.64) ; v2(31.46,99.49) SC36.2 ; v6(225.2,205.9) 228.76,205.9 231.17,203.49 237.4,203.49 241.66,199.22 241.66,114.41 v2(237.78,110.52) 236.81,109.56 234.23,109.56 232.44,107.76 232.44,107.1 229.81,104.47 v2(229.81,101.35) 229.81,99.57 230.41,98.97 230.41,93.56 231.83,92.13 231.83,89.07 v2(232.06,88.84) 233.33,87.57 v2(233.33,85.58) ; v2(231.55,67.22) v2(236.15,67.22) ; v2(237.14,28.86) 237.14,27.31 236.13,26.3 236.13,22.58 236.76,21.94 v2(236.76,21.31)
  BOTTOM w0.635: v2(75.57,86.54) 75.57,85.22 73.72,83.37 73.72,68.23 v2(70.34,64.85)
  BOTTOM w0.762: v6(225.2,205.9) 223.55,204.25 212.2,204.25 211.18,205.26 207.42,205.26 201.25,199.09 187.81,199.09 v2(186.34,200.57) ; v5(111.41,184.44) 110.08,183.1 100.3,183.1 98.03,180.83 95.87,180.83 93.28,183.42 v5(93.28,185.76)
  vias: v2(28.25,92.43) v2(28.63,85.1) v2(28.63,84.31) v2(31.5,114.82) v2(33.31,110.78) v2(33.31,109.76) v2(33.94,110.27) v2(33.94,109.38) v2(40.16,52.1) v2(40.72,62.72) v2(40.67,52.74) v2(41.31,53.25) v2(49.18,48.29) v2(49.82,49.05) v2(50.58,49.82) v2(51.34,50.58) v2(55.09,51.28) v2(55.79,50.52) v2(55.79,49.44) v2(57.06,50.52) v2(57.06,49.44) v2(57.82,54.26) v2(58.9,54.26) v2(58.9,53.12) v2(59.32,192.01) v2(59.98,54.26) v2(59.98,53.12) v2(63.63,191.98) v2(94.14,103.66) v3(37.89,105.6) v3(39.15,104.76) v3(39.89,104.4) v3(41.84,102.39)
