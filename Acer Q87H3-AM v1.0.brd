# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_RX_P2: length 86.4
  TOP w0.102: v4(151.11,141.21) CPU1.E13
  TOP w0.114: PCIE16X_1.A25 83.28,172.27 83.93,172.27 84.31,172.65 91.09,172.65 91.47,173.03 v2(91.47,173.04)
  BOTTOM w0.102: v4(151.11,141.21) 151.11,141.05 151.05,140.99 150.96,140.99 150.86,141.09 150.86,143.44 149.59,144.7 149.59,145.34 148.99,145.94 148.99,146.3 149,146.31 149,146.34
  BOTTOM w0.114: 149,146.34 149,146.54 146.14,149.4 131.97,149.4 129.97,151.4 122.58,151.4 121.51,152.47 121.51,155.24 119.39,157.36 113.11,157.36 112.08,157.36 101.38,168.06 96.97,172.47 91.96,172.47 91.47,172.96 v2(91.47,173.04)
PEG_RX_P3: length 81.4
  TOP w0.102: v4(150.2,142.12) CPU1.D12
  TOP w0.114: v2(91.47,169.1) 91.07,168.7 84.35,168.7 84,168.36 84,168.36 83.2,168.36 PCIE16X_1.A29
  BOTTOM w0.102: 147.48,146.34 147.5,146.32 147.5,146.31 147.94,145.87 147.99,145.82 147.99,144.85 148.33,144.51 148.8,144.51 149.64,143.67 149.64,141.98 149.85,141.76 150.07,141.76 150.2,141.89 v4(150.2,142.12)
  BOTTOM w0.114: 147.48,146.34 145.13,148.69 131.67,148.69 129.74,150.62 122.09,150.62 116.77,155.94 111.47,155.94 98.76,168.65 91.92,168.65 v2(91.47,169.1)
PEG_RX_P4: length 80.1
  TOP w0.114: v2(91.54,163.01) 91.09,162.55 84.3,162.55 84.16,162.41 83.14,162.41 PCIE16X_1.A35 ; v4(149.28,141.21) CPU1.E11
  BOTTOM w0.102: 145.6,146.34 145.6,146.31 145.59,146.3 145.59,145.85 147.56,143.87 148.58,143.87 149,143.45 149,141.76 148.72,141.49 148.72,141.04 148.91,140.85 149.09,140.85 149.28,141.04 v4(149.28,141.21)
  BOTTOM w0.114: v2(91.54,163.01) 91.99,162.55 102.84,162.55 110.88,154.52 115.32,154.52 117.62,152.22 117.62,150.39 118.28,149.73 129.59,149.73 131.38,147.94 144.48,147.94 145.6,146.82 145.6,146.34
PEG_RX_P5: length 76.8
  TOP w0.114: v4(148.37,140.29) CPU1.F10 ; v2(91.47,159.17) 91.47,159.1 91.08,158.71 84.4,158.71 83.99,158.3 83.25,158.3 PCIE16X_1.A39
  BOTTOM w0.102: v4(148.37,140.29) 148.32,140.29 148.11,140.49 148.11,141.61 147.89,141.84 147.89,142.7 144.74,145.85 144.74,146.3 144.74,146.31 144.74,146.34
  BOTTOM w0.114: 144.74,146.34 144.74,146.58 144.1,147.23 131.07,147.23 129.39,148.9 116.52,148.9 115.55,149.87 115.55,150.55 113.29,152.81 109.76,152.81 103.93,158.65 91.41,158.65 91.32,158.73 91.32,159.02 v2(91.47,159.17)
PEG_RX_P6: length 72.8
  TOP w0.102: v4(147.45,141.21) CPU1.E9
  TOP w0.114: PCIE16X_1.A43 83.22,154.34 84,154.34 84.33,154.66 91.03,154.66 v2(91.47,155.11)
  BOTTOM w0.102: v4(147.45,141.21) 147.3,141.21 147.18,141.32 147.18,142.44 146.72,142.91 145.92,142.91 145.09,143.73 145.09,144.57 144.51,145.15 144.27,145.4 143.5,145.4 143.26,145.63 143.26,145.64 143.25,145.66
  BOTTOM w0.114: 143.25,145.66 142.43,146.48 130.81,146.48 129.11,148.18 113.99,148.18 111.31,150.86 109.56,150.86 105.87,154.54 91.55,154.54 91.4,154.69 91.4,155.03 v2(91.47,155.11)
PEG_RX_P7: length 70.1
  TOP w0.102: CPU1.F8 v4(146.54,141.21)
  TOP w0.114: PCIE16X_1.A47 83.15,150.4 84.14,150.4 84.27,150.53 91.06,150.53 v2(91.47,150.94)
  BOTTOM w0.102: v4(146.54,141.21) 146.4,141.21 146.3,141.31 146.3,141.63 144.51,143.42 144.51,144.31 144.08,144.74 142.98,144.74 142.68,145.04 142.68,145.05 142.66,145.07
  BOTTOM w0.114: 142.66,145.07 141.96,145.77 130.52,145.77 128.89,147.39 109.81,147.39 106.46,150.74 102.69,150.74 v1(102.33,151.1) 101.98,150.74 96.83,150.74 96.53,150.44 91.49,150.44 91.37,150.55 91.37,150.84 v2(91.47,150.94)
PEG_RX_P8: length 64.5
  TOP w0.102: v4(142.89,143.02) 142.98,142.93 142.98,142.78 142.78,142.58 CPU1.D3
  TOP w0.114: PCIE16X_1.A52 84.49,145.55 84.21,145.27 84.21,144.89 84.48,144.62 90.96,144.62 v2(91.47,145.13)
  BOTTOM w0.102: 141.39,143.8 141.41,143.78 141.41,143.77 142.41,142.77 142.82,142.77 142.89,142.84 v4(142.89,143.02)
  BOTTOM w0.114: 141.39,143.8 140.19,145 131.48,145 131.03,144.56 127.16,144.56 125.8,145.92 101.01,145.92 99.63,144.53 91.43,144.53 91.28,144.69 91.28,144.94 v2(91.47,145.13)
PEG_RX_P9: length 66.5
  TOP w0.102: CPU1.E4 143.34,141.66 142.89,142.11 v4(142.89,142.11)
  TOP w0.114: v2(91.47,141.19) 90.91,140.63 84.53,140.63 84.21,140.95 84.21,141.26 84.51,141.55 PCIE16X_1.A56
  BOTTOM w0.102: 140.12,142.53 140.14,142.51 140.14,142.5 140.37,142.27 141.64,142.27 142.06,141.85 142.91,141.85 142.98,141.93 142.98,142.02 142.89,142.11 v4(142.89,142.11)
  BOTTOM w0.114: v2(91.47,141.19) 91.19,140.91 91.19,140.75 91.37,140.57 98.61,140.57 102.53,144.5 123.41,144.5 125.53,142.37 130.25,142.37 132.16,144.29 138.36,144.29 140.12,142.53
PEG_RX_P10: length 68.9
  TOP w0.102: CPU1.F5 144.25,140.75 143.8,141.21 v4(143.79,141.21)
  TOP w0.114: PCIE16X_1.A60 84.52,137.55 84.18,137.22 84.18,136.91 84.46,136.63 90.96,136.63 v2(91.52,137.19)
  BOTTOM w0.102: 139.56,141.98 139.58,141.96 139.58,141.95 139.88,141.66 141.03,141.66 141.41,141.28 141.93,140.75 143.22,140.75 143.42,140.95 143.92,140.95 144,141.03 144,141.13 143.92,141.21 v4(143.79,141.21)
  BOTTOM w0.114: v2(91.52,137.19) 91.45,137.12 91.45,136.74 91.64,136.54 96.62,136.54 103.15,143.07 120.51,143.07 122.48,141.1 130.12,141.1 132.6,143.58 137.96,143.58 139.56,141.98
PEG_RX_P11: length 69.6
  TOP w0.102: v4(143.79,140.29) 143.79,140.29 143.34,139.83 CPU1.G4
  TOP w0.114: v2(91.47,133.13) 90.96,132.62 84.54,132.62 84.2,132.96 84.2,133.29 84.46,133.55 PCIE16X_1.A64
  BOTTOM w0.102: v4(143.79,140.29) 143.8,140.29 143.87,140.22 143.87,140.11 143.8,140.04 141.63,140.04 141.46,140.21 141.4,140.27 139.79,140.27 139.43,140.63 139.43,141.09 139.07,141.44 139.07,141.45 139.06,141.47
  BOTTOM w0.114: 139.06,141.47 137.65,142.87 132.91,142.87 130.44,140.39 116.4,140.39 115.83,140.96 114.75,140.96 v1(114.4,141.32) 114.04,140.96 103.05,140.96 94.62,132.53 91.33,132.53 91.19,132.67 91.19,132.85 v2(91.47,133.13)
PEG_RX_P12: length 70.2
  TOP w0.102: CPU1.H5 144.25,139.25 144.13,139.38 v4(143.79,139.38)
  TOP w0.114: PCIE16X_1.A68 84.44,129.55 84.11,129.22 84.11,128.99 84.44,128.66 90.98,128.66 v2(91.52,129.19)
  BOTTOM w0.102: v4(143.79,139.38) 143.79,139.22 143.69,139.12 143.36,139.12 143.07,138.83 142.67,138.83 142.21,139.28 141.1,139.28 140.8,139.59 139.65,139.59 138.44,140.81 138.44,140.82 138.42,140.83
  BOTTOM w0.114: v2(91.52,129.19) 91.27,128.94 91.27,128.71 91.46,128.52 92.26,128.52 94.2,130.46 95.66,130.46 96.04,130.84 v1(96.04,131.35) 96.55,131.35 98.78,133.57 100,133.57 105.4,138.97 132.82,138.97 135.46,141.6 137.65,141.6 138.42,140.83
PEG_RX_P13: length 69.6
  TOP w0.102: v4(143.79,138.46) 143.79,138.26 143.54,138.01 CPU1.J4
  TOP w0.114: PCIE16X_1.A72 84.46,125.55 84.21,125.31 84.21,124.95 84.54,124.62 90.96,124.62 v2(91.47,125.13)
  BOTTOM w0.102: 138.21,138.87 138.23,138.87 138.23,138.86 139.18,138.86 140.09,137.95 142.26,137.95 142.54,138.23 143.64,138.23 143.79,138.38 v4(143.79,138.46)
  BOTTOM w0.114: v2(91.47,125.13) 91.37,125.13 91.12,124.87 91.12,124.67 91.26,124.53 92.97,124.53 105.99,137.55 135.62,137.55 136.94,138.87 138.21,138.87
PEG_RX_P14: length 72.2
  TOP w0.102: CPU1.K5 v4(143.79,137.55)
  TOP w0.114: v2(91.55,121.07) 91.14,120.66 84.39,120.66 84.11,120.94 84.11,121.19 84.47,121.56 PCIE16X_1.A76
  BOTTOM w0.102: v4(143.79,137.55) 144.05,137.55 144.15,137.45 144.15,137.17 143.89,136.91 142.81,136.91 142.34,137.38 139.77,137.38 138.51,136.12 138.23,136.12 138.23,136.13 138.21,136.13
  BOTTOM w0.114: v2(91.55,121.07) 91.55,120.68 91.66,120.57 93.67,120.57 95.41,122.31 95.41,123.94 97.69,126.22 97.69,127.21 106.6,136.13 138.21,136.13
PEG_RX_P15: length 74
  TOP w0.102: v4(143.79,135.72) CPU1.L4
  TOP w0.114: v2(91.6,117.36) 91.22,116.97 90.81,116.97 90.46,116.62 84.39,116.62 84.08,116.92 84.08,117.18 84.46,117.56 PCIE16X_1.A80
  BOTTOM w0.102: v4(143.79,135.72) 144.03,135.72 144.15,135.59 144.15,135.35 143.86,135.06 142.98,135.06 142.21,134.3 139.36,134.3 138.96,134.7 138.24,134.7 138.23,134.7 138.21,134.7
  BOTTOM w0.114: 138.21,134.7 107.21,134.7 99.92,127.41 99.92,126.32 97.19,123.59 97.19,120.57 93.44,116.82 91.78,116.82 91.6,117 v2(91.6,117.36)
PEG_TX_C_N0: length 11.2
  TOP w0.114: PCIE16X_1.B15 80.14,182.91 79.53,182.91 79.37,182.75 79.37,182.3 80.03,181.64 83.34,181.64 84.37,182.67 87.42,182.67 87.82,183.07 C51.1
PEG_TX_C_N1: length 11.2
  TOP w0.114: PCIE16X_1.B20 79.28,178.33 79.28,179.04 79.93,179.69 83.67,179.69 84.69,178.67 87.33,178.67 C56.1
PEG_TX_C_N2: length 11.3
  TOP w0.114: PCIE16X_1.B24 79.28,174.33 79.28,175.09 79.83,175.64 83.43,175.64 84.41,174.66 87.59,174.66 87.82,174.89 C58.1
PEG_TX_C_N3: length 11.2
  TOP w0.114: C60.1 87.4,170.68 84.51,170.68 83.56,171.63 79.76,171.63 79.28,171.15 79.28,170.33 PCIE16X_1.B28
PEG_TX_C_N4: length 11.3
  TOP w0.114: PCIE16X_1.B34 79.28,164.33 79.28,165.05 79.92,165.7 83.53,165.7 84.58,164.65 87.36,164.65 87.82,165.11 C62.1
PEG_TX_C_N5: length 11.2
  TOP w0.114: C64.1 87.36,160.6 84.57,160.6 83.51,161.67 80.02,161.67 79.28,160.93 79.28,160.33 PCIE16X_1.B38
PEG_TX_C_N6: length 11.2
  TOP w0.114: C66.1 87.34,156.65 84.54,156.65 83.52,157.66 79.89,157.66 79.28,157.05 79.28,156.33 PCIE16X_1.B42
PEG_TX_C_N7: length 11.1
  TOP w0.114: PCIE16X_1.B46 79.28,152.33 79.28,152.86 80.08,153.66 83.37,153.66 84.39,152.65 87.34,152.65 C68.1
PEG_TX_C_N8: length 11.2
  TOP w0.114: PCIE16X_1.B51 80.48,146.55 79.89,147.15 79.61,147.15 79.45,146.99 79.45,146.41 80.2,145.66 83.45,145.66 84.46,146.68 87.32,146.68 87.8,147.16 C70.1
PEG_TX_C_N9: length 11.2
  TOP w0.114: PCIE16X_1.B55 79.97,143.09 79.64,143.09 79.45,142.9 79.45,142.15 79.94,141.66 83.45,141.66 84.4,142.62 87.4,142.62 C72.1
PEG_TX_C_N10: length 11.2
  TOP w0.114: C74.1 87.34,138.68 84.47,138.68 83.46,137.66 79.99,137.66 79.45,138.2 79.45,138.89 79.61,139.05 80.01,139.05 PCIE16X_1.B59
PEG_TX_C_N11: length 11.2
  TOP w0.114: PCIE16X_1.B63 80.02,135.03 79.58,135.03 79.45,134.91 79.45,134.15 79.94,133.66 83.46,133.66 84.47,134.68 87.34,134.68 C76.1
PEG_TX_C_N12: length 11.3
  TOP w0.114: PCIE16X_1.B67 79.98,131.07 79.64,131.07 79.49,130.93 79.49,129.99 79.81,129.67 83.39,129.67 84.4,130.68 87.34,130.68 C78.1
PEG_TX_C_N13: length 11.3
  TOP w0.114: C80.1 87.37,126.71 84.43,126.71 83.41,125.69 79.92,125.69 79.45,126.15 79.45,126.93 79.59,127.06 80,127.06 PCIE16X_1.B71
PEG_TX_C_N14: length 11.3
  TOP w0.114: PCIE16X_1.B75 79.91,123.15 79.66,123.15 79.49,122.98 79.49,122.12 79.92,121.7 83.36,121.7 84.33,122.68 87.4,122.68 C82.1
PEG_TX_C_N15: length 10.2
  TOP w0.114: C84.1 87.38,118.46 84.5,118.46 83.55,119.41 79.9,119.41 79.66,119.18 79.66,118.76 79.87,118.56 PCIE16X_1.B79
PEG_TX_C_P0: length 11.2
  TOP w0.114: C47.1 87.33,182.46 84.46,182.46 83.43,181.43 79.94,181.43 79.15,182.21 79.15,182.9 PCIE16X_1.B14
PEG_TX_C_P1: length 11.2
  TOP w0.114: PCIE16X_1.B19 79.97,178.02 79.66,178.02 79.49,178.19 79.49,178.95 80.02,179.47 83.59,179.47 84.6,178.45 87.33,178.45 C49.1
PEG_TX_C_P2: length 11.3
  TOP w0.114: C57.1 87.34,174.44 84.32,174.44 83.34,175.42 79.92,175.42 79.49,175 79.49,174.19 79.66,174.02 80.17,174.02 80.5,174.35 PCIE16X_1.B23
PEG_TX_C_P3: length 11.2
  TOP w0.114: PCIE16X_1.B27 79.97,170.02 79.66,170.02 79.49,170.19 79.49,171.06 79.85,171.42 83.47,171.42 84.42,170.47 87.31,170.47 C59.1
PEG_TX_C_P4: length 11.3
  TOP w0.114: PCIE16X_1.B33 80.5,164.32 80.23,164.05 79.73,164.05 79.49,164.28 79.49,164.96 80.01,165.48 83.44,165.48 84.49,164.43 87.38,164.43 C61.1
PEG_TX_C_P5: length 11.2
  TOP w0.114: PCIE16X_1.B37 79.97,160.03 79.62,160.03 79.49,160.16 79.49,160.84 80.11,161.45 83.42,161.45 84.48,160.39 87.36,160.39 C63.1
PEG_TX_C_P6: length 11.2
  TOP w0.114: PCIE16X_1.B41 80.5,156.25 80.3,156.05 79.83,156.05 79.49,156.39 79.49,156.96 79.98,157.45 83.43,157.45 84.45,156.43 87.38,156.43 C65.1
PEG_TX_C_P7: length 11.1
  TOP w0.114: PCIE16X_1.B45 80,152.05 79.74,152.05 79.49,152.3 79.49,152.77 80.17,153.45 83.28,153.45 84.3,152.43 87.59,152.43 87.82,152.2 C67.1
PEG_TX_C_P8: length 11.2
  TOP w0.114: C69.1 87.38,146.46 84.55,146.46 83.54,145.45 80.11,145.45 79.24,146.32 79.24,147.07 78.75,147.55 PCIE16X_1.B50
PEG_TX_C_P9: length 11.2
  TOP w0.114: PCIE16X_1.B54 79.24,142.82 79.24,142.06 79.85,141.45 83.54,141.45 84.49,142.4 87.31,142.4 C71.1
PEG_TX_C_P10: length 11.2
  TOP w0.114: C73.1 87.38,138.46 84.56,138.46 83.55,137.45 79.9,137.45 79.24,138.11 79.24,138.81 78.5,139.55 PCIE16X_1.B58
PEG_TX_C_P11: length 11.2
  TOP w0.114: PCIE16X_1.B62 79.24,134.82 79.24,134.06 79.85,133.45 83.55,133.45 84.56,134.46 87.38,134.46 C75.1
PEG_TX_C_P12: length 11.3
  TOP w0.114: PCIE16X_1.B66 79.28,130.78 79.28,129.91 79.72,129.46 83.48,129.46 84.49,130.46 87.38,130.46 C77.1
PEG_TX_C_P13: length 11.2
  TOP w0.114: PCIE16X_1.B70 79.24,126.82 79.24,126.06 79.83,125.47 83.5,125.47 84.52,126.49 87.35,126.49 C79.1
PEG_TX_C_P14: length 11.2
  TOP w0.114: PCIE16X_1.B74 79.28,122.78 79.28,122.03 79.83,121.48 83.45,121.48 84.42,122.46 87.31,122.46 C81.1
PEG_TX_C_P15: length 10.2
  TOP w0.114: C83.1 87.34,118.68 84.59,118.68 83.64,119.63 79.75,119.63 79.41,119.29 78.77,119.29 PCIE16X_1.B78
PEG_TX_N0: length 82.9
  TOP w0.114: C51.2 88.77,182.97 89.07,182.67 89.22,182.67 v2(89.57,183.02) ; CPU1.B12 150.65,144.58 150.77,144.7 150.95,144.7 151.21,144.96 151.21,145.68 150.95,145.94 150.95,147.82 146.96,151.81 130.78,151.81 129.26,153.33 129.26,154.1 v2(129.53,154.37)
  BOTTOM w0.114: v2(129.53,154.37) 129.23,154.67 129.23,155.6 123.69,161.13 119.22,161.13 118.59,161.77 117,161.77 v1(116.62,162.15) 116.24,161.77 113.36,161.77 92.45,182.67 89.92,182.67 v2(89.57,183.02)
PEG_TX_N1: length 82.3
  TOP w0.102: 149.13,148.62 149.14,148.61 149.14,148.6 149.16,148.58 150.31,147.43 150.31,144.09 150.06,143.84 149.91,143.84 149.74,143.67 CPU1.C11
  TOP w0.114: C56.2 88.77,178.91 89.01,178.67 89.22,178.67 v2(89.57,179.02) ; v2(125.68,155.81) 125.43,155.56 125.43,152.87 127.2,151.1 146.65,151.1 149.13,148.62
  BOTTOM w0.114: v2(89.57,179.02) 89.92,178.67 90.74,178.67 v1(91.09,179.03) 91.45,178.67 93.87,178.67 101.38,171.16 113.03,159.51 122.83,159.51 125.43,156.9 125.43,156.06 v2(125.68,155.81)
PEG_TX_N2: length 80.1
  TOP w0.102: 148.12,148.62 148.14,148.6 148.14,148.6 149.11,147.63 149.11,145.8 149.38,145.52 149.38,143.06 149.16,142.83 148.93,142.83 148.82,142.73 CPU1.D10
  TOP w0.114: 148.12,148.62 146.35,150.39 124.51,150.39 123.24,151.66 123.24,152.89 v2(123.56,153.21) ; v2(89.57,174.96) 89.22,174.61 89.06,174.61 88.77,174.89 C58.2
  BOTTOM w0.114: v2(123.56,153.21) 123.29,153.49 123.29,154.81 120.02,158.07 112.4,158.07 101.53,168.94 95.87,174.61 95.08,174.61 v1(94.65,175.04) 94.27,174.66 89.87,174.66 v2(89.57,174.96)
PEG_TX_N3: length 76.2
  TOP w0.102: CPU1.C9 147.91,143.62 148.01,143.72 148.25,143.72 148.48,143.95 148.48,144.86 148.31,145.04 148.31,145.12 148.31,147.28 147.12,148.47 147.12,148.48 147.1,148.5
  TOP w0.114: C60.2 88.77,170.94 89.11,170.61 89.22,170.61 v2(89.57,170.96) ; v2(119.94,155.04) 119.68,154.78 119.68,153.03 123.12,149.59 146.01,149.59 147.1,148.5
  BOTTOM w0.114: v2(89.57,170.96) 89.92,170.61 96.06,170.61 v1(96.43,170.97) 96.79,170.61 97.81,170.61 111.76,156.65 118.82,156.65 119.62,155.85 119.62,155.36 v2(119.94,155.04)
PEG_TX_N4: length 73.2
  TOP w0.102: CPU1.D8 146.99,142.73 147.19,142.92 147.31,142.92 147.56,143.17 147.56,144.68 147.73,144.86 147.73,146.68 145.82,148.6 145.82,148.6 145.8,148.62
  TOP w0.114: v2(89.57,164.99) 89.22,164.64 89.11,164.64 88.77,164.97 C62.2 ; v2(119.93,150.84) 119.67,150.58 119.67,149.73 120.51,148.88 145.55,148.88 145.8,148.62
  BOTTOM w0.114: v2(119.93,150.84) 119.68,151.09 119.68,151.81 116.26,155.23 111.17,155.23 101.76,164.64 93.24,164.64 v1(92.87,165.01) 92.5,164.64 89.92,164.64 v2(89.57,164.99)
PEG_TX_N5: length 70.6
  TOP w0.102: 142.78,148.17 142.81,148.17 142.81,148.16 145.14,148.16 146.86,146.45 146.86,145.64 146.64,145.42 146.64,143.97 146.41,143.75 146.18,143.75 146.08,143.64 CPU1.C7
  TOP w0.114: 142.78,148.17 117.07,148.17 115.84,149.4 115.84,152.13 115.97,152.25 v2(116.1,152.25) ; v2(89.57,160.92) 89.22,160.57 89.11,160.57 88.77,160.91 C64.2
  BOTTOM w0.114: v2(89.57,160.92) 89.87,160.62 97.89,160.62 v1(98.2,160.94) 98.57,160.57 103.81,160.57 110.58,153.8 115.02,153.8 115.54,153.28 115.78,153.04 115.78,152.58 v2(116.1,152.25)
PEG_TX_N6: length 66.3
  TOP w0.102: 142.78,147.46 142.81,147.46 142.81,147.45 144.5,147.45 145.52,146.43 145.52,145.93 145.73,145.72 145.73,144.89 145.5,144.66 145.27,144.66 145.17,144.56 CPU1.B6
  TOP w0.114: 142.78,147.46 114.33,147.46 113.74,148.05 113.74,150.15 v2(113.97,150.39) ; C66.2 88.77,156.97 89.11,156.64 89.22,156.64 v2(89.57,156.99)
  BOTTOM w0.114: v2(89.57,156.99) 89.87,156.69 96.36,156.69 v1(96.68,157) 97.05,156.64 104.79,156.64 109.38,152.05 112.81,152.05 113.65,151.21 113.65,150.71 v2(113.97,150.39)
PEG_TX_N7: length 63.9
  TOP w0.102: CPU1.C5 144.25,143.59 144.38,143.72 144.58,143.72 144.81,143.95 144.81,146.31 144.38,146.74 142.81,146.74 142.81,146.75 142.78,146.75
  TOP w0.114: v2(89.57,152.98) 89.22,152.64 89.11,152.64 88.77,152.97 C68.2 ; 142.78,146.75 112.68,146.75 111.53,147.9 111.53,148.43 v2(111.79,148.69)
  BOTTOM w0.114: v2(111.79,148.69) 111.46,149.01 111.46,149.49 110.89,150.06 109.34,150.06 106.76,152.64 95.46,152.64 v1(95.03,153.07) 94.6,152.64 89.92,152.64 v2(89.57,152.98)
PEG_TX_N8: length 57.9
  TOP w0.102: CPU1.E2 141.15,142.02 140.53,142.02 140,142.54 140,143.06 138.59,144.47 138.42,144.65 138.37,144.69 138.38,144.7 138.36,144.71
  TOP w0.114: v2(128.88,145.86) 128.58,145.56 128.58,144.97 128.99,144.56 130.53,144.56 131.35,145.38 137.69,145.38 138.36,144.71 ; C70.2 88.77,147 89.11,146.67 89.22,146.67 v2(89.57,147.02)
  BOTTOM w0.114: v2(128.88,145.86) 128.56,146.18 128.56,146.41 128.3,146.67 92.16,146.67 v1(91.73,147.1) 91.29,146.67 89.72,146.67 89.57,146.81 v2(89.57,147.02)
PEG_TX_N9: length 60.1
  TOP w0.102: 138.36,143.7 138.38,143.68 138.38,143.67 138.59,143.46 139.1,142.95 139.1,142.62 140.4,141.32 141.84,141.32 142.07,141.09 142.07,140.85 142.17,140.75 CPU1.F3
  TOP w0.114: v2(126.85,143.67) 126.52,143.35 126.52,143.02 126.8,142.74 129.92,142.74 131.57,144.39 137.66,144.39 138.36,143.7 ; v2(89.57,142.89) 89.22,142.54 89.11,142.54 88.77,142.88 C72.2
  BOTTOM w0.114: v2(89.57,142.89) 89.92,142.54 94.53,142.54 v1(94.9,142.91) 95.27,142.54 99.31,142.54 101.97,145.21 125.51,145.21 126.52,144.19 126.52,144 v2(126.85,143.67)
PEG_TX_N10: length 61.6
  TOP w0.102: 138.49,142.44 138.5,142.42 138.5,142.41 138.55,142.37 139.35,141.56 139.35,140.72 139.76,140.32 139.77,140.32 139.77,140.31 140.19,140.31 140.24,140.37 140.99,140.37 141.23,140.12 141.23,139.96 141.36,139.83 CPU1.G2
  TOP w0.114: C74.2 88.77,139 89.11,138.67 89.22,138.67 v2(89.57,139.01) ; v2(123.74,142.01) 123.53,142.01 123.41,141.89 123.41,141.37 123.72,141.07 129.76,141.07 132.37,143.67 137.25,143.67 138.49,142.44
  BOTTOM w0.114: v2(123.74,142.01) 123.42,142.34 123.42,143.07 122.7,143.78 102.85,143.78 97.73,138.67 95.71,138.67 v1(95.28,139.1) 94.85,138.67 89.92,138.67 v2(89.57,139.01)
PEG_TX_N11: length 63.4
  TOP w0.102: 138.49,141.45 138.51,141.43 138.51,141.43 138.79,141.14 138.79,140.6 139.68,139.71 140.06,139.71 140.28,139.49 141.96,139.49 142.15,139.3 142.15,139 142.22,138.92 CPU1.H3
  TOP w0.114: v2(89.57,135.01) 89.22,134.67 89.11,134.67 88.77,135 C76.2 ; 138.49,141.45 136.99,142.95 132.87,142.95 129.84,139.92 120.49,139.92 120.05,140.37 120.05,141.07 120.17,141.19 v2(120.37,141.19)
  BOTTOM w0.114: v2(89.57,135.01) 89.92,134.67 94.41,134.67 v1(94.77,135.03) 95.14,134.67 95.75,134.67 103.44,142.36 119.58,142.36 120.05,141.89 120.05,141.52 v2(120.37,141.19)
PEG_TX_N12: length 60.6
  TOP w0.102: 138.84,139.86 139.48,139.22 139.48,138.72 139.8,138.4 140.13,138.4 140.27,138.54 141.02,138.54 141.22,138.34 141.22,138.2 141.41,138.01 CPU1.J2
  TOP w0.114: C78.2 88.77,131 89.11,130.66 89.22,130.66 v2(89.57,131.01) ; v2(133.56,141.9) 133.86,141.6 137.36,141.6 138.21,140.75 138.21,140.49 138.84,139.86
  BOTTOM w0.114: v2(89.57,131.01) 89.57,130.84 89.75,130.66 92.69,130.66 93.76,131.73 94.84,131.73 98.52,135.41 99.73,135.41 100.49,136.18 v1(100.49,136.68) 101,136.68 103.99,139.68 130.79,139.68 132.73,141.62 133.29,141.62 v2(133.56,141.9)
PEG_TX_N13: length 62.1
  TOP w0.102: v2(137.32,140.49) 137.32,140.37 137.51,140.18 137.76,140.18 138.72,139.22 138.72,138.84 139.9,137.66 141.87,137.66 142.08,137.45 142.08,137.43 CPU1.K3
  TOP w0.114: C80.2 88.77,127 89.11,126.66 89.22,126.66 v2(89.57,127.01)
  BOTTOM w0.114: v2(89.57,127.01) 89.57,126.89 89.8,126.66 90.85,126.66 v1(91.22,127.03) 91.59,126.66 94.1,126.66 105.69,138.26 133.53,138.26 135.48,140.2 137.03,140.2 v2(137.32,140.49)
PEG_TX_N14: length 63.4
  TOP w0.102: CPU1.M3 142.23,135.26 142.15,135.35 142.15,135.61 141.94,135.81 139.78,135.81 139.61,135.99 139.61,137.19 139.16,137.64 138.91,137.64 v4(138.67,137.88)
  TOP w0.114: v2(89.57,122.95) 89.22,122.6 89.11,122.6 88.77,122.94 C82.2
  BOTTOM w0.114: v2(89.57,122.95) 89.92,122.6 93.07,122.6 94.9,124.44 v1(94.9,125) 95.47,125 96.74,126.27 96.74,127.28 106.29,136.84 136.33,136.84 137.13,137.64 138.42,137.64 v4(138.67,137.88)
PEG_TX_N15: length 64.8
  TOP w0.102: v4(141.97,136.63) CPU1.L2
  TOP w0.114: C84.2 88.77,118.21 89.01,118.45 89.22,118.45 v2(89.57,118.1)
  BOTTOM w0.102: v4(141.97,136.63) 141.8,136.63 141.67,136.51 141.67,136.21 141.28,135.82 139.39,135.82 138.77,135.2 138.23,135.2 138.23,135.2 138.21,135.2
  BOTTOM w0.114: 138.21,135.2 106.99,135.2 99.04,127.25 99.04,126.26 96.45,123.67 96.45,120.83 94.06,118.45 93.81,118.45 v1(93.38,118.02) 92.95,118.45 89.8,118.45 89.57,118.22 v2(89.57,118.1)
PEG_TX_P0: length 82.9
  TOP w0.114: CPU1.A12 150.65,144.97 150.71,144.91 150.86,144.91 151,145.05 151,145.59 150.73,145.85 150.73,147.73 146.87,151.59 130.69,151.59 129.04,153.25 129.04,154.21 128.88,154.37 v2(128.66,154.37) ; v2(89.57,182.11) 89.22,182.46 89.08,182.46 88.77,182.14 C47.2
  BOTTOM w0.114: v2(128.66,154.37) 128.97,154.37 129.01,154.41 129.01,155.51 123.6,160.92 119.13,160.92 118.5,161.55 115.32,161.55 v1(114.97,161.2) 114.61,161.55 113.27,161.55 92.36,182.46 89.67,182.46 89.57,182.36 v2(89.57,182.11)
PEG_TX_P1: length 82.2
  TOP w0.102: 148.97,148.47 148.99,148.46 149,148.46 149.04,148.41 150.11,147.35 150.11,144.17 149.98,144.04 149.82,144.04 149.74,144.12 CPU1.B11
  TOP w0.114: C49.2 88.77,178.21 89.02,178.45 89.22,178.45 v2(89.57,178.11) ; 148.97,148.47 148.82,148.62 146.56,150.88 127.11,150.88 125.22,152.78 125.22,155.68 125.09,155.81 v2(124.82,155.81)
  BOTTOM w0.114: v2(89.57,178.11) 89.57,178.35 89.68,178.45 92.5,178.45 v1(92.87,178.09) 93.24,178.45 93.78,178.45 101.38,170.85 112.94,159.29 122.74,159.29 125.22,156.81 125.22,155.94 125.09,155.81 v2(124.82,155.81)
PEG_TX_P2: length 80.1
  TOP w0.102: CPU1.C10 148.82,143.11 148.9,143.03 149.07,143.03 149.18,143.14 149.18,145.44 148.9,145.72 148.9,147.54 147.99,148.46 147.98,148.46 147.97,148.47
  TOP w0.114: C57.2 88.77,174.19 88.97,174.39 89.22,174.39 v2(89.57,174.04) ; v2(122.7,153.21) 122.9,153.21 123.02,153.09 123.02,151.57 124.42,150.17 146.26,150.17 147.97,148.47
  BOTTOM w0.114: v2(122.7,153.21) 122.89,153.21 123.07,153.4 123.07,154.72 119.93,157.86 112.32,157.86 101.38,168.79 95.78,174.39 93.49,174.39 v1(93.12,174.02) 92.7,174.44 89.71,174.44 89.57,174.31 v2(89.57,174.04)
PEG_TX_P3: length 76.1
  TOP w0.102: 146.95,148.34 146.96,148.33 146.97,148.33 148.1,147.2 148.1,145.2 148.1,144.95 148.28,144.78 148.28,144.04 148.17,143.92 148.01,143.92 147.91,144.03 CPU1.B9
  TOP w0.114: C59.2 88.77,170.16 89.01,170.39 89.22,170.39 v2(89.57,170.04) ; v2(119.08,155.04) 119.1,155.04 119.46,154.67 119.46,152.94 123.03,149.38 145.92,149.38 146.95,148.34
  BOTTOM w0.114: v2(89.57,170.04) 89.57,170.29 89.67,170.39 94.47,170.39 v1(94.9,169.96) 95.33,170.39 97.72,170.39 111.67,156.43 118.73,156.43 119.4,155.76 119.4,155.14 119.3,155.04 v2(119.08,155.04)
PEG_TX_P4: length 73.2
  TOP w0.102: CPU1.C8 146.99,143.18 147.05,143.13 147.22,143.13 147.35,143.26 147.35,144.76 147.53,144.94 147.53,146.6 145.67,148.46 145.66,148.46 145.65,148.47
  TOP w0.114: C61.2 88.77,164.19 89.01,164.42 89.22,164.42 v2(89.57,164.07) ; 145.65,148.47 145.46,148.67 120.42,148.67 119.45,149.64 119.45,150.72 119.33,150.84 v2(119.06,150.84)
  BOTTOM w0.114: v2(89.57,164.07) 89.57,164.3 89.69,164.42 90.79,164.42 v1(91.22,163.99) 91.65,164.42 101.67,164.42 111.08,155.01 116.17,155.01 119.46,151.72 119.46,151.04 119.27,150.84 v2(119.06,150.84)
PEG_TX_P5: length 70.6
  TOP w0.102: 142.78,147.95 142.81,147.95 142.81,147.96 145.06,147.96 146.65,146.37 146.65,145.72 146.44,145.5 146.44,144.06 146.33,143.95 146.16,143.95 146.08,144.03 CPU1.B7
  TOP w0.114: C63.2 88.77,160.12 89.01,160.36 89.22,160.36 v2(89.57,160.01) ; 142.78,147.95 116.98,147.95 115.63,149.31 115.63,152.13 115.5,152.25 v2(115.24,152.25)
  BOTTOM w0.114: v2(115.24,152.25) 115.4,152.25 115.56,152.42 115.56,152.95 114.93,153.59 110.49,153.59 103.72,160.36 97.11,160.36 v1(96.68,159.93) 96.2,160.41 89.75,160.41 89.57,160.24 v2(89.57,160.01)
PEG_TX_P6: length 66.3
  TOP w0.102: 142.78,147.24 142.81,147.24 142.81,147.25 144.41,147.25 145.32,146.34 145.32,145.84 145.52,145.64 145.52,144.97 145.41,144.86 145.28,144.86 145.17,144.98 CPU1.A6
  TOP w0.114: C65.2 88.77,156.19 89,156.42 89.22,156.42 v2(89.57,156.07) ; v2(113.11,150.39) 113.2,150.39 113.52,150.07 113.52,147.96 114.24,147.24 142.78,147.24
  BOTTOM w0.114: v2(113.11,150.39) 113.34,150.39 113.43,150.48 113.43,151.12 112.72,151.84 109.29,151.84 104.71,156.42 95.46,156.42 v1(95.03,155.99) 94.55,156.47 89.82,156.47 89.57,156.22 v2(89.57,156.07)
PEG_TX_P7: length 63.9
  TOP w0.102: CPU1.B5 144.25,144 144.33,143.92 144.5,143.92 144.61,144.03 144.61,146.22 144.29,146.54 142.81,146.54 142.81,146.53 142.78,146.53
  TOP w0.114: v2(110.92,148.69) 110.94,148.69 111.31,148.32 111.31,147.81 112.59,146.53 142.78,146.53 ; C67.2 88.77,152.17 89.02,152.42 89.22,152.42 v2(89.57,152.07)
  BOTTOM w0.114: v2(110.92,148.69) 111.09,148.69 111.25,148.85 111.25,149.4 110.8,149.84 109.25,149.84 106.67,152.42 93.75,152.42 v1(93.38,152.05) 93.01,152.42 89.57,152.42 89.47,152.32 89.47,152.18 v2(89.57,152.07)
PEG_TX_P8: length 57.7
  TOP w0.102: CPU1.E1 140.59,141.66 139.8,142.46 139.8,142.98 138.45,144.33 138.27,144.5 138.23,144.54 138.23,144.54 138.21,144.56
  TOP w0.114: v2(89.57,146.1) 89.22,146.45 89.02,146.45 88.77,146.2 C69.2 ; 138.21,144.56 137.6,145.17 131.44,145.17 130.61,144.34 128.9,144.34 128.37,144.88 128.37,145.83 128.24,145.96 127.95,145.96 v2(127.86,145.86)
  BOTTOM w0.114: v2(127.86,145.86) 128.25,145.86 128.34,145.96 128.34,146.32 128.21,146.45 93.75,146.45 v1(93.25,145.96) 92.76,146.45 89.69,146.45 89.57,146.33 v2(89.57,146.1)
PEG_TX_P9: length 60.1
  TOP w0.102: CPU1.F2 141.76,140.75 141.87,140.85 141.87,141 141.75,141.12 140.32,141.12 138.89,142.54 138.89,142.87 138.45,143.31 138.24,143.52 138.23,143.52 138.21,143.54
  TOP w0.114: v2(89.57,141.97) 89.22,142.32 89,142.32 88.77,142.09 C71.2 ; 138.21,143.54 137.57,144.18 131.66,144.18 130.01,142.53 126.72,142.53 126.31,142.93 126.31,143.35 v2(125.98,143.67)
  BOTTOM w0.114: v2(125.98,143.67) 126.19,143.67 126.31,143.8 126.31,144.1 125.42,144.99 102.06,144.99 99.4,142.32 93.81,142.32 v1(93.38,141.89) 92.95,142.32 89.69,142.32 89.57,142.2 v2(89.57,141.97)
PEG_TX_P10: length 61.7
  TOP w0.102: CPU1.G1 140.93,139.83 141.03,139.94 141.03,140.04 140.9,140.16 140.32,140.16 140.27,140.11 139.69,140.11 139.68,140.11 139.67,140.11 139.15,140.64 139.15,141.48 138.4,142.23 138.4,142.23 138.36,142.27 138.35,142.27 138.34,142.28
  TOP w0.114: C73.2 88.77,138.2 89.02,138.45 89.22,138.45 v2(89.57,138.1) ; 138.34,142.28 137.17,143.45 132.46,143.45 129.85,140.85 123.63,140.85 123.2,141.28 123.2,141.69 v2(122.88,142.01)
  BOTTOM w0.114: v2(89.57,138.1) 89.57,138.38 89.64,138.45 93.14,138.45 v1(93.63,137.95) 94.13,138.45 97.82,138.45 102.94,143.57 122.61,143.57 123.2,142.98 123.2,142.07 123.15,142.01 v2(122.88,142.01)
PEG_TX_P11: length 63.4
  TOP w0.102: 138.34,141.3 138.35,141.29 138.36,141.29 138.59,141.05 138.59,140.51 139.6,139.5 139.98,139.5 140.19,139.29 141.87,139.29 141.94,139.22 141.94,139.02 141.84,138.92 CPU1.H2
  TOP w0.114: C75.2 88.77,134.21 89.01,134.45 89.22,134.45 v2(89.57,134.1) ; v2(119.51,141.19) 119.83,140.87 119.83,140.28 120.4,139.71 129.93,139.71 132.96,142.74 136.9,142.74 138.34,141.3
  BOTTOM w0.114: v2(119.51,141.19) 119.74,141.19 119.83,141.28 119.83,141.8 119.49,142.15 103.53,142.15 95.84,134.45 93.56,134.45 v1(93.12,134.02) 92.69,134.45 89.69,134.45 89.57,134.33 v2(89.57,134.1)
PEG_TX_P12: length 60.6
  TOP w0.102: 138.69,139.71 139.28,139.12 139.28,138.63 139.71,138.2 140.21,138.2 140.35,138.34 140.93,138.34 141.02,138.25 141.02,138.11 140.91,138.01 CPU1.J1
  TOP w0.114: C77.2 88.77,130.2 89.02,130.45 89.22,130.45 v2(89.57,130.1) ; v2(133.56,141.03) 133.56,141.25 133.7,141.38 137.27,141.38 137.99,140.66 137.99,140.4 138.69,139.71
  BOTTOM w0.114: v2(133.56,141.03) 133.19,141.41 132.82,141.41 130.88,139.47 104.08,139.47 102.27,137.65 v1(102.27,137.07) 101.68,137.07 99.82,135.2 98.61,135.2 94.93,131.52 93.85,131.52 92.78,130.45 89.92,130.45 v2(89.57,130.1)
PEG_TX_P13: length 62
  TOP w0.102: CPU1.K2 141.85,137.09 141.92,137.15 141.92,137.31 141.88,137.35 141.88,137.36 141.78,137.46 139.81,137.46 138.51,138.76 138.51,139.14 137.68,139.97 137.43,139.97 137.32,139.86 v2(137.32,139.63)
  TOP w0.114: v2(89.57,126.1) 89.22,126.45 89.01,126.45 88.77,126.21 C79.2
  BOTTOM w0.114: v2(89.57,126.1) 89.92,126.45 92.56,126.45 v1(93,126.02) 93.43,126.45 94.18,126.45 105.78,138.04 133.62,138.04 135.57,139.99 136.96,139.99 v2(137.32,139.63)
PEG_TX_P14: length 63.4
  TOP w0.102: CPU1.M2 141.87,135.26 141.94,135.34 141.94,135.52 141.86,135.61 139.7,135.61 139.4,135.9 139.4,137.11 139.08,137.43 138.74,137.43 138.67,137.36 v4(138.67,137.12)
  TOP w0.114: v2(89.57,122.04) 89.22,122.38 89.01,122.38 88.77,122.15 C81.2
  BOTTOM w0.114: v4(138.67,137.12) 138.36,137.42 137.22,137.42 136.42,136.62 106.38,136.62 96.96,127.19 96.96,126.18 94.39,123.62 v1(94.39,123.1) 93.87,123.1 93.16,122.38 89.92,122.38 v2(89.57,122.04)
PEG_TX_P15: length 64.7
  TOP w0.102: v4(141.05,136.63) CPU1.L1
  TOP w0.114: v2(89.57,119.01) 89.22,118.66 89.11,118.66 88.77,119 C83.2
  BOTTOM w0.102: 138.21,135.41 138.23,135.41 138.23,135.41 138.68,135.41 139.3,136.02 141.2,136.02 141.47,136.3 141.47,136.58 141.32,136.74 141.15,136.74 141.05,136.63 v4(141.05,136.63)
  BOTTOM w0.114: 138.21,135.41 106.9,135.41 98.83,127.34 98.83,126.35 96.24,123.76 96.24,120.92 93.97,118.66 91.71,118.66 v1(91.35,119.03) 90.98,118.66 89.69,118.66 89.57,118.78 v2(89.57,119.01)
PERR_L: length 45.4
  TOP w0.127: U11.55 56.04,157.39 57.18,158.53 R976.1 56.67,159.96 56.67,160.81 57.28,161.42 57.28,164.7 56.4,165.59 47.61,165.59 45.7,163.68 44.41,163.68 43.41,164.68 41.74,164.68 40.75,163.68 39.33,163.68 38.13,164.88 35.97,164.88 v2(35.85,164.75)
  BOTTOM w0.127: PCI.B40 36.35,154.13 36.35,164.24 v2(35.85,164.75)
PEX1_100M_N: length 109.6
  TOP w0.102: v3(49.75,104.69) 49.74,104.69 49.74,104.7 49.48,104.7 PCH1.R6 ; v2(73.69,179.86) 74.15,179.86 74.35,180.07 74.35,181.77 73.46,182.66 66.83,182.66 65.06,184.44 64,184.44 63.84,184.28 63.84,184.13 64.41,183.56 PCIE1X.A14
  BOTTOM w0.102: v3(49.75,104.69) 49.96,104.9 49.96,105.66 49.56,106.05 49.56,107.48 50.72,108.63 50.72,112.63 50.69,112.66 50.69,114.36 55.15,118.82 55.15,123.24 53.88,124.51 53.88,128.66 56.8,131.58 62.39,131.58 63.68,132.88 63.68,137.76 65.21,139.28 65.21,162.59 63.84,163.96 63.84,165.16 68.63,169.96 71.1,169.96 74.3,173.16 74.3,179.99 74.12,180.17 73.9,180.17 73.69,179.97 v2(73.69,179.86)
PEX1_100M_P: length 109.5
  TOP w0.102: v3(49.74,103.94) 49.45,104.23 PCH1.R7 ; v2(74.89,179.86) 74.61,180.14 74.61,181.87 73.57,182.91 66.94,182.91 65.16,184.69 63.89,184.69 63.66,184.46 62.77,184.46 PCIE1X.A13
  BOTTOM w0.102: v3(49.74,103.94) 50.16,104.36 50.16,105.74 49.77,106.13 49.77,107.39 50.92,108.55 50.92,112.63 50.95,112.66 50.95,114.26 55.4,118.71 55.4,123.35 54.13,124.62 54.13,128.55 56.91,131.33 62.49,131.33 63.94,132.77 63.94,137.65 65.46,139.17 65.46,162.69 64.09,164.07 64.09,165.06 68.74,169.7 71.2,169.7 74.56,173.06 74.56,179.53 v2(74.89,179.86)
PEX1_RST_L: length 6.7
  TOP w0.102: R271.1 67.15,184.91 C310.1 65.86,185.87 65.4,186.33 65.23,186.5 63.78,186.5 63.41,186.87 63.41,187.83 PCIE1X.A11
PEX1_RX_N4: length 104.4
  TOP w0.102: PCH1.J11 52.55,102.11 v3(52.84,102.4) ; PCIE1X.A17 63.1,180.98 63.45,180.98 63.65,180.78 63.97,180.46 65.48,180.46 67.47,178.47 70.46,178.47 73.84,175.08 73.84,171.75 74.65,170.95 74.94,170.95 v2(75.34,170.54)
  BOTTOM w0.102: v3(52.84,102.4) 52.61,102.63 52.61,102.74 52.82,102.95 54.6,102.95 56.37,104.72 56.37,105.57 61.37,110.57 67.05,110.57 73.62,117.14 73.62,135.92 73.11,136.43 73.11,154.96 75.85,157.71 75.85,166.82 74.58,168.09 74.58,170.54 75.01,170.97 75.34,170.97 75.42,170.9 75.42,170.62 v2(75.34,170.54)
PEX1_RX_P4: length 104.3
  TOP w0.102: v2(75.34,171.46) 75.32,171.46 75.01,171.15 74.73,171.15 74.05,171.84 74.05,175.17 70.54,178.67 67.55,178.67 65.56,180.66 64.05,180.66 63.71,181.01 63.71,181.23 64.04,181.56 PCIE1X.A16 ; v3(52.08,102.4) 52.08,102.39 PCH1.L11
  BOTTOM w0.102: v2(75.34,171.46) 75.06,171.18 74.93,171.18 74.38,170.63 74.38,168 75.65,166.73 75.65,157.79 72.91,155.05 72.91,136.35 73.41,135.84 73.41,117.23 66.96,110.78 61.29,110.78 56.17,105.65 56.17,104.81 54.52,103.16 52.74,103.16 52.41,102.83 52.41,102.73 v3(52.08,102.4)
PEX1_TX_N4: length 104.6
  TOP w0.102: v2(63.35,111.41) 63.15,111.61 63,111.61 62.88,111.5 62.88,109.84 60.15,107.11 60.15,106.6 57.46,103.91 56.62,103.91 PCH1.B8 ; C292.2 55.25,178.09 55.25,177.82 56.94,176.13 71.36,176.13 73.31,174.18 73.31,171.2 74.96,169.55 74.96,167.71 76.05,166.61 76.05,161.24 75.55,160.74 74.43,160.74 v2(74.07,160.38)
  BOTTOM w0.102: v2(63.35,111.41) 63.29,111.41 62.95,111.75 62.95,112.2 64.64,113.89 64.99,113.89 66.96,115.86 66.96,116.84 68.7,118.57 v1(69.25,118.57) 69.25,119.12 72.24,122.12 72.24,135.35 71.74,135.86 71.74,155.63 74.1,158 74.1,159.17 73.39,159.88 73.39,160.6 73.52,160.74 73.8,160.74 74.07,160.47 v2(74.07,160.38)
PEX1_TX_P4: length 104.7
  TOP w0.102: v2(62.4,111.41) 62.68,111.13 62.68,109.92 59.95,107.19 59.95,106.69 57.38,104.12 56.39,104.12 55.99,103.72 PCH1.C8 ; C290.2 54.92,178.5 55.05,178.37 55.05,177.73 56.85,175.93 71.28,175.93 73.11,174.1 73.11,171.12 74.76,169.47 74.76,167.62 75.85,166.53 75.85,161.32 75.47,160.94 74.43,160.94 v2(74.07,161.3)
  BOTTOM w0.102: v2(62.4,111.41) 62.62,111.41 62.75,111.54 62.75,112.28 64.55,114.09 64.91,114.09 66.76,115.94 66.76,116.92 67.34,117.51 v1(67.34,118.02) 67.85,118.02 72.04,122.21 72.04,135.27 71.53,135.78 71.53,155.72 73.9,158.08 73.9,159.09 73.18,159.8 73.18,160.69 73.44,160.94 73.72,160.94 v2(74.07,161.3)
PEX4_100M_N: length 147.9
  TOP w0.102: v3(45.64,103.94) 45.94,104.23 PCH1.AA7 ; v2(69.83,173.44) 69.55,173.72 69.1,173.72 68.16,174.66 56.06,174.66 53.5,177.22 53.5,180.78 49.82,184.46 49.82,188.52 48.82,189.52 47.28,189.52 45.75,191.04 44.4,191.04 43.13,189.77 41.71,189.77 40.44,191.04 39.13,191.04 37.98,189.9 36.48,189.9 33.81,187.23 33.81,184.97 32.4,183.55 27.74,183.55 27.36,183.93 25.05,183.93 24.54,184.44 23.37,184.44 23.17,184.24 23.17,184.06 23.67,183.55 PCIE16X_2.A14
  BOTTOM w0.102: v2(69.83,173.44) 69.63,173.64 68.94,173.64 61.32,166.02 61.32,157.17 62.16,156.33 62.16,153.23 61.32,152.39 61.32,141.08 57.11,136.86 57.11,136.14 50.81,129.85 50.81,123.85 49.69,122.74 49.69,117.94 47.48,115.73 47.48,111.97 45.24,109.74 45.24,107.83 46.05,107.02 46.05,104.35 v3(45.64,103.94)
PEX4_100M_P: length 147.9
  TOP w0.102: PCH1.AA6 45.86,104.94 45.64,104.72 v3(45.64,104.7) ; v2(69.83,174.35) 69.83,174.2 69.6,173.97 69.21,173.97 68.27,174.91 56.17,174.91 53.75,177.32 53.75,180.88 50.07,184.56 50.07,188.63 48.93,189.77 47.38,189.77 45.86,191.29 44.29,191.29 43.02,190.02 41.82,190.02 40.55,191.29 39.02,191.29 37.88,190.15 36.38,190.15 33.56,187.34 33.56,185.07 32.29,183.8 27.85,183.8 27.46,184.18 25.16,184.18 24.65,184.69 23.27,184.69 22.96,184.39 22.2,184.39 PCIE16X_2.A13
  BOTTOM w0.102: v2(69.83,174.35) 69.83,174.07 69.65,173.9 68.84,173.9 61.07,166.13 61.07,157.06 61.91,156.22 61.91,153.33 61.07,152.49 61.07,141.18 56.85,136.97 56.85,136.25 50.55,129.95 50.55,123.96 49.44,122.84 49.44,118.04 47.23,115.83 47.23,112.08 44.99,109.84 44.99,107.72 45.8,106.92 45.8,104.85 v3(45.64,104.7)
PEX4_RST_L: length 6.9
  TOP w0.102: R270.1 C299.1 25.31,184.94 24.8,185.45 24.8,186.21 22.46,188.55 PCIE16X_2.A11
PEX4_RX_N5: length 138
  TOP w0.102: v2(71.74,165.64) 72.13,166.03 72.13,166.65 72.6,167.12 72.6,168.73 69.93,171.41 69.22,171.41 67.42,173.21 55.2,173.21 51.85,176.56 51.85,179.63 45.41,186.06 44.33,186.06 43.09,184.82 41.75,184.82 40.43,186.14 39.33,186.14 38.01,184.82 35.88,184.82 32.78,181.72 28.08,181.72 27.24,180.88 25.09,180.88 24.63,180.42 23.56,180.42 22.95,181.03 22.51,181.03 PCIE16X_2.A17 ; v3(53.58,103.62) 53.52,103.59 53.52,103.03 PCH1.G9
  BOTTOM w0.102: v3(53.58,103.62) 53.75,103.62 54.69,104.56 54.69,105.18 54.45,105.42 54.45,108.22 57.55,111.31 57.55,112.89 69.3,124.63 69.3,134.13 68.79,134.64 68.79,160.9 71.97,164.07 71.97,165.41 v2(71.74,165.64)
PEX4_RX_N6: length 127.5
  TOP w0.102: PCIE16X_2.A22 23.97,175.5 23.3,175.5 23.1,175.7 23.1,176.06 23.47,176.44 27.85,176.44 28.73,175.55 35.12,175.55 36.77,177.2 38.01,177.2 39.23,175.98 40.6,175.98 41.87,177.25 42.87,177.25 44.14,175.98 45.92,175.98 51.31,170.59 66.02,170.59 68.26,168.36 68.65,168.36 69.08,167.93 v2(69.08,167.88) ; v3(54.21,104.72) 54.03,104.54 54.03,104.18 PCH1.F7
  BOTTOM w0.102: v2(69.08,167.88) 69.27,168.07 69.27,168.28 69.2,168.36 68.49,168.36 68.31,168.17 68.31,166.87 70.59,164.58 70.59,163.43 68.31,161.14 68.31,134.44 68.82,133.93 68.82,124.85 57.06,113.09 57.06,111.25 54.04,108.24 54.04,104.89 v3(54.21,104.72)
PEX4_RX_N7: length 121.8
  TOP w0.102: PCIE16X_2.A26 23.88,171.41 23.25,171.41 23.04,171.61 23.04,172.01 23.53,172.5 27.97,172.5 28.3,172.17 37.76,172.17 39.03,170.9 40.5,170.9 41.77,172.17 42.87,172.17 44.14,170.9 48.59,170.9 50.37,169.12 65.48,169.12 68.99,165.61 68.99,164.17 v2(68.56,163.74) ; v3(52.24,104.92) 51.95,104.62 PCH1.K6
  BOTTOM w0.102: v3(52.24,104.92) 52.24,104.73 52.36,104.62 52.67,104.62 52.78,104.72 52.78,105.4 52.38,105.8 52.38,106.83 53.28,107.73 53.28,108.65 56.17,111.54 56.17,113.47 67.93,125.23 67.93,133.56 67.42,134.07 67.42,161.69 68.94,163.21 68.94,163.56 68.76,163.74 v2(68.56,163.74)
PEX4_RX_N8: length 115.4
  TOP w0.102: v2(53.97,110.21) 53.97,110.37 53.88,110.46 53.63,110.46 53.5,110.33 53.5,109.51 52.53,108.53 52.53,107.32 52.47,107.27 PCH1.J2 ; PCIE16X_2.A30 23.61,167.98 23.17,167.98 23,167.81 23,167.31 23.65,166.66 26.79,166.66 27.37,167.24 37.93,167.24 39.15,166.02 40.44,166.02 41.71,167.29 42.95,167.29 44.27,165.97 45.67,165.97 47.5,167.8 64.29,167.8 65.67,166.42 65.67,165.15 v2(66.07,164.75)
  BOTTOM w0.102: v2(66.07,164.75) 65.74,164.42 65.74,163.72 66.22,163.24 66.22,138.51 65.82,138.11 65.82,134.02 66.76,133.08 66.76,125.71 54.9,113.85 54.9,113.32 53.5,111.92 53.5,110.4 53.69,110.21 v2(53.97,110.21)
PEX4_RX_P5: length 138
  TOP w0.102: v3(54.34,103.63) 54.28,103.57 PCH1.F9 ; v2(72.65,165.64) 72.33,165.96 72.33,166.56 72.8,167.04 72.8,168.82 70.01,171.61 69.31,171.61 67.5,173.41 55.29,173.41 52.05,176.65 52.05,179.71 45.5,186.27 44.25,186.27 43,185.02 41.84,185.02 40.52,186.34 39.24,186.34 37.92,185.02 35.8,185.02 32.7,181.92 28,181.92 27.16,181.08 25,181.08 24.54,180.63 23.64,180.63 23.22,181.05 23.22,181.34 23.44,181.55 PCIE16X_2.A16
  BOTTOM w0.102: v3(54.34,103.63) 54.34,103.91 54.9,104.47 54.9,105.27 54.66,105.51 54.66,108.13 57.75,111.23 57.75,112.8 69.5,124.55 69.5,134.22 68.99,134.72 68.99,160.81 72.17,163.99 72.17,165.49 72.32,165.64 v2(72.65,165.64)
PEX4_RX_P6: length 127.4
  TOP w0.102: v3(53.41,104.36) 53.27,104.22 52.9,104.22 PCH1.H7 ; v2(69.08,168.84) 68.85,168.61 68.29,168.61 66.11,170.8 51.39,170.8 46.01,176.18 44.23,176.18 42.96,177.45 41.78,177.45 40.51,176.18 39.32,176.18 38.1,177.4 36.68,177.4 35.03,175.75 28.82,175.75 27.93,176.64 23.39,176.64 22.85,176.11 22.48,176.11 PCIE16X_2.A21
  BOTTOM w0.102: v2(69.08,168.84) 68.8,168.56 68.41,168.56 68.1,168.26 68.1,166.78 70.39,164.5 70.39,163.52 68.1,161.23 68.1,134.35 68.61,133.85 68.61,124.93 56.85,113.17 56.85,111.34 53.84,108.32 53.84,105.01 53.81,104.97 53.77,104.9 v3(53.41,104.36)
PEX4_RX_P7: length 121.9
  TOP w0.102: v2(69.48,163.74) 69.2,164.01 69.2,165.69 65.56,169.32 50.45,169.32 48.67,171.1 44.23,171.1 42.96,172.37 41.69,172.37 40.42,171.1 39.11,171.1 37.84,172.37 28.39,172.37 28.06,172.7 23.45,172.7 22.84,172.09 22.49,172.09 PCIE16X_2.A25 ; v3(52.24,104.16) 51.95,103.86 PCH1.K8
  BOTTOM w0.102: v3(52.24,104.16) 52.5,104.41 52.76,104.41 52.98,104.64 52.98,105.48 52.58,105.88 52.58,106.75 53.48,107.65 53.48,108.57 56.37,111.45 56.37,113.38 68.13,125.14 68.13,133.65 67.62,134.15 67.62,161.6 69.15,163.13 69.15,163.41 v2(69.48,163.74)
PEX4_RX_P8: length 115.5
  TOP w0.102: v2(65.16,164.75) 65.47,165.06 65.47,166.33 64.21,167.6 47.58,167.6 45.75,165.77 44.19,165.77 42.87,167.09 41.8,167.09 40.53,165.82 39.06,165.82 37.84,167.04 27.46,167.04 26.87,166.45 23.57,166.45 22.8,167.23 22.8,168.18 22.42,168.55 PCIE16X_2.A29 ; v2(53.02,110.21) 53.3,109.93 53.3,109.59 52.32,108.62 52.32,107.41 52.16,107.25 52.16,106.96 52.38,106.74 PCH1.J3
  BOTTOM w0.102: v2(53.02,110.21) 53.3,110.48 53.3,112 54.69,113.4 54.69,113.93 66.56,125.8 66.56,132.99 65.62,133.93 65.62,138.19 66.02,138.6 66.02,163.15 65.54,163.63 65.54,164.62 65.41,164.75 v2(65.16,164.75)
PEX4_TX_N5: length 138.3
  TOP w0.102: v2(73.13,164.5) 73.46,164.83 73.46,168.88 70.18,172.17 69.45,172.17 67.72,173.9 55.62,173.9 52.66,176.86 52.66,180.48 49.05,184.09 49.05,187.58 47.88,188.75 44.52,188.75 43.17,187.41 41.73,187.41 40.51,188.63 39.18,188.63 37.96,187.41 36.57,187.41 34.78,185.62 34.78,184.73 32.5,182.46 26.9,182.46 26.8,182.35 C291.2 ; PCH1.B7 56.33,104.35 56.8,104.81 57.31,104.81 59.24,106.74 59.24,107.47 60.8,109.03 60.8,111.13 v2(60.52,111.41)
  BOTTOM w0.102: v2(60.52,111.41) 60.61,111.41 60.87,111.67 60.87,112.97 62.63,114.73 63.42,114.73 64.04,115.35 v1(64.04,115.86) 64.55,115.86 66.07,117.38 66.07,118.4 71.36,123.68 71.36,134.98 70.85,135.49 70.85,156.07 73.14,158.36 73.14,158.83 72.47,159.49 72.47,161.15 72.96,161.64 72.96,162.92 73.49,163.46 73.49,164.14 v2(73.13,164.5)
PEX4_TX_N6: length 131.7
  TOP w0.102: v2(56.8,109.51) 56.8,109.38 56.55,109.13 55.15,109.13 54.43,108.41 54.43,107.77 PCH1.E1 ; v2(71.1,158.63) 71.51,158.63 71.69,158.81 71.69,159.6 72.73,160.64 72.73,163.22 70.8,165.15 70.8,166.04 69.93,166.9 69.93,169.7 67.14,172.5 54.61,172.5 46.13,180.97 46.13,183.04 45.63,183.55 44.48,183.55 43.21,182.28 41.84,182.28 40.55,183.57 39.2,183.57 37.93,182.3 36.86,182.3 36.05,181.49 36.05,177.78 35.39,177.12 32.11,177.12 v1(31.76,176.77) 31.4,177.12 28.94,177.12 27.68,178.38 27.1,178.38 26.8,178.08 C294.2
  BOTTOM w0.102: v2(71.1,158.63) 71.56,158.63 71.69,158.5 71.69,158.05 70.16,156.53 70.16,135.21 70.67,134.7 70.67,123.98 59.63,112.95 59.63,110.12 58.72,109.2 57.11,109.2 v2(56.8,109.51)
PEX4_TX_N7: length 120.9
  TOP w0.102: v2(71.89,161.7) 71.53,162.06 71.53,163.44 70.14,164.84 70.14,165.77 65.82,170.09 50.83,170.09 47.28,173.64 44.24,173.64 43.02,174.86 41.55,174.86 40.28,173.59 39.23,173.59 37.91,174.91 35.74,174.91 35.03,174.2 32.67,174.2 v1(32.32,174.56) 31.96,174.2 29.07,174.2 28.46,174.81 27.15,174.81 C296.2 ; PCH1.G3 53.63,106.48 53.63,106.93 53.59,106.98 53.59,107.24 53.75,107.39 53.75,108.23 55.71,110.19 58.63,110.19 58.78,110.04 58.78,109.81 58.67,109.7 v2(58.39,109.7)
  BOTTOM w0.102: v2(71.89,161.7) 71.53,161.35 71.53,160.18 69.68,158.33 69.68,135.01 70.19,134.5 70.19,124.26 59.15,113.23 59.15,110.3 58.92,110.07 58.57,110.07 58.39,109.89 v2(58.39,109.7)
PEX4_TX_N8: length 110.8
  TOP w0.102: PCH1.H2 52.84,107.01 52.84,108.37 54.69,110.23 54.69,111.36 v2(54.41,111.64) ; C298.2 26.8,170.1 27.07,170.38 28.32,170.38 29.12,169.58 30.36,169.58 v1(30.72,169.22) 31.07,169.58 38.02,169.58 39.24,168.36 40.43,168.36 41.7,169.63 43.09,169.63 44.36,168.36 65.16,168.36 67.27,166.25 67.27,165.59 67.15,165.47 v2(66.91,165.47)
  BOTTOM w0.102: v2(54.41,111.64) 54.67,111.64 54.9,111.87 54.9,112.52 55.48,113.11 55.48,113.75 67.24,125.51 67.24,133.28 66.73,133.79 66.73,162.65 67.27,163.18 67.27,165.12 v2(66.91,165.47)
PEX4_TX_P5: length 138.4
  TOP w0.102: v2(74.05,164.5) 73.67,164.88 73.67,168.97 70.26,172.37 69.54,172.37 67.81,174.1 55.71,174.1 52.86,176.94 52.86,180.56 49.26,184.17 49.26,187.66 47.96,188.96 44.43,188.96 43.09,187.61 41.82,187.61 40.6,188.83 39.1,188.83 37.88,187.61 36.48,187.61 34.58,185.71 34.58,184.82 32.42,182.66 27.18,182.66 C289.2 ; v2(61.53,111.41) 61.53,111.46 61.32,111.67 61.14,111.67 61.01,111.53 61.01,108.95 59.44,107.39 59.44,106.65 57.39,104.6 57.1,104.6 PCH1.A7
  BOTTOM w0.102: v2(61.53,111.41) 61.41,111.41 61.07,111.75 61.07,112.88 62.71,114.53 63.51,114.53 65.22,116.24 v1(65.82,116.24) 65.82,116.84 66.28,117.3 66.28,118.31 71.56,123.6 71.56,135.07 71.05,135.58 71.05,155.99 73.34,158.28 73.34,158.91 72.68,159.58 72.68,161.07 73.16,161.55 73.16,162.84 73.69,163.37 73.69,164.14 v2(74.05,164.5)
PEX4_TX_P6: length 131.9
  TOP w0.102: PCH1.D2 54.64,107.27 54.64,108.32 55.23,108.92 56.62,108.92 v2(56.8,108.74) ; v2(72.24,158.63) 71.89,158.99 71.89,159.52 72.93,160.56 72.93,163.3 71,165.23 71,166.12 70.14,166.99 70.14,169.79 67.22,172.7 54.69,172.7 46.34,181.06 46.34,183.12 45.71,183.75 44.4,183.75 43.13,182.48 41.93,182.48 40.63,183.78 39.11,183.78 37.84,182.51 36.78,182.51 35.85,181.57 35.85,177.87 35.3,177.32 30.61,177.32 v1(30.23,177.71) 29.85,177.32 29.02,177.32 27.76,178.58 27.32,178.58 C293.2
  BOTTOM w0.102: v2(72.24,158.63) 71.89,158.27 71.89,157.97 70.37,156.45 70.37,135.29 70.87,134.78 70.87,123.9 59.84,112.86 59.84,110.03 58.8,109 57.06,109 v2(56.8,108.74)
PEX4_TX_P7: length 120.8
  TOP w0.102: PCH1.G5 53.83,105.85 53.43,106.25 53.43,106.85 53.39,106.89 53.39,107.32 53.54,107.48 53.54,108.31 55.62,110.4 58.14,110.4 v2(58.39,110.65) ; v2(70.97,161.7) 71.15,161.7 71.33,161.88 71.33,163.35 69.93,164.75 69.93,165.68 65.73,169.88 50.75,169.88 47.19,173.44 44.15,173.44 42.93,174.66 41.64,174.66 40.37,173.39 39.15,173.39 37.83,174.71 35.82,174.71 35.11,174 31.17,174 v1(30.82,173.64) 30.46,174 28.99,174 28.38,174.61 27.13,174.61 26.8,174.27 C295.2
  BOTTOM w0.102: v2(70.97,161.7) 71.18,161.7 71.33,161.55 71.33,160.26 69.48,158.41 69.48,134.92 69.98,134.42 69.98,124.35 58.95,113.31 58.95,110.38 58.83,110.27 58.58,110.27 58.39,110.46 v2(58.39,110.65)
PEX4_TX_P8: length 110.8
  TOP w0.102: v2(55.47,111.64) 55.47,111.79 55.26,112 55.05,112 54.9,111.84 54.9,110.14 53.04,108.29 53.04,107.78 PCH1.H1 ; C297.2 27.19,170.58 28.4,170.58 29.2,169.78 31.96,169.78 v1(32.32,170.14) 32.67,169.78 38.11,169.78 39.33,168.56 40.35,168.56 41.62,169.83 43.17,169.83 44.44,168.56 65.25,168.56 67.47,166.34 67.47,165.83 v2(67.83,165.47)
  BOTTOM w0.102: v2(67.83,165.47) 67.63,165.47 67.47,165.31 67.47,163.1 66.94,162.57 66.94,133.87 67.44,133.36 67.44,125.43 55.68,113.67 55.68,113.02 55.1,112.44 55.1,111.84 55.3,111.64 v2(55.47,111.64)
PEX16_100M_N: length 108.8
  TOP w0.102: PCH1.AA3 46.16,106.63 46.51,106.99 46.51,107.3 46.51,107.3 46.28,107.54 46.28,109.11 46.86,109.69 46.86,113.84 54.01,120.99 54.01,121.5 v2(54.21,121.7) ; PCIE16X_1.A14 84.63,183.93 84.01,183.93 83.5,183.42 80.06,183.42 79.05,184.44 77.76,184.44 77.38,184.82 76.34,184.82 75.72,184.2 75.72,183.85 v2(76.05,183.52)
  BOTTOM w0.102: v2(54.21,121.7) 53.96,121.95 53.96,123.48 53.25,124.19 53.25,128.83 56.63,132.21 62.19,132.21 63.13,133.15 63.13,136.82 62.24,137.7 62.24,139.42 62.95,140.14 62.95,151.54 63.79,152.38 63.79,152.55 63.79,157 62.95,157.84 62.95,165.18 68.36,170.59 70.92,170.59 72.85,172.52 72.85,180.52 73.67,181.34 74.64,181.34 75.65,182.35 75.65,183.4 75.78,183.52 v2(76.05,183.52)
PEX16_100M_P: length 108.8
  TOP w0.102: v2(53.3,121.7) 53.3,121.95 53.45,122.1 53.63,122.1 53.75,121.98 53.75,121.09 46.61,113.95 46.61,109.73 46.07,109.19 46.07,107.41 46.21,107.27 PCH1.AA2 ; PCIE16X_1.A13 83.4,184.55 83.73,184.23 83.73,184 83.4,183.67 80.17,183.67 79.15,184.69 77.86,184.69 77.48,185.07 76.23,185.07 75.47,184.31 75.47,183.85 v2(75.14,183.52)
  BOTTOM w0.102: v2(75.14,183.52) 75.39,183.27 75.39,182.46 74.53,181.59 73.56,181.59 72.6,180.63 72.6,172.63 70.82,170.85 68.25,170.85 62.69,165.29 62.69,157.74 63.53,156.9 63.53,153.33 63.53,153.33 63.53,152.66 63.53,152.66 63.53,152.49 62.69,151.65 62.69,140.24 61.98,139.53 61.98,137.6 62.87,136.71 62.87,133.26 62.08,132.47 56.53,132.47 52.99,128.93 52.99,124.08 53.7,123.37 53.7,121.9 53.5,121.7 v2(53.3,121.7)
PEX16_RST: length 6.2
  TOP w0.102: R98.1 87.47,185.67 R96.1 R95.1 88.96,185.83 89.72,185.83 v1(89.87,185.99) 90.02,185.83 D23.3
PEX16_RST_L: length 6.1
  TOP w0.102: R98.2 86.88,186.03 86.88,186.65 C50.1 86.27,186.44 85.11,186.44 PCIE16X_1.A11
PHASE1: length 124.7
  TOP w0.127: P1.2 163.55,177.45 L8.1
  TOP w0.203: 233.36,152.2 233.08,151.93 U39.19
  TOP w0.635: R821.2 160.69,181.01 v2(160.56,181.13) ; v2(234.6,179.9) 238.01,176.49 238.01,161.87 C739.1 236.63,161.39 236.25,161.01 236.25,154.44 234.02,152.2 233.36,152.2
  BOTTOM w0.635: v2(234.6,179.9) 227.47,187.03 215.12,187.03 212.54,189.61 161.92,189.61 159.54,187.23 v2(159.54,183.67)
  vias: v2(156.5,183.67) v2(156.62,174.4) v2(157.13,177.2) v2(157.51,183.67) v2(158.53,183.67) v2(158.53,177.2) v2(160.05,177.2) v2(160.56,182.4) v2(160.69,171.74) v2(160.69,170.47) v2(160.69,169.2) v2(161.32,177.45) v2(162.34,175.67) v2(162.59,179.23) v2(164.75,178.85) v2(167.42,178.85) v2(167.42,177.2)
PHASE1_RC1: length 1.7
  TOP w1.016: C740.1 154.52,176 R829.2
PHASE2: length 77.1
  TOP w0.127: P3.2 185.71,175.86 L9.1
  TOP w0.203: 231.3,156.17 231.17,156.04 231.17,155.61 229.51,153.94 U39.23
  TOP w0.635: v2(233.46,162.47) C742.1 232.86,161.39 232.25,160.78 232.25,157.12 231.3,156.17 ; R838.2 181.36,182.18 v2(181.13,182.4)
  BOTTOM w0.635: v2(186.21,180.37) 186.47,180.63 226,180.63 231.93,174.69 231.93,163.48 232.95,162.47 v2(233.46,162.47)
  vias: v2(176.82,183.8) v2(176.82,174.4) v2(177.83,183.8) v2(177.83,177.2) v2(178.85,183.8) v2(179.23,177.2) v2(179.86,183.8) v2(180.63,177.2) v2(181.13,181.13) v2(181.39,171.74) v2(181.39,170.47) v2(181.39,169.2) v2(182.02,177.32) v2(182.28,178.59) v2(182.66,176.18) v2(183.42,179.36)
