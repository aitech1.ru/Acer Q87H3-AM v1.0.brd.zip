# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA1: length 8
  TOP w0.203: 65,144.49 65,143.47 65.19,143.29 U11.3 ; 65,144.49 U11.6 ; 65,144.49 65,144.71 v2(64.4,145.32)
  TOP w0.508: R276.2 71.91,150.91 71.69,150.68 v1(71.23,150.68) 70.32,150.68 R279.1
  vias: v2(64.4,147.61) v2(73.9,149.05)
P2V12: length 2.8
  TOP w0.102: R563.2 v1(155.61,17.23)
  TOP w0.508: R563.2 156.94,18.38 D21.1
P2VCC: length 8.5
  TOP w0.508: U31.5 166.34,23.53 C548.1 166.21,24.1 165.67,24.65 v1(164.9,24.65) 164.35,24.65 R565.1 R564.1
P2VCC_R: length 3.9
  TOP w0.508: D20.3 159.54,23.4 161.32,21.62 R564.2
P2VIN:
  vias: v2(174.89,36.71) v2(175.65,36.71) v2(176.54,36.71) v2(177.43,36.71) v2(179.23,34.07) v2(179.23,33.31) v2(181.64,32.67) v2(181.64,31.27) v2(182.4,33.94) v2(182.53,26.96) v2(183.8,35.08) v2(183.8,32.67) v2(183.8,28.23) v2(185.07,33.94) v2(185.07,31.27) v2(188.63,31.15) v2(188.75,33.69) v2(190.79,34.7) v2(191.04,33.31) v2(191.93,32.42) v2(193.58,32.29) v2(194.72,33.18) v2(194.85,34.7)
V1N: length 105.5
  TOP w0.127: P2.1 166.21,174.15 167.16,174.15 167.42,174.4 167.42,174.91 v2(167.75,175.24) ; R877.1 218.41,154.43 218.41,154.07 v2(218.23,153.89) 218.23,153.47 217.71,152.94 215.81,152.94 215.3,153.45 v2(215.3,153.83) R852.1 ; R835.1 211.42,160.85 211.42,161.03 211.83,161.43 v2(212.42,161.43) ; v2(208.44,153.96) R900.1
  BOTTOM w0.127: v2(167.75,175.24) 167.75,175.12 167.42,174.79 167.42,174.64 167.65,174.4 169.68,174.4 173.02,171.07 173.02,167.83 173.9,166.95 181.68,166.95 183.04,168.31 183.04,172.37 185.74,175.08 191.59,175.08 193,176.49 199.22,176.49 199.86,175.85 202.42,175.85 v1(202.75,176.18) 203.08,175.85 206.88,175.85 213.52,169.21 213.52,163 212.42,161.9 v2(212.42,161.43) 213.42,160.43 218.45,160.43 219.6,159.28 219.6,157.74 218.23,156.37 v2(218.23,153.89) ; v2(215.3,153.83) 215.3,154.87 214.42,155.75 210.11,155.75 209.71,155.35 208.95,155.35 208.44,154.85 v2(208.44,153.96)
V2N: length 78.8
  TOP w0.127: v2(210.48,152.31) 210.34,152.45 207.81,152.45 206.15,154.1 R901.1 ; R826.1 211.87,154.19 v2(211.64,153.96) ; P4.1 186.24,174.11 187.3,174.11 187.99,174.81 187.99,176.61 v2(188.32,176.94) ; R878.1 217.33,154.5 217.33,153.96 v2(217.2,153.83) ; v2(215.18,161.6) 214.85,161.27 214.85,160.85 R859.1
  BOTTOM w0.127: v2(188.32,176.94) 187.99,176.61 187.99,176.29 188.22,176.05 190.28,176.05 192.26,178.04 197.42,178.04 v1(197.77,178.39) 198.13,178.04 205.95,178.04 214.41,169.58 214.41,163.71 214.79,163.33 214.79,161.99 v2(215.18,161.6) 215.71,161.07 218.73,161.07 218.73,161.06 220.24,159.55 220.24,157.37 219.36,156.5 219.36,153.61 218.7,152.94 217.52,152.94 ; 217.52,152.94 216.9,152.32 213.28,152.32 v2(211.64,153.96) 210.48,152.8 v2(210.48,152.31) ; 217.52,152.94 217.52,153.26 217.2,153.58 v2(217.2,153.83)
V3N: length 43
  TOP w0.127: P6.1 213.04,168.91 213.52,168.43 213.52,165.13 214.92,163.74 215.81,163.74 216.95,162.59 216.95,162.47 v2(216.57,162.08) 216.95,161.7 216.95,160.91 R881.1 ; R827.1 210.6,154.62 210.6,153.73 ; 210.6,153.73 209.95,153.08 208.08,153.08 207.3,153.86 R903.1 ; 210.6,153.73 211.25,153.08 213.79,153.08 ; 213.79,153.08 214.15,153.45 R853.1 ; 213.79,153.08 214.77,153.08 215.54,152.31 217.97,152.31 219.68,154.02 219.68,158.24 220.89,159.44 220.89,161.32 220.12,162.08 v2(218.85,162.08)
  BOTTOM w0.102: 217.73,162.5 v1(217.66,162.57)
  BOTTOM w0.127: v1(217.66,162.57) 217.18,162.08 v2(216.57,162.08) ; v2(218.85,162.08) 218.14,162.08 217.73,162.5
V3P3_BG_N1: length 4.9
  TOP w0.102: QN32.B 27.85,137.03 28.96,135.92 R264.2 R265.1 v1(30.29,134.37)
V3P3_BG_N2: length 7.1
  TOP w0.102: v1(32.32,134.6) 33.64,134.6 34.16,135.13 R268.2 34.16,135.92 34.45,136.21 34.45,138.97 QN33.B
V3P3_BG_N3: length 10.3
  TOP w0.102: R262.1 R263.1 R269.1 30,140.06 29.67,139.73 QN32.C 28.86,139.43 29.57,138.72 33.76,138.72 v2(33.89,138.59)
V3P3_BG_N4: length 11.6
  TOP w0.102: v2(33.94,150.4) 33.64,150.71 31.68,150.71 31.43,150.95 R261.1 31.31,151.29 28.23,151.29 27.85,150.91 QN30.G 27.85,147.48 QN31.C
V3P3_BG_N5: length 4.9
  TOP w0.102: v2(34.35,143.39) 33.97,143.01 32.52,143.01 QN34.G 30.79,142.15 30.76,142.11 R269.2
V3P3_BG_N6: length 3.6
  TOP w0.102: R266.1 33.89,146.21 v2(34.65,145.45)
  TOP w0.508: QN34.D 33.43,145.19 R266.1
V3P3_BG_N7: length 2.5
  TOP w0.102: R263.2 28.86,142.96 v1(28.73,143.09) 27.85,143.97 QN31.B
V3P3_BG_N8: length 4
  TOP w0.102: v1(32.29,136.35) 32.67,136.74 QN33.C QN32.E
V4N: length 133.4
  TOP w0.127: v2(209.58,153.96) R833.1 ; R904.1 208,160.85 208,161.7 208.25,161.96 208.49,161.96 v2(208.82,161.63) ; v2(149.08,175.26) 148.75,174.93 148.75,174.4 148.37,174.02 146.65,174.02 P8.1 ; R857.1 v2(213.01,153.96) ; v2(216.17,153.83) 216.17,154.46 216.44,154.73 R880.1
  BOTTOM w0.127: v2(209.58,153.96) 209.58,154.08 210.35,154.85 212.12,154.85 v2(213.01,153.96) 214.01,152.95 215.66,152.95 216.17,153.47 v2(216.17,153.83) 216.17,155.21 218.97,158.01 218.97,159.02 218.19,159.8 210.65,159.8 v2(208.82,161.63) 209.15,161.96 210.45,161.96 212.63,164.14 212.63,168.84 207.19,174.28 199.35,174.28 198.72,174.91 197.67,174.91 v1(197.31,175.27) 196.96,174.91 193.83,174.91 193.11,174.19 186.11,174.19 183.93,172 183.93,167.94 182.05,166.06 173.53,166.06 172.13,167.46 172.13,170.68 169.43,173.39 164.37,173.39 162.85,171.86 162.85,168.05 161.7,166.91 152.56,166.91 151.16,168.31 151.16,171.74 148.75,174.15 148.75,174.78 148.72,174.8 148.72,174.91 v2(149.08,175.26)
VCCIO_OUT: length 24.4
  TOP w0.356: CPU1.L40 180.98,135.26 182.15,136.43
  TOP w0.508: R72.2 200.34,138.21 200.04,138.51 198.8,138.51 C838.2 197.23,138.61 194.19,138.61 v2(194.09,138.72) 193.99,138.61 184.33,138.61 182.15,136.43
3P3_EPW_N1: length 5
  TOP w0.508: R645.1 7.3,153.92 v2(6.92,154.31) 6.48,153.88 5.99,153.88 C608.1 5.82,153.69 QN65.B
3P3_EPW_N2: length 9
  TOP w0.102: QN65.C 4.02,148.55 v1(4.02,148.11)
  TOP w0.254: 6.18,147.96 6.79,147.35 10.41,147.35 R642.1 ; 6.18,147.96 5.64,147.96 4.83,148.77 4.83,149.31 QN65.C ; 6.18,147.96 R643.2
3P3_EPW_N3: length 4.1
  TOP w0.254: C607.1 7.19,147.94 R643.1 7.47,148.27 QSW4.G v2(6.1,149.33)
662_P3: length 3.3
  TOP w0.203: C520.1 15.53,215.3 v1(15.78,215.55) 16.29,215.55 16.7,215.96 CODEC.3
662_P4: length 8.9
  TOP w0.102: R505.2 14.79,210.03 v1(14.79,210.7) 15.12,210.7 16.54,212.12 16.54,215.24 17.2,215.89 CODEC.4
662_P9: length 7
  TOP w0.254: CODEC.9 19.7,214.78 C523.1
  TOP w0.508: C523.1 19.56,214.5 19.34,214.28 19.34,212.25 19.72,211.87 v1(19.72,211.61) RJ6.2
662_P11: length 3.7
  TOP w0.102: CODEC.11 20.7,215.71 v1(20.99,215.42) 21.11,215.3 C524.1 R504.1
81038_EN: length 11.3
  TOP w0.178: C783.2 49.05,31.53 50.69,33.16 U41.26
  TOP w0.508: R909.2 47.02,37.78 47.05,37.75 R912.2 47.05,37.08 v2(47.53,36.61) ; C783.2 v2(48.55,32.35)
  BOTTOM w0.508: v2(48.55,32.35) 48.93,32.74 v1(48.93,34.07) 48.93,35.21 v2(47.53,36.61)
81038_FB1: length 8.7
  TOP w0.178: 56.04,35.47 55.33,34.76 U41.14
  TOP w0.381: C804.1 56.77,36.2 56.04,35.47
  TOP w0.508: 58.23,37.12 R929.2 57.21,36.35 C804.1 ; 58.23,37.12 R932.1 C801.2 ; 58.23,37.12 58.36,36.99 59.63,36.99 59.93,36.69 60.06,36.69 R933.1
81038_FB2: length 8.8
  TOP w0.102: C791.2 57.82,28.45 57.82,27.05 v1(57.72,26.96)
  TOP w0.178: C793.1 55.67,31.8 55.67,32.05 55.37,32.36 U41.8
  TOP w0.508: R919.1 57.75,29.72 R921.1 ; R919.1 57.85,30.64 R918.2 56.71,30.77 C793.1 ; R919.1 C791.2
81038_VIN: length 6.7
  TOP w0.508: R908.2 46.01,39.28 46.23,39.5 R909.1 C858.1 48.58,39.5 48.93,39.15 48.93,37.37 49.31,36.99 49.31,36.48 49.44,36.35
  vias: v1(50.26,35.21)
95820_P3: length 12.7
  TOP w0.203: C760.1 222.28,143.26 222.28,145.88 v1(222.38,145.98) 223.2,145.98 224.44,147.23 227.11,147.23 227.51,147.62 U39.3
  TOP w0.254: C760.1 222.63,142.88 221.68,141.92 R861.1
95820_P5: length 5.4
  TOP w0.203: R865.1 v1(224.95,146.29) 225.22,146.55 227.41,146.55 228.31,147.45 U39.5
95820_P5_R: length 137.4
  TOP w0.254: R871.1 224.95,143.29 v2(225.33,143.67) 224.95,144.05 R865.2 ; RT2.1 163.89,182.63 v2(164.12,182.4) ; v2(222.03,154.21) 220.86,154.21 215.68,149.03 215.68,144.81 216.82,143.67 v2(219.11,143.67)
  BOTTOM w0.254: 222.54,143.67 v1(222.54,143.67) ; 222.54,143.67 v2(219.11,143.67) ; 222.54,143.67 v2(225.33,143.67) ; v2(222.03,154.21) 224.7,154.21 225.71,153.19 229.52,153.19 230.57,154.24 230.57,156.08 234.6,160.12 234.6,175.05 226.29,183.36 213.65,183.36 211.04,185.96 183.32,185.96 182.91,186.37 173.84,186.37 171.48,184 171.48,181.57 170.42,180.5 166.02,180.5 v2(164.12,182.4)
95820_P6: length 11.1
  TOP w0.102: v1(224.37,139.99) 225.03,139.99 225.48,140.44 225.48,141.38 R837.2 226.12,142.02
  TOP w0.203: C746.2 226.12,145.99 226.35,146.22 227.63,146.22 228.71,147.3 U39.6
  TOP w0.254: 226.12,143.16 C751.2 C746.2 ; 226.12,143.16 226.12,142.02 ; 226.12,143.16 C748.2
95820_P6_1: length 1.9
  TOP w0.203: C748.1 227.61,142.63 v2(227.77,142.63) 227.9,142.63 R840.2
95820_P6_2: length 2.1
  TOP w0.102: v1(230.57,139.99) C747.2
  TOP w0.254: C747.2 R839.1
95820_P6_R: length 2
  TOP w0.102: C745.2 227.08,140.03 v1(227.03,139.99)
  TOP w0.254: C745.2 227.08,141.92 R837.1
95820_P8: length 2.8
  TOP w0.203: U39.8 229.51,146.52 v1(229.29,146.31) 229.29,145.9 229.36,145.83 C752.2
95820_P8_C: length 10.8
  TOP w0.102: R839.2 228.41,140.34 v1(228.76,139.99)
  TOP w0.203: C752.1 228.41,146.37 229.11,147.06 U39.7
  TOP w0.254: R839.2 228.41,141.89 R843.2 228.49,142.09 229.44,143.05 R840.1 229.39,143.21 228.88,143.72 228.8,143.72 228.41,144.11 R847.2 ; C752.1 R847.2 ; R847.2 C751.1
95820_P8_R1: length 1.7
  TOP w0.254: R843.1 229.44,142.09 230.51,143.16 C749.2
95820_P9: length 6.3
  TOP w0.102: v1(232.39,144.66) 232.21,144.84 231.03,144.84 R850.2
  TOP w0.203: U39.9 229.91,144.89 R850.2
95820_P9_R: length 6
  TOP w0.102: R849.1 231.66,142.02 v1(232.39,142.76)
  TOP w0.254: R847.1 229.87,143.8 230.94,143.8 R850.1 231.52,144.23 C749.1 R849.1
95820_P9_R1: length 11.1
  TOP w0.254: R849.2 231.08,141.51 232.09,141.51 232.32,141.29 232.32,139.61 v1(232.44,139.48) 232.86,139.07 C756.1 234.47,139.07 235.14,139.73 R846.2 235.14,140.69 R851.2 233.97,142.4 234.25,142.69 C754.1
95820_P14: length 10.4
  TOP w0.203: v1(231.99,146.97) 232.19,147.17 232.19,149.07 232.32,149.2 232.32,149.58 231.96,149.93 U39.14
  TOP w0.254: R854.2 232.82,142.27 233.3,142.75 C754.2 R856.1 C757.1 232.92,145.96 232.45,145.96 232.19,146.22 232.19,146.46 231.99,146.67 v1(231.99,146.97)
95820_P25: length 8.6
  TOP w0.203: 228.63,155.51 228.71,155.43 U39.25
  TOP w0.635: R817.2 229.9,159.2 229.17,158.47 C738.1 228.38,158.47 228,158.08 228,156.14 228.63,155.51
95820_P32: length 7.4
  TOP w0.203: 225.68,151.93 U39.32
  TOP w0.254: C736.1 224.54,152.69 224.92,152.69 225.68,151.93
  TOP w0.508: R812.2 v1(221.9,155.73) 222.03,155.61 222.03,155.6 223.29,154.34 223.3,154.34 224.03,153.61 C736.1
95820_P33: length 2.2
  TOP w0.102: R864.1 224.77,151.92 v1(224.9,151.8) 225.17,151.53 U39.33
95820_P34: length 7.8
  TOP w0.102: v2(220.66,152.31) 220.03,151.68 R863.1 220.46,150.86 221.34,150.86 221.83,151.34 224.37,151.34 224.47,151.24 225.55,151.24 225.66,151.13 U39.34
95820_P35: length 4.3
  TOP w0.102: U39.35 225.66,150.73 225.2,150.27 223.58,150.27 R862.1 v1(222.16,150.78)
95820_P36: length 8.5
  TOP w0.102: v1(218.35,149.87) 219.06,150.58 220.55,150.58 R828.2 222.84,150.15 223.04,149.94 225.16,149.94 225.55,150.33 U39.36
95820_P37: length 5.5
  TOP w0.102: U39.37 225.56,149.93 225.32,149.69 223.12,149.69 v1(222.51,149.08) 222.43,149 R831.2
+1P5V_FB: length 10.2
  TOP w0.102: v1(103.61,110.37) 102.72,110.37 C834.1
  TOP w0.508: U32.6 99.09,105.06 99.35,105.32 99.59,105.32 100.35,106.08 102.39,106.08 102.62,106.3 C833.1 C832.1 R611.2 C834.1
+1P05V_FB: length 9.4
  TOP w0.508: C830.1 98.33,97.16 97.82,97.67 U32.2 ; C830.1 98.62,96.52 99.09,96.04 99.09,94.67 v1(98.33,93.91) 97.83,93.41 C831.1 R601.2 ; C830.1 97.31,96.52 C574.1
+1P5V_REF: length 15.3
  TOP w0.508: U32.5 100.36,105.19 100.62,105.44 103.66,105.44 104.48,106.26 v1(104.48,108.8) 104.48,110.76 R602.1 R604.1 R608.2 100.08,111.7 C579.2
+1P05V_REF: length 8.3
  TOP w0.102: 103.16,97.19 v1(103.18,97.16)
  TOP w0.508: U32.3 99.09,97.44 100.52,96.01 R591.1 R596.2 102.87,96.01 C573.2 103.16,95.98 QN53.C
+12_VGA_G: length 2.6
  TOP w0.102: R798.1 166,201.96 v1(165.62,201.58)
  TOP w0.508: QN76.G 166.78,202.65 166.56,202.43 R798.1
+ATX_3VSB: length 901.4
  TOP w0.254: R345.2 v2(196.55,25.34) ; U21.67 204.98,16.89 204.88,16.99 v2(204.88,17.3) ; v2(69.63,222.92) 69.63,223.43 70.77,224.57 71.79,224.57 72.83,223.53 76.54,223.53 R442.2 R695.1 ; v2(56.29,209.33) 56.29,208.67 61.29,203.68 90.48,203.68 93.09,201.07 R640.2 ; U21.4 220.98,33.78 221.9,34.7 221.9,35.69 ; v2(194.09,9.56) 193.33,10.32 192.06,10.32 191.68,10.7 191.68,11.13 193.66,13.11 193.66,15.3 R944.2 193.64,16.33 193.64,17.3 194.85,18.51 195.97,18.51 196.57,19.1 196.57,19.78 RJ11.1 ; 205.39,34.32 205.39,33.74 205.48,33.65 U21.35 ; R351.2 214.2,36.99 220.47,36.99 C387.1
  TOP w0.508: R231.2 23.69,79.06 24.1,79.47 24.13,79.47 24.89,80.23 C281.1 25.94,80.42 v2(26.96,81.44) ; R231.2 R225.2 R237.2 21.5,76.74 19.11,74.35 v2(18.83,74.35) ; R231.2 22.77,78.9 22.13,79.53 R234.2 20.47,82.36 16.82,86.01 15.78,86.01 14.74,87.05 14.74,89.42 15.2,89.87 15.2,94.32 v2(15.22,94.34) ; v2(42.2,23.65) 41.39,24.46 41.39,26.15 40.5,27.04 v2(16.47,27.04) ; v2(206.28,26.96) 206.18,26.85 206.18,18.6 v2(204.88,17.3) ; 227.49,38.77 v2(226.73,38.77) 223.09,38.77 221.14,36.82 C387.1 221.43,36.04 221.55,36.04 221.9,35.69 ; 227.49,38.77 227.49,39.91 226.47,40.93 226.47,42.48 227.62,43.63 229.26,43.63 v2(229.29,43.59) 229.32,43.63 R368.2 ; 227.49,38.77 229.9,38.77 231.3,40.16 ; ME_TEST.1 1.63,158.22 1.63,151.59 2.5,150.73 6.59,150.73 7.4,151.54 v2(7.4,152.43) ; 205.39,34.32 205.39,34.86 C384.1 205.74,35.12 206.15,34.7 v2(206.15,33.74) ; v2(87.03,90.58) 87.03,93.38 86.72,93.68 86.72,108.95 88.3,110.52 91.09,110.52 95.41,114.84 95.41,129.83 97.19,131.6 97.19,151.67 98.28,152.76 98.28,183.09 96.86,184.51 96.86,185.48 v2(96.02,186.32) ; 241.08,37.17 231.76,37.17 231.1,36.51 226.85,36.51 v2(226.73,36.63) ; 241.08,37.17 241.08,38.04 R367.2 240.28,38.83 239.11,38.83 ROM1.8 ; 241.08,37.17 242.35,35.9 242.35,22.77 241.71,22.13 236.51,22.13 v2(236,21.62) ; D1.2 232.82,47.02 231.73,45.93 230.59,45.93 229.78,45.12 v2(229.29,45.12) ; R633.2 95.79,190.02 96.68,189.14 ; v2(89.82,55.53) 93.12,55.53 93.89,54.77 93.89,50.71 92.87,49.69 92.87,40.42 90.81,38.36 90.08,38.36 89.62,37.9 89.62,33.96 90.99,32.59 90.99,22.36 v5(90.74,22.11) ; C396.1 200.28,14 199.04,14 C397.1 ; C396.1 200.72,13.56 200.85,13.56 201.07,13.34 201.07,12.45 199.93,11.3 v2(199.93,10.45) ; C396.1 200.44,14.26 201.14,14.96 201.14,15.3 v2(202.47,16.63) ; 96.68,189.14 97.44,189.9 99.09,189.9 99.47,190.28 100.01,190.28 102.78,193.05 102.78,194.85 103.28,195.36 ; 96.68,189.14 v2(96.68,188.12) 94.14,188.12 93.89,188.37 92.62,188.37 92.17,188.82 92.17,192.88 92.49,193.2 93.12,193.2 93.96,194.04 93.96,200.39 R640.2 ; v2(230.28,12.22) 231.17,11.34 231.17,9.56 230.6,8.99 230.6,7.78 PFB8.2 ; R344.2 208.06,12.45 208.06,11.97 v2(207.93,11.84) ; v2(208.44,29.24) 206.99,30.69 v2(206.99,31.02) ; v2(81.19,18.37) 78.22,18.37 77.48,17.63 70.31,17.63 69.88,18.07 69.25,18.07 v2(68.87,17.69) ; 35.72,87.54 34.58,86.39 v2(34.58,85.5) ; v2(205.71,11.84) 205.71,12.64 R350.2
  TOP w0.762: 108.24,18.19 107.3,17.25 107.3,10.24 v5(107.25,10.19) ; v5(91.73,8.67) 91.73,10.57 87.92,14.38 87.92,19.29 v5(90.74,22.11)
  BOTTOM w0.254: v2(69.63,222.92) 69.38,223.17 66.83,223.17 66.45,222.79 66.45,222.1 66.83,221.72 66.83,212.8 67.23,212.41 67.23,212.39 67.67,211.95 67.67,210.93 67.41,210.66 65.12,210.66 64.46,210 56.97,210 v2(56.29,209.33) ; v2(196.55,25.34) 196.5,25.39 196.5,25.56 198.03,27.08 198.03,28.25 197.72,28.56 197.72,29.55 199.7,31.53 203.94,31.53 v2(206.15,33.74)
  BOTTOM w0.305: v2(206.28,26.96) 205.47,26.14 204.25,26.14 204.1,26.3 203.62,26.3 203.38,26.54 203.38,27.2 203.99,27.81 ; 203.99,27.81 SR51.2 ; 203.99,27.81 SR52.2
  BOTTOM w0.508: v2(87.03,90.58) 87.15,90.58 89.01,88.73 89.01,87.36 88.6,86.95 88.6,75.01 87.21,73.62 87.21,62.55 89.82,59.93 v2(89.82,55.53) ; v2(229.29,45.12) v2(229.29,43.59) ; v2(68.87,17.69) 68.87,17.44 67.54,16.11 61.22,16.11 58.35,18.98 48.27,18.98 47.02,20.23 43.57,20.23 42.2,21.6 v2(42.2,23.65) ; v2(206.99,31.02) 207.37,31.4 207.37,32.52 ; v2(96.68,188.12) 96.68,187.99 96.02,187.33 v2(96.02,186.32) ; v2(15.22,94.34) 13.78,94.34 12.99,95.13 12.99,96.92 11.2,98.71 11.2,105.12 12.4,106.33 12.4,108.06 9.94,110.52 9.94,123.76 10.34,124.17 10.34,127.92 11.11,128.68 11.11,138.89 9.94,140.06 9.94,146.51 9.43,147.02 9.43,148.75 8.72,149.46 8.72,151.11 v2(7.4,152.43) ; v2(81.19,18.37) 81.21,18.4 81.99,18.4 83.06,19.46 87.28,19.46 89.92,22.11 v5(90.74,22.11) ; v2(226.73,38.77) v2(226.73,36.63) 226.73,36.46 225.51,35.24 224.98,35.24 222.27,32.52 207.37,32.52 ; v2(236,21.62) 235.49,21.11 235.49,17.37 230.35,12.22 v2(230.28,12.22) ; v5(107.25,10.19) 107.76,9.67 121.63,9.67 122.08,9.23 160.57,9.23 160.93,8.87 181.83,8.87 183.43,7.27 187.91,7.27 188.49,7.86 192.64,7.86 194.09,9.3 v2(194.09,9.56) 194.16,9.63 196.44,9.63 196.77,9.3 198.79,9.3 v2(199.93,10.45) 200.18,10.19 202.28,10.19 203.93,11.84 v2(205.71,11.84) 205.79,11.92 207.86,11.92 v2(207.93,11.84) ; v2(34.58,85.5) 33.43,84.36 33.07,84.36 31.1,82.39 27.91,82.39 v2(26.96,81.44) ; 207.37,32.52 v2(206.15,33.74) ; v2(204.88,17.3) 204.27,16.69 202.5,16.69 202.47,16.67 v2(202.47,16.63) ; v2(16.47,27.04) 15.2,28.31 15.2,37.29 14.59,37.9 14.59,47.54 14.94,47.9 14.94,60.22 15.5,60.78 15.5,64.55 15.34,64.71 15.34,67.09 16.29,68.04 16.29,72.54 18.1,74.35 v2(18.83,74.35) ; v2(208.44,29.24) 207.75,29.24 206.28,27.77 v2(206.28,26.96)
  BOTTOM w0.762: v5(107.25,10.19) 106.17,10.19 103.25,7.28 92.99,7.28 91.73,8.54 v5(91.73,8.67)
+ATX_3VSB_FB: length 3.8
  TOP w0.508: U34.7 113.44,18.7 v1(113.29,18.55) 113.14,18.7 112.33,18.7 R624.2 112.15,18.58 R626.2
+ATX_5VSB: length 603.3
  TOP w0.254: v2(122.33,27.21) 121.95,27.59 121.95,29.91 R625.2 ; v2(123.6,26.32) 121.83,24.54 121.83,23.65
  TOP w0.381: R342.2 207.34,9.82 201.36,9.82 200.88,9.34 197.59,9.34 197.4,9.53 196.85,9.53 195.47,8.15 193.48,8.15 193.01,7.68 191.32,7.68 190.65,7 190.65,4.88 190.39,4.62 188.11,4.62 187.74,4.99 187.74,5.62 188.41,6.29 188.41,10.1 189.14,10.83 189.14,11.84 187.12,13.86 187.12,14.99 185.85,16.26 185.85,17.54 v2(185.99,17.69)
  TOP w0.508: 134.27,15.02 136.3,15.02 v2(138.08,16.8) ; R990.1 187.87,19.97 186.63,18.73 R991.1 186.63,18.32 v2(185.99,17.69) ; v2(101.66,186.21) 102.17,186.73 R647.2
  TOP w1.016: v6(71.2,18.52) 77.11,18.52 78.18,19.59 v6(81.19,19.59) ; v6(4.99,72.93) 6.64,74.58 6.64,83.25 8.67,85.29 8.67,87.63 9.97,88.93 11.41,88.93 13.37,90.89 13.37,93.89 12.99,94.27 12.99,95.92 13.62,96.55 13.62,97.7 14.45,98.52 15.46,98.52 17.43,100.49 17.43,103.54 17.3,103.66 v6(17.3,103.79) ; v6(92.13,24.16) 92.13,38.16 93.76,39.78 v6(93.76,49.18) ; 16.92,28.86 17.86,27.93 41.35,27.93 42.28,27 42.28,24.96 43.45,23.79 46.01,23.79 46.4,23.4 51.85,23.4 v6(52.81,22.44) ; v6(109.51,107.98) 109.51,109.62 111.31,111.43 111.31,118.96 108.59,121.68 106.49,123.78 106.49,124.14 103.41,127.22 103.41,180.5 107.47,184.56 v2(107.47,186.21)
  BOTTOM w0.254: v2(123.6,26.32) 123.22,26.32 v2(122.33,27.21)
  BOTTOM w0.508: v2(107.47,186.21) v2(101.66,186.21) ; v2(138.08,16.8) 141.29,16.8 143.47,14.61 155.19,14.61 156.39,15.81 167.83,15.81 168.61,16.59 179.49,16.59 180.88,17.99 185.69,17.99 v2(185.99,17.69)
  BOTTOM w0.762: 14.36,129.01 14.36,131.33 14.99,131.96 14.99,147.38 13.41,148.97 13.41,159.61 14.78,160.98 14.78,171.51 13.41,172.88 13.41,176.6 14.23,177.43 14.23,193.87 14.64,194.28 14.64,195.3 13.49,196.44 13.49,205.07 14.89,206.47 16.23,206.47 16.97,207.22 20.15,207.22 20.8,207.87 20.8,209.14 20.23,209.71 19.08,209.71 18.13,210.66 14.38,210.66 v5(13.75,210.03)
  BOTTOM w1.016: 14.36,129.01 14.36,117.61 12.71,115.96 12.71,111.67 15.02,109.35 15.02,105 16.1,103.92 17.18,103.92 v6(17.3,103.79) ; v6(52.81,22.44) 53.3,21.95 61.09,21.95 62.64,20.4 67.67,20.4 69.55,18.52 v6(71.2,18.52) ; v6(93.76,49.18) 93.76,54.96 93.06,55.66 93.06,79.21 92.23,80.04 92.23,84.12 106.59,98.47 106.59,104.05 109.51,106.97 v6(109.51,107.98) ; 1.76,33.76 1.47,34.05 1.47,55.45 6.43,60.41 6.43,60.44 6.66,60.66 6.66,62.62 6.43,62.84 6.43,71.48 v6(4.99,72.93) ; v6(81.19,19.59) 81.8,19.59 82.56,20.35 86.75,20.35 90.56,24.16 v6(92.13,24.16)
  BOTTOM w1.524: v6(92.13,24.16) 102.72,24.16 104.88,22 v6(117.76,22)
  vias: v2(2.6,34.04) v2(2.6,33.28)
+DDR_VTTR_REF: length 4.6
  TOP w0.508: C551.1 101.79,30.93 R566.2 100.52,29.62 R568.1 100.24,29.4 U30.3
+DI_5VDU_N1: length 3.1
  TOP w0.508: QN48.B 133.6,25.78 R585.2
+DI_5VDU_N2: length 12
  TOP w0.508: R583.2 128.84,24.58 QN49.C 129.29,24.83 R590.2 R585.1 136.73,24.83 v1(136.99,24.57) 136.99,23.29 R584.2
+DI_5VDU_N3: length 21.7
  TOP w0.102: v2(143.29,21.6) 142.68,21.6 142.27,22 144.1,23.83 144.1,27.16 143.67,27.59 142.91,27.59 140.88,29.62 135.8,29.62 132.24,26.07 R590.1
+DI_5VDU_N4: length 6.6
  TOP w0.102: R582.2 128.52,30.67 C564.2 127.54,29.69 v2(127.54,29.29) 127.79,29.04 128.73,29.04 R588.2 129.57,28.61 130.21,27.97 QN49.B
+DIMM_5VDUAL: length 217.8
  TOP w0.508: 12.86,54.34 13.91,55.39 13.91,55.66 R388.1 ; 12.86,54.34 13.82,53.37 15.15,53.37 15.53,52.99 15.53,51.21 15.34,51.03 15.28,51.03 ; 12.86,54.34 11.59,54.34 11.44,54.49 R393.2 R394.2 ; D21.2 157,16.42 154.46,16.42 v2(154.21,16.16) ; 152.18,26.19 153.8,26.19 155.58,24.42 160.31,24.42 R565.2 ; v2(14.26,49.41) 15.25,49.41 15.53,49.68 15.53,50.78 15.28,51.03 ; D20.1 154.34,21.11 ; v2(81.82,17.66) 81.77,17.61 78.35,17.61 77.74,17 69.93,17 v2(69.63,17.3) ; 15.28,51.03 R395.1
  BOTTOM w0.508: v2(69.63,17.3) 67.8,15.48 60.96,15.48 58.08,18.35 49.21,18.35 47.4,16.54 47.4,9.18 45.63,7.4 18.75,7.4 17.3,8.85 17.3,11.59 17.46,11.74 17.46,17.09 14.51,20.04 14.51,37.01 13.95,37.57 13.95,49.11 v2(14.26,49.41) ; v2(144.94,16.92) 143.54,18.32 106.71,18.32 102.01,23.02 91.85,23.02 91.5,22.66 91.5,21.67 91.17,21.34 90.06,21.34 87.54,18.83 83.39,18.83 82.22,17.66 v2(81.82,17.66)
  vias: v2(145.45,21.5) v2(146.97,21.5) v2(146.97,19.46) v2(150.27,16.16) v2(150.78,16.8) v2(151.16,16.16) v2(151.67,16.8) v2(152.18,16.16) v2(152.69,16.8) v2(153.19,16.16) v2(153.7,16.8) v2(180.55,16.67) v2(181.21,17.3) v2(181.59,16.67) v2(182.02,17.3) v2(182.91,17.3) v2(188.25,26.32) v2(189.14,26.32) v2(190.15,27.46) v2(190.15,26.32) v2(191.17,27.46) v2(191.42,28.48) v2(191.42,26.32) v2(192.56,29.12) v2(193.71,29.12) v2(194.6,28.61) v2(194.85,27.72)
+DP_PWR: length 32.3
  TOP w0.508: C703.2 192.91,223.14 195.74,225.97 v2(196.37,225.97)
  BOTTOM w0.762: v2(196.37,225.97) 196.63,225.71 v1(213.04,225.71) 218.85,225.71 221.14,228 222.16,228
  vias: v6(226.09,225.84)
+DP_VCC3: length 88.7
  TOP w0.381: U3.5 222.54,224.35 C700.1 222.19,224.7 v2(221.6,224.7)
  TOP w0.508: R786.2 188.47,215.08 v2(188.75,214.79) ; R797.2 194.98,208.92 194.44,209.46 v2(194.44,209.71) 194.44,209.94 193.82,210.57 R791.2 ; v2(207.8,221.77) 207.68,221.65 v2(207.68,216.31) ; R89.2 R83.2 225.04,215.2 225.2,215.04 R84.2 226.85,215.81 226.85,218.22 ; v2(190.75,223.17) C107.1 190.75,221.11 190.53,220.89 U6.5 ; v2(217.58,221.77) R77.2
  BOTTOM w0.508: v2(227.87,219.36) 227.87,220 v1(227.29,220.58) 223.17,224.7 v2(221.6,224.7) 221.6,224.64 218.73,221.77 v2(217.58,221.77) v2(207.8,221.77) 192.15,221.77 v2(190.75,223.17) ; v2(188.75,214.79) 193.83,209.71 v2(194.44,209.71) 195.1,209.71 195.99,210.6 202.1,210.6 207.68,216.17 v2(207.68,216.31)
+DVI_VCC: length 51.4
  TOP w0.508: v2(149.38,216.19) 149.38,216.8 150.91,218.32 150.91,221.74 C129.1 150.5,224.03 v2(151.42,224.95) 152.81,226.35 152.81,231.81 v2(155.61,234.6) ; U9.5 v2(152.81,223.68) ; R108.1 v2(150.65,214.79) R105.1
  BOTTOM w0.508: 150.65,216.19 151.59,217.13 164.09,217.13 165.16,218.19 168.54,218.19 169.78,216.95 v2(170.21,216.95) ; 150.65,216.19 v2(149.38,216.19) ; 150.65,216.19 v2(150.65,214.79) ; v2(152.81,223.68) 152.56,223.68 151.42,224.82 v2(151.42,224.95)
+DVI_VGA_VCC:
  vias: v1(171.3,212.27)
+ENSR: length 3.5
  TOP w0.102: RLAN.62 54.34,224.32 54.21,224.19 54.21,223.07 v2(53.68,222.54) 53.5,222.36 R449.2
+EVDD12: length 22.8
  TOP w0.254: C475.2 49.03,236.1 49.84,235.28 RLAN.28
  TOP w0.381: R953.1 50.96,239.25 v2(50.88,239.17)
  TOP w0.508: C474.2 C475.2 49.49,236.31 49.77,236.58 v2(49.77,236.89)
  BOTTOM w0.381: v2(50.88,239.17) 50.05,240.01 45.07,240.01 v1(44.36,239.3) 43.97,238.92 43.97,237.59 SR1.2 45.74,237.19 47.8,237.19 48.23,236.76 49.64,236.76 v2(49.77,236.89)
+LDOVDD: length 26.2
  TOP w0.254: CODEC.29 19.2,226.99 18.7,227.49 18.7,227.87
  TOP w0.508: 18.7,227.87 18.7,228.63 C843.1
  TOP w0.762: v5(10.45,214.41) 10.95,213.9 PFB9.2
  BOTTOM w0.762: v5(10.45,214.41) 10.45,215.93 9.59,216.79 9.59,222 9.13,222.46 9.13,227.44 10.7,229.01 v1(12.35,229.01) 15.27,229.01 v5(15.53,229.27)
+RTCVCC: length 551.1
  TOP w0.305: v3(39.65,91.2) 39.65,91.19 39.65,91.19 39.63,91.19 39.07,90.63 PCH1.AP33 ; R386.1 9.47,171.53 8.92,170.97 7.02,170.97 6.51,170.47 v2(6.51,168.43)
  TOP w0.381: v2(58.96,4.99) 58.45,5.49 52.1,5.49 49.69,3.08 40.82,3.08 40.09,3.82 40.09,5.65 37.52,8.21 v2(37.52,8.44) ; CLR_CMOS.1 4.73,70.26 6.64,72.17 8.73,72.17 9.28,71.62 12.48,71.62 12.94,71.17 13.75,71.17 14.11,71.52 16.1,71.52 16.39,71.23 v2(17.33,71.23) 18.02,71.23 20.54,73.76 v2(22.56,73.76) 23.11,73.76 R247.2 23.69,73.15 24.22,72.61 24.32,72.61 24.51,72.42 v2(24.58,72.42) ; C484.1 25.5,82.1 v2(25.05,82.54) ; R252.2 R233.1 35.59,76.04 35.15,75.6 35.15,74.77 34.61,74.23 R229.1 34.32,74.1 34.32,73.07 33.05,71.8 33.05,68.54 30.9,66.39 27.59,66.39 26.83,67.15 v2(26.83,68.61)
  TOP w0.508: C282.1 22.77,81.82 v2(23.15,82.2) ; D1.3 235.49,47.4 235.87,47.02 239.99,47.02 v2(240.09,47.12) ; v2(20.1,33.31) 20.35,33.56 20.35,42.33 23.27,45.26 v2(23.27,47.4) ; v2(240.75,42.02) 241.31,42.02 242.98,40.34 242.98,21.88 v2(242.16,21.05)
  BOTTOM w0.381: v2(242.16,21.05) 242.29,20.92 242.29,18.51 240.1,16.33 239.91,16.33 232.32,8.73 232.32,5.3 230.35,3.33 226.88,3.33 224.25,0.7 112.24,0.7 112.17,0.76 ; v2(26.83,68.61) 25.18,70.26 25.18,71.83 v2(24.58,72.42) ; v2(22.56,73.76) 22.45,73.76 21.94,74.26 21.94,81 v2(23.15,82.2) 23.27,82.07 24.58,82.07 v2(25.05,82.54) 28.36,85.85 32.02,85.85 35.93,89.76 37.86,89.76 38.77,90.67 39.14,90.67 39.65,91.19 v3(39.65,91.2) ; v2(17.33,71.23) 17.33,67.75 16.29,66.71 16.29,65.82 23.15,58.96 23.15,47.53 v2(23.27,47.4) ; v2(37.52,8.44) 37.28,8.2 25.01,8.2 24.15,9.06 22.04,9.06 21.7,8.72 19.93,8.72 19.11,9.54 19.11,11.41 18.06,12.46 18.06,17.77 15.55,20.28 15.55,25.08 19.59,29.12 19.59,31.53 20.1,32.04 v2(20.1,33.31) ; v2(58.96,4.99) 62.56,1.38 72.99,1.38 73.49,1.88 73.49,1.88 74.78,3.18 74.78,8.74 77.94,11.89 83.17,11.89 86.24,8.82 86.24,7.5 92.13,1.61 ; v2(6.51,168.43) 5.6,167.52 5.6,164.85 3.19,162.45 3.19,157.97 4.22,156.94 4.84,156.94 5.43,156.35 5.43,151.59 6.92,150.11 6.92,144.89 7.13,144.67 7.13,134.91 6.4,134.17 6.4,131.76 2.73,128.09 2.73,71.38 3.84,70.26 CLR_CMOS.1
  BOTTOM w0.508: v2(240.09,47.12) 240.8,46.41 240.8,42.07 v2(240.75,42.02) ; 92.13,1.61 103.36,1.61 106.28,4.53 108.31,4.53 112.08,0.76 112.17,0.76
+RTCVCC_BAT: length 67.1
  TOP w0.508: R250.1 228.99,45.83 227.28,45.83 225.91,47.2 225.91,52.93 228.91,55.94 228.91,59.94 224.31,64.54 224.31,69.95 223.58,72.14 223.58,77.67 224.31,78.4 224.31,88.78 223.43,89.67 223.43,100.99 BAT1.P
+RTCVCC_BAT_R: length 3.7
  TOP w0.508: 233.2,49.05 232.47,49.05 v2(232.06,48.65) 230.89,47.47 R250.2
+SPI_3P3V: length 52.8
  TOP w0.254: 32.44,3.92 32.44,4.96 28.61,8.8 R765.1 ; 35.95,3.46 37.9,3.46 38.79,4.35 38.79,6.31 36.89,8.21 36.89,9.44 R764.1 36.93,9.59 R314.1 37.88,10.93 v2(37.35,11.46) ; R316.1 40.16,9 v2(40.44,8.72)
  TOP w0.508: v2(10.95,11.97) 7.96,11.97 6.69,10.7 6.69,8.24 9.05,5.87 SPI_DEBUG.4 10.6,4.73 v1(10.22,4.35) 11.47,3.1 16.69,3.1 C370.1
  BOTTOM w0.254: v2(37.35,11.46) 40.09,8.72 v2(40.44,8.72)
  BOTTOM w0.508: SD1.3 SR50.1 11.27,8.86 10.88,9.25 10.88,11.89 v2(10.95,11.97) 10.99,12 SR49.2
+SROUT12:
  vias: v1(57.44,224.7)
+SROUT12_R:
  vias: v1(70.8,226.54)
+USB3VCC0: length 369.1
  TOP w0.254: v2(237.01,34.01) 231.49,34.01 226.6,29.12 226.6,28.23 225.65,27.27 225.65,17.5 225.2,17.05 v2(225.2,15.4) ; R329.1 217.87,10.54 218.23,10.18 219.09,10.18 219.43,10.51 v2(219.68,10.51) ; v2(115.65,200.31) 117,201.66 117,203.07 116.11,203.96 ; v2(240.7,51.72) 239.71,51.72 236.05,55.38 236.05,64.78 236.74,65.46 236.74,66.35 237.12,66.73 237.12,70.06 231.54,75.63 230.89,76.28 230.89,82.23 234.37,85.71 239.42,85.71 241.21,87.5 241.21,199.17 238.79,201.58 232.32,201.58 231.43,202.47 229.14,202.47 227.57,200.9 198.48,200.9 197.26,199.68 151.12,199.68 148.58,202.22 142.73,202.22 141.74,201.23 134.88,201.23 132.19,198.53 v2(121.9,198.53)
  TOP w0.508: 123.48,209.33 117,209.33 115.48,207.8 115.48,204.6 116.11,203.96
  BOTTOM w0.254: v2(121.9,198.53) 117.43,198.53 v2(115.65,200.31) ; v2(225.2,15.4) 225.97,15.4 226.41,14.96 226.41,13.3 223.62,10.51 v2(219.68,10.51) ; v2(237.01,34.01) 238.09,34.01 238.54,34.45 238.54,37.14 238.89,37.5 238.89,44.33 238.67,44.56 238.67,49.69 v2(240.7,51.72)
  vias: v2(121.57,233.08) v2(121.57,232.32) v2(122.33,233.08) v2(122.33,232.32) v2(122.33,231.55) v2(122.71,223.68) v2(122.71,222.66) v2(122.71,221.65) v2(122.71,220.76)
+USB3VCC1: length 27.5
  TOP w0.381: U20.5 23.15,58.83 22.05,57.74 v2(22.05,58.05)
  TOP w0.508: v2(21.24,59.98) 21.67,60.41 24.13,60.41 24.83,61.1 C369.1
  BOTTOM w0.508: USB3F1.19 22.05,45.68 v2(22.05,58.05) 22.05,59.16 v2(21.24,59.98)
  BOTTOM w0.762: USB3F1.1 18.41,41.58 19.96,43.13 USB3F1.19
+USBVCC0: length 16.6
  TOP w0.102: 138.18,218.69 138.21,218.73
  TOP w0.508: v2(136.43,218.73) 136.46,218.69 C361.1 138.18,218.69 ; U17.5 v2(134.78,217.2)
  TOP w0.686: U29.6 126.91,206.03
  TOP w1.524: 126.91,206.03 129.7,206.03 131.1,207.42 EC9.1
  BOTTOM w0.508: v2(134.78,217.2) 134.91,217.2 v2(136.43,218.73)
+USBVCC1: length 118.9
  TOP w0.508: U18.5 v2(128.81,219.62)
  BOTTOM w0.508: v2(142.15,223.17) 140.49,221.52 138.06,221.52 135.23,218.69 SC48.1 133.66,218.72 133.66,219.82 132.98,220.5 129.37,220.5 128.81,219.95 v2(128.81,219.62)
  BOTTOM w1.016: v6(237.65,222.41) 226.73,222.41 223.43,225.71 220.63,225.71 219.18,224.26 182.46,224.26 179.23,227.49 179.23,230.03 176.69,232.57 v6(144.05,232.57)
+USBVCC2: length 5.8
  TOP w0.508: U15.5 v2(10.7,93.63)
  BOTTOM w0.508: F_USB2.2 7.27,95.66 9.3,93.63 v2(10.7,93.63)
+USBVCC3: length 12.7
  TOP w0.381: U14.5 v2(12.48,117.51)
  TOP w0.508: v2(13.11,121.6) 9.33,121.6 7.02,119.29
  BOTTOM w0.508: v2(12.48,117.51) 13.11,118.14 v2(13.11,121.6)
+USBVCC4: length 10.3
  TOP w0.508: U26.5 7.78,130.59 v2(7.27,130.08)
  BOTTOM w0.508: v2(7.27,130.08) 7.27,130.21 7.7,130.64 7.7,131.43 8.72,132.44 8.72,135.87 9.23,136.38 v2(9.23,137.9)
+UVDD12: length 6.7
  TOP w0.254: RLAN.43 46.28,228.02 v1(46.13,227.87) 45.5,227.24 44.58,227.24 C477.2
  TOP w0.381: C477.2 C476.2 44.36,225.84 44.99,226.47 v2(44.99,226.6)
  BOTTOM w0.508: SR43.2 45.31,226.28 v2(44.99,226.6)
+V_1P05_ME: length 262.5
  TOP w0.203: v2(48.5,41.56) 48.52,41.56 48.47,41.51 44.05,41.51 43.09,40.55 43.09,34.47 39.98,31.36 18.11,31.36 15.91,33.56 v2(15.91,34.96) ; v2(16.99,72.23) 16.81,72.41 9.75,72.41 9.1,73.06 6.28,73.06 5.33,72.11 4.64,72.11 4.16,72.59 4.16,73.27 5.61,74.72 5.61,86.01 5.11,86.51 v2(5.11,86.52) ; R188.2 14.96,167.48 12.86,165.39 10.6,165.39 9.94,166.05 v2(7.88,166.05)
  TOP w0.508: R616.1 84.96,60.61 84.48,60.13 v2(81.9,60.13)
  BOTTOM w0.203: v2(7.88,166.05) 7.88,165.79 5.96,163.88 5.96,160.6 6.77,159.8 7.07,159.8 8.03,158.83 8.03,158.15 8.66,157.53 8.66,155.1 8.03,154.47 6.55,152.99 6.55,151.77 7.69,150.63 7.69,145.94 8.66,144.98 8.66,141.28 7.87,140.49 7.87,134.6 7.13,133.86 7.13,131.34 3.55,127.76 3.55,111.17 4.62,110.1 4.62,99.85 3.55,98.78 3.55,87.62 4.66,86.52 v2(5.11,86.52) ; v2(48.5,41.56) 48.5,42.48 50.25,44.23 52.41,44.23 54.03,45.85 v1(54.03,45.88) 54.03,52.76 57.36,56.09 59.45,56.09 62.47,59.11 65.56,59.11 66.56,60.1 66.56,61.08 69.19,63.71 70.84,63.71 74.37,67.24 v2(77.83,67.24) ; v2(15.91,34.96) 15.91,37.55 15.22,38.23 15.22,47.15 15.47,47.39 15.47,59.98 16.14,60.65 16.14,64.85 15.84,65.15 15.84,66.9 16.8,67.85 16.8,72.04 v2(16.99,72.23)
  BOTTOM w0.508: v2(81.9,60.13) 80.37,61.65 80.37,66.38 v2(79.61,67.14)
  vias: v2(70.64,66.45) v2(71.28,67.09) v2(71.91,67.72) v3(44.97,95.19) v3(44.97,94.39)
+V_1P05_ME_R_B: length 5
  TOP w0.254: QN27.B 12.17,166.22 13.44,167.49 C228.2 13.44,168.99 R189.2 14.86,169.01 R188.1
+V_1P05_ME_R_C: length 13.4
  TOP w0.102: R183.1 8.41,164.65 v2(8.06,165.01)
  TOP w0.508: R183.1 8.7,163.96 9.65,163.01 C227.1 11.56,163.01 12.35,162.21 12.35,161.73 QN25.B 14.64,161.58 14.64,164.84 QN27.C
+V_1P5_PCH: length 250.7
  TOP w0.127: 59.87,101.84 58.85,101.84 58.32,101.3 56.54,101.3 PCH1.B13
  TOP w0.203: PCH1.A19 57.72,97.98 58.04,98.3 60.41,98.3 60.51,98.2 60.89,98.2 ; 59.87,101.84 60.76,102.72 63.45,102.72 R130.1 ; 58.27,89.85 58.13,89.85 57.54,90.44 PCH1.A33
  TOP w0.279: 57.75,87.03 PCH1.A38 56.4,88.38 PCH1.B37
  TOP w0.292: PCH1.K1 51.89,107.67 51.89,109.52 52.3,109.94 52.3,111.29 52.67,111.67 v2(52.67,111.79)
  TOP w0.305: 60.89,98.2 61.88,98.2 62.1,98.42 63.44,98.42 63.75,98.11 R129.1 ; PCH1.A4 56.22,105.54 PCH1.B4
  TOP w0.356: PCH1.T14 v3(48.76,101.01) ; v3(51.14,102.42) 50.76,102.42 PCH1.N11 ; v3(51.14,103.18) 50.81,103.18 PCH1.N10
  TOP w0.381: 57.75,87.03 58.33,87.03 58.58,86.77 58.58,86.65 58.4,86.47 PCH1.A40 ; PCH1.C2 55.62,107.56 PCH1.C1 55.75,107.7 55.75,107.84 56.08,108.16 56.62,108.16 57.82,106.97 57.82,106.39 56.97,105.54 PCH1.A4 ; R166.2 63.81,88.25 63.58,88.48 63.1,88.48 62.87,88.7 60,88.7 59.54,89.16 58.99,89.16 58.3,89.85 58.27,89.85
  TOP w0.406: PCH1.B39 56.77,87.29 PCH1.A39 PCH1.A40
  TOP w0.508: v2(77.12,97.75) 76.54,98.33 72.04,98.33 ; v2(72.17,91.52) 71.91,91.78 71.91,98.2 72.04,98.33 ; 96.25,111.41 98.23,111.41 99.35,110.3 C580.2 99.51,110.27 C834.2 R611.1 ; R130.1 65.59,103.26 68.21,100.64 69.73,100.64 70.11,100.26 70.11,98.61 70.39,98.33 72.04,98.33 ; PFB1.2 40.42,120.81 41.18,121.57 v2(41.56,121.57) 44.23,121.57 46.95,124.29 53.25,124.29 56.1,121.44 56.8,121.44 57.44,120.81 v2(57.44,120.17) 57.74,119.87 68.41,119.87 80.42,107.86 v2(80.42,98.08) ; 58.58,86.77 59.34,86.01 63.66,86.01 64.17,86.52 64.17,87.55 R166.2 63.81,87.92 66.58,90.69 66.58,91.02 v2(66.66,91.09) 66.66,91.12 64.9,92.87 64.9,96.2 64.17,96.93 64.17,97.28 R129.1 ; v2(38.26,129.19) 36.74,129.19 35.08,130.84 28.99,130.84 28,131.83 R264.1 ; 57.06,107.73 57.63,107.73 59.34,109.44 59.34,110.71 58.67,111.39 57.04,111.39 56.16,112.27 55.95,112.27 55.44,112.78 C250.2 54.28,112.94 R153.1 54.23,112.77 53.44,111.98 52.86,111.98 v2(52.67,111.79)
  TOP w0.635: v2(89.31,100.87) 89.57,100.87 C581.1 C582.1 90.46,104.07 91.73,105.34 92.26,105.34 95.92,109 QN55.S 95.92,111.08 96.25,111.41 R610.2
  BOTTOM w0.508: v2(57.44,120.17) 57.44,118.56 52.67,113.8 v2(52.67,111.79) 52.36,111.48 52.36,108.06 51.59,107.3 51.59,103.63 v3(51.14,103.18) v3(51.14,102.42) 51.14,101.94 50.74,101.54 SC22.1 SR21.1 49.44,101.54 49.44,101.33 49.11,101.01 v3(48.76,101.01) ; v2(89.31,100.87) 88.55,100.11 84.87,100.11 v1(84.87,100.11) 82.46,100.11 v2(80.42,98.08) 80.09,97.75 v2(77.12,97.75) ; v2(72.17,91.52) 71.99,91.7 67.27,91.7 v2(66.66,91.09) ; v2(41.56,121.57) 41.56,124.07 40.93,124.7 40.93,127.29 40.29,127.92 38.77,127.92 38.26,128.43 v2(38.26,129.19)
+V_1P05_PCH: length 483.9
  TOP w0.178: 47.06,115.51 46.01,114.46 46.01,109.68 45.78,109.46 45.78,107.8 45.78,107.04 PCH1.AB2
  TOP w0.305: v3(45.62,101.02) 45.48,101.02 PCH1.AC12 ; PCH1.AP22 39.01,96.21 v3(39.35,95.87)
  TOP w0.356: PCH1.M14 50.48,100.61 v3(50.23,100.87) ; 49.62,95.6 49.63,95.6 v3(50.02,95.21) 49.6,94.79 ; 49.62,95.6 PCH1.P23 ; 49.62,95.6 v3(50.02,95.99) 49.61,96.4 PCH1.P22 ; PCH1.W14 47.08,100.44 v3(47.49,100.03) ; PCH1.T16 48.74,99.63 v3(48.33,99.23) ; PCH1.U12 47.91,101.12 PCH1.V14 47.95,100.44 v3(48.35,100.04) ; 49.6,94.79 PCH1.P25 ; 49.6,94.79 49.62,94.79 v3(50.02,94.39) 49.61,93.98 PCH1.P26 49.6,93.98 v3(49.18,93.57) 49.57,93.18 PCH1.P28 ; v3(50.23,100.07) 49.86,100.44 PCH1.P14 ; PCH1.AA16 46.24,99.63 v3(46.64,99.23) 47.04,99.63 PCH1.W16 ; PCH1.AB19 45.37,98.02 v3(45.79,98.43) 46.21,98.02 PCH1.AA19 ; 44.55,99.63 v3(44.95,99.23) 45.35,98.82 PCH1.AB17 ; 44.55,99.63 v3(44.95,100.03) 45.35,99.63 PCH1.AB16 ; 44.55,99.63 PCH1.AD16 ; PCH1.V19 47.89,98.02 v3(47.49,97.61) 47.08,98.02 PCH1.W19 ; PCH1.V16 47.89,99.63 v3(47.49,99.23) ; PCH1.W25 47.08,94.79 v3(47.49,95.19) 47.89,94.79 PCH1.V25 ; PCH1.W23 47.08,95.6 v3(47.49,96) 47.89,95.6 PCH1.V23 ; PCH1.T19 48.78,98.02 v3(49.19,97.61) 48.79,97.21 PCH1.T20 ; PCH1.P16 49.58,99.63 v3(49.18,99.23) 49.58,98.82 PCH1.P17 ; PCH1.V22 47.89,96.4 v3(47.49,96.81) 47.89,97.21 PCH1.V20 ; PCH1.AA20 46.21,97.21 v3(45.81,97.61) 45.41,97.21 PCH1.AB20 ; PCH1.V17 47.89,98.82 v3(47.49,98.42) 47.08,98.82 PCH1.W17
  TOP w0.381: C668.1 35.99,119.7 v2(35.72,119.97)
  TOP w0.508: C243.1 61.83,75.04 v2(61.5,74.71) ; v2(98.08,94.77) 97.66,94.36 C831.2 R601.1 95.95,94.36 95.54,94.77 C829.2 ; C497.2 v2(74.99,99.85) ; v2(72.84,99.85) C498.2 C490.2 ; v2(202.85,137.83) 202.85,137.57 201.96,136.68 R15.1 ; C258.1 73.5,90.14 74.07,90.71 v2(74.07,91.47) ; v2(113.06,190.02) 113.7,190.66 113.7,191.67 119.8,197.77 132.49,197.77 135.44,200.72 141.95,200.72 142.94,201.71 148.37,201.71 150.91,199.17 197.77,199.17 198.99,200.39 228.05,200.39 228.4,200.03 237.8,200.03 239.55,198.28 239.55,178.02 v2(239.78,177.79) ; C404.2 60.36,112.9 v2(60.36,112.17) ; C403.2 62.68,113.27 v2(63.15,113.75) 64.15,113.75 C486.2 ; v2(48.55,119.67) 48.55,117.38 47.85,116.68 C259.1 47.06,116.21 47.06,115.51 ; v2(238.01,140.19) 237.73,140.19 237.01,139.48 237.01,137.57 236.63,137.19 233.84,137.19 v2(232.57,138.46) ; v2(51.34,121.79) C844.1 ; v2(63.91,99.22) 64.34,98.79 C654.2 ; R73.2 205.01,139.1 v2(205.52,138.59) ; v2(48.57,121.57) 48.85,121.57 49.37,122.09 PFB2.1 ; C698.1 v2(55.66,69.22) C697.1 ; C489.2 v2(60.33,75.25) ; R40.1 v2(205.52,142.15) 207.55,142.15 214.28,135.41 219.74,135.41 v2(220,135.16) 220.12,135.29 R985.1 ; C488.2 v2(58.17,75.32) ; C271.1 v2(72.8,96.3)
  TOP w0.762: R441.2 82.96,208.69 83.92,207.74 93.68,207.74 95.26,209.33 102.26,209.33 102.79,209.33 105.03,211.56 105.72,211.56 106.18,211.11 106.18,209.84 105.93,209.59 105.93,199.54 106.05,199.41 106.05,195.51 106.59,194.98 v5(106.59,189.9) 106.59,189.41 101.18,184 101.18,179.43 100.87,179.13 100.87,126.27 105.28,121.86 R612.2 105.89,121.19 108.14,118.94 R71.2 108.14,112.21 107.47,111.54 107.47,110.52 106.46,109.51 v5(106.46,108.49)
  BOTTOM w0.381: v3(39.35,95.87) 39.95,95.87 40.45,96.36 40.91,96.36 41.94,97.39 42.45,97.39 43.03,96.81 v3(43.21,96.81)
  BOTTOM w0.508: v2(205.52,142.15) v2(205.52,138.59) 203.61,138.59 v2(202.85,137.83) ; v2(239.78,177.79) 240.77,176.8 240.77,142.78 238.19,140.19 v2(238.01,140.19) ; v5(106.59,189.9) 112.94,189.9 v2(113.06,190.02) ; v2(220,135.16) 222.92,135.16 223.68,135.92 224.19,135.92 226.73,138.46 v2(232.57,138.46) ; v2(65.69,95.69) 65.71,95.66 SC9.2
  BOTTOM w0.762: v5(106.46,108.49) 103.56,105.59 103.56,102.1 102.11,100.65 102.11,98.81 v2(98.08,94.77) 94.37,91.07 v1(93.3,91.07) 93.3,90 91.73,88.42 v5(91.73,88.3)
  vias: v2(66.58,106.71) v2(67.34,106.71) v2(68.1,106.71) v2(68.49,99.98) v2(68.87,106.71) v2(69.25,99.98) v2(74.58,74.33) v2(74.58,73.31) v2(75.85,73.31) v2(78.77,85.38) v2(78.77,84.61) v2(79.53,85.38) v2(79.53,84.61) v2(80.3,85.38) v2(80.3,84.61) v2(81.06,85.38) v2(81.06,84.61) v2(81.82,85.38) v2(81.82,84.61) v2(82.46,72.04) v2(82.46,71.28) v2(83.22,72.8) v2(83.22,72.04) v2(83.22,71.28)
+V_3P3_BG: length 160.3
  TOP w0.178: PCH1.AE1 43.88,107.84 43.88,109.29 43.53,109.63
  TOP w0.203: 58.5,107.72 58.5,106.51 57.13,105.13 56.56,105.13 PCH1.B6
  TOP w0.254: PCH1.AW21 36,96.48 31.63,96.48 30.56,97.54 30.56,98.13 30.37,98.32
  TOP w0.305: 42.2,111.92 43.12,111 43.12,110.05 43.53,109.63
  TOP w0.457: C253.1 58.41,113.8 54.02,113.8 v2(53.79,113.57)
  TOP w0.508: 31.91,147.48 31.91,146.44 31.68,146.21 R266.2 ; 31.91,147.48 34.2,147.48 35.85,145.83 35.85,134.88 36.71,134.02 38.13,134.02 39.28,132.87 40.16,132.87 41.05,131.99 v2(41.05,131.86) ; 31.91,147.48 31.56,147.83 R267.2 ; C254.1 27.79,100.32 27.79,99.73 27.8,99.73 v2(27.85,99.73) 27.85,99.52 28.65,98.71 29.98,98.71 30.37,98.32 ; R267.2 30,148.24 QN30.S ; R267.2 31.59,148.27 R260.2 ; C253.1 59.37,112.85 59.37,111.56 59.95,110.98 59.95,109.16 58.5,107.72 ; v2(20.17,103.56) 20.17,105.19 21.52,106.53 21.52,111.18 22.94,112.61 22.94,117.94 23.64,118.64 24.41,118.64 24.98,119.21 24.98,120.61 25.52,121.15 25.52,122.09 27.33,123.91 32.8,123.91 34.38,122.33 v2(40.04,122.33) 42.07,122.33 v2(42.32,122.59) 44.35,122.59 46.68,124.92 53.51,124.92 55.67,122.77 56.49,122.77 v2(57.72,121.55) ; 42.2,111.92 41.18,112.94 41.18,120.3 41.59,120.71 v2(41.59,120.66)
  BOTTOM w0.508: v2(20.17,103.56) 20.81,103.56 22.13,102.24 22.13,101.51 v1(23.27,100.36) 23.91,99.73 v2(27.85,99.73) ; v2(41.59,120.66) 41.51,120.66 40.04,122.13 v2(40.04,122.33) ; v2(41.05,131.86) 41.23,131.68 41.23,129.78 41.94,129.06 43.34,129.06 43.72,128.68 43.72,125 42.32,123.6 v2(42.32,122.59) ; v2(53.79,113.57) 53.79,114.02 58.26,118.49 58.26,120.49 57.72,121.04 v2(57.72,121.55)
+V_3P3_EPW: length 247.7
  TOP w0.305: R182.2 2.95,164.12 1.1,162.26 1.1,150.86 2.19,149.77 v2(3.59,149.77) 3.94,150.12 6.99,150.12 QSW4.D 10.62,151.62 R651.2 11.45,151.33 R646.2 ; C273.1 50.3,81.72 50.17,81.72 49.18,82.71 PCH1.R41 ; v2(2.52,140.7) 2.17,140.34 2.17,59.7 2.9,58.96 7.16,58.96 7.39,59.19 8.64,59.19 10.83,61.37 12.86,61.37 13.3,61.82 14.35,61.82 14.41,61.75
  TOP w0.508: v2(32.2,62.39) 32.15,62.44 28.45,62.44 27.89,61.88 24.42,61.88 23.59,61.06 16.1,61.06 15.4,61.75 v2(14.64,61.75) 14.41,61.75 ; v2(50.83,78.14) 50.83,79.66 C273.1
  BOTTOM w0.305: v2(3.59,149.77) 4.1,149.26 4.1,145.17 4.1,144.05 2.52,142.48 v2(2.52,140.7)
  BOTTOM w0.508: v2(14.64,61.75) 14.64,60.93 14.19,60.48 14.19,50.87 13.32,49.99 13.32,37.15 13.68,36.79 13.68,19.48 14.84,18.32 14.84,16.28 16.1,15.02 16.1,12.16 15.21,11.27 SD1.2 SD1.1 12.61,11.15 SR50.2 ; v2(50.83,78.14) 50.83,77.44 51.59,76.68 51.59,76.17 50.3,74.87 50.3,73.03 49.19,71.91 45.81,71.91 43.99,70.1 42.13,70.1 39.78,67.75 v1(39.78,67.34) 39.78,66.96 35.21,62.39 v2(32.2,62.39)
+V_3P3_EPW_3VSB_R: length 5.9
  TOP w0.102: v2(6.36,165.36) 6.86,164.86 R182.1
  TOP w0.508: R184.2 R181.1 8.87,162.55 R183.2 8.26,163.01 7.14,164.12 R182.1
+V_3P3_LAN: length 307.5
  TOP w0.203: ILAN.4 70.91,211.5 70.52,211.11 v2(70.52,210.85) 71.03,210.85 71.28,211.11 71.28,211.71 71.31,211.74 ILAN.5 ; ILAN.29 72.51,220.1 C442.2 ; ILAN.15 v2(73.87,213.62) ; ILAN.19 v2(73.89,215.22)
  TOP w0.508: C442.2 73.69,221.46 73.69,222.16 v2(73.31,222.54) ; C499.1 103.97,213.77 v2(104.05,213.7) ; 66.07,204.32 66.2,204.45 66.2,205.39 66.76,205.95 66.76,206.9 R444.1 66.58,207.2 67.09,207.71 67.09,208.53 R431.2 67.76,209.74 68.29,210.28 69.95,210.28 v2(70.52,210.85) ; v2(82.2,218.85) 81.57,218.22 R463.2 79.57,219.39 C483.2 ; v2(81.64,220.5) 81.13,221.01 R462.2 80.74,221.39 79.15,222.98 79.15,225.58 78.52,226.22 77.12,226.22 76.65,225.74 R443.2 74.96,225.46 74.58,225.08 73.38,225.08 72.49,225.97 C669.2 71.45,225.97 69.81,224.33 68.8,224.33 67.83,223.36 67.83,222.82 v2(68.1,222.54) R448.2 R447.2 ; 104.93,207.3 104.93,210.32 v2(105.36,210.75) ; v2(102.27,213.01) 102.14,213.14 U28.5 ; 99.44,217.11 C699.2 100.65,217.11 101.25,217.71 101.25,219.31 102.9,220.96 v2(102.9,222.54) ; 99.44,217.11 v2(99.35,217.2) ; 99.44,217.11 98.73,217.11 D38.N 97.68,216.06 92.87,216.06 91.47,214.66 ; QP9.S C450.2 ; C450.2 20.57,206.88 19.96,207.5 18.51,207.5 17.18,206.17 17.18,202.72 ; C450.2 C856.2 ; v5(16.16,201.07) 11.72,196.63 11.72,189.01 14.87,185.86 14.87,177.07 11.82,174.02 v2(10.57,174.02) ; v2(91.09,218.85) 90.71,218.47 90.71,215.42 91.47,214.66 ; 91.47,214.66 v2(91.47,213.77) ; R642.2 v2(10.9,149.64) R651.1 10.55,150.38 QSW4.S
  TOP w0.762: EC30.1 93.78,205.9 84.87,205.9 83.29,204.32 62.19,204.32 61.63,204.88 ; 17.18,202.72 R450.2 17.18,202.09 v5(16.16,201.07) ; v5(49.13,207.63) 39.22,207.63 38.69,208.16 36.13,208.16 35.16,207.19 35.16,202.79 34.23,201.86 v5(25.33,201.86) ; C670.1 58.2,208.06 v5(57.82,208.44)
  BOTTOM w0.508: v2(91.47,213.77) 93.09,213.77 93.35,213.52 SC10.2 93.47,213.14 SU2.5 ; 104.05,213.01 104.55,212.5 104.55,211.54 105.34,210.75 v2(105.36,210.75) ; 104.05,213.01 v2(104.05,213.7) ; 104.05,213.01 v2(102.27,213.01) ; v2(91.09,218.85) v2(82.2,218.85) 82.2,219.23 81.64,219.79 v2(81.64,220.5) ; v2(102.9,222.54) 105.06,222.54 106.84,224.31 106.84,225.58 107.47,226.22 118.82,226.22 118.95,226.1 121.12,223.92 USB3_LAN.32 ; v2(73.31,222.54) 73.31,222.16 72.8,221.65 68.99,221.65 v2(68.1,222.54) 68.1,218.78 67.34,218.02 67.34,213.01 68.19,212.16 68.19,211.2 68.54,210.85 v2(70.52,210.85) 70.52,211.49 71.15,212.12 73.18,212.12 73.87,212.81 v2(73.87,213.62) 73.87,215.2 v2(73.89,215.22) ; v2(10.57,174.02) 10.07,173.51 10.07,172.18 12.16,170.09 12.16,162.21 11.08,161.13 11.08,149.82 v2(10.9,149.64) ; SU1.5 v2(99.35,217.2)
  BOTTOM w0.762: v5(25.33,201.86) 25.08,201.86 23.15,199.93 23.15,198.72 ; v5(16.16,201.07) 17.69,199.55 17.69,198.98 ; v5(57.82,208.44) 53.83,208.44 53.02,207.63 v5(49.13,207.63)
+VCOMP_OUT: length 24.7
  TOP w0.305: 135.49,139.78 136.19,139.78 136.99,138.98 137.81,138.98 137.97,138.83 137.97,136.79 R4.1
  TOP w0.381: CPU1.P4 v4(143.79,132.98)
  TOP w0.508: v4(136.68,132.24) 134.08,134.84 134.08,135.92 134.43,136.27 ; 135.49,139.78 134.68,139.78 133.98,139.09 133.98,136.72 134.43,136.27 ; 134.43,136.27 R1.1
  BOTTOM w0.508: v4(136.68,132.24) v1(137.7,132.24) 138.21,132.24 138.87,132.9 140.7,132.9 141.28,132.32 143.13,132.32 v4(143.79,132.98)
+VCORE: length 225.2
  TOP w0.102: P2.2 165.52,172.82
  TOP w0.127: L9.2 187.8,170.85 P4.2 ; L11.2 146.34,172.94 P8.2 ; L10.2 210.4,167.22 P6.2 ; 165.52,172.82 L8.2
  TOP w0.254: v2(239.71,47.78) 238.51,48.98 237.6,48.98 233.51,53.07 233.51,61.54 232.49,62.56 232.49,67.67 230.92,69.25 227.92,69.25 227.17,70 226.75,70.79 225.97,72.98 225.97,76.2 226.75,76.99 226.75,84.39 230.92,88.55 v2(230.92,89.82) ; v2(216.69,148.5) 216.69,149.26 220.76,153.32 v2(222.03,153.32) ; v2(227.97,9.3) 227.87,9.3 227.08,10.1 R331.1 ; v2(236.09,137.99) R846.1 236.09,141.45 235.49,142.05 v2(235.36,142.05) ; v2(200.69,155.23) 202.98,152.94 204.38,152.94 v2(205.01,152.31)
  TOP w0.305: CPU1.M8 v4(147.45,134.8) ; CPU1.P8 v4(147.45,132.98)
  BOTTOM w0.254: v2(222.03,153.32) 225.08,153.32 225.56,152.84 235.47,152.84 236.51,151.8 236.51,144.43 236.89,144.05 236.89,142.91 236.03,142.05 v2(235.36,142.05) ; v2(230.92,89.82) 230.92,92.11 229.9,93.12 229.9,98.67 228.81,99.76 228.81,104.19 231.81,107.19 231.81,108.34 233.54,110.07 236.18,110.07 238.92,112.81 238.92,135.16 v2(236.09,137.99) ; v2(205.01,152.31) 205.01,151.82 208.03,148.8 216.39,148.8 v2(216.69,148.5) ; v2(239.71,47.78) 239.43,47.51 239.43,45.12 239.66,44.89 239.66,40.34 240.55,39.45 240.55,29.92 v1(239.3,28.67) 236.7,26.07 236.7,22.99 238.09,21.59 238.09,20.57 236.7,19.18 236.7,17.8 228.2,9.3 v2(227.97,9.3)
  vias: v2(142.53,163.35) v2(143.8,164.62) v2(143.8,162.08) v2(144.94,163.35) v2(146.21,171.1) v2(146.59,169.7) v2(147.73,168.69) v2(149.64,168.82) v2(149.64,163.35) v2(150.53,160.05) v2(150.91,164.62) v2(150.91,162.08) v2(151.8,133.13) v2(152.05,163.35) v2(152.56,158.02) v2(152.94,126.02) v2(152.94,125.25) v2(153.19,132.11) v2(153.19,131.35) v2(153.19,130.08) v2(153.19,129.32) v2(153.19,128.05) v2(153.19,127.29) v2(154.21,133.13) v2(155.1,155.61) v2(157.13,153.7) v2(158.91,151.8) v2(160.05,133.13) v2(160.94,163.35) v2(160.94,149.51) v2(161.07,158.91) v2(161.2,132.11) v2(161.2,131.35) v2(161.2,130.08) v2(161.2,129.32) v2(161.2,128.05) v2(161.2,127.29) v2(161.2,126.02) v2(161.2,125.25) v2(162.21,164.62) v2(162.21,162.08) v2(162.34,133.13) v2(163.48,163.35) v2(165.13,170.72) v2(165.77,169.32) v2(167.29,168.56) v2(168.05,163.35) v2(168.18,133.13) v2(168.94,168.82) v2(169.32,164.62) v2(169.32,162.08) v2(169.32,132.37) v2(169.32,131.48) v2(169.32,130.59) v2(169.32,129.7) v2(169.32,128.94) v2(169.32,128.05) v2(169.32,127.29) v2(170.09,158.91) v2(170.59,163.35) v2(177.2,159.04) v2(179.23,163.35) v2(179.74,150.65) v2(180.37,162.08) v2(181.64,163.35) v2(182.53,153.19) v2(185.71,158.91) v2(185.71,154.46) v2(185.83,163.61) v2(186.6,169.83) v2(187.36,168.82) v2(190.02,169.07) v2(190.53,170.09) v2(190.66,171.48) v2(191.29,159.04) v2(191.29,154.59) v2(191.42,163.48) v2(197.14,154.46) v2(197.39,158.91) v2(199.42,156.5) v2(200.69,157.77) v2(207.42,168.43) v2(208.19,165.13) v2(208.57,169.32) v2(209.46,165.13) v4(153.86,135.72) v4(155.69,135.72) v4(157.51,137.55) v4(157.51,135.72) v4(159.34,138.46) v4(159.34,135.72) v4(161.17,147.61) v4(161.17,145.78) v4(161.17,143.95) v4(161.17,142.12) v4(161.17,140.29) v4(161.17,138.46) v4(161.17,136.63) v4(161.17,134.8) v4(163,147.61) v4(163,145.78) v4(163,143.95) v4(163,142.12) v4(163,140.29) v4(163,138.46) v4(163,136.63) v4(163,134.8) v4(164.83,147.61) v4(164.83,145.78) v4(164.83,143.95) v4(164.83,142.12) v4(164.83,140.29) v4(164.83,138.46) v4(164.83,136.63) v4(164.83,134.8) v4(166.65,147.61) v4(166.65,145.78) v4(166.65,143.95) v4(166.65,142.12) v4(166.65,140.29) v4(166.65,138.46) v4(166.65,136.63) v4(166.65,134.8) v4(168.48,147.61) v4(170.04,147.61) v4(171.59,147.61) v4(171.59,145.78) v4(171.6,143.95) v4(171.6,142.12) v4(171.6,140.29) v4(171.6,138.46) v4(171.6,136.63) v4(171.6,134.8) v4(173.42,147.61) v4(173.42,145.78) v4(173.43,143.95) v4(173.43,142.12) v4(173.43,140.29) v4(173.43,138.46) v4(173.43,136.63) v4(173.43,135.72) v4(175.25,147.61) v4(175.25,145.78) v4(177.08,147.61)
+VDIMM: length 381.3
  TOP w0.203: v2(88.04,88.17) 89.19,89.31 94.77,89.31 ; v2(16.29,105.06) 14.89,105.06 14.76,105.19 RJ4.3 ; v2(16.03,112.81) 16.29,112.55 19.08,112.55 20.1,111.54 21.14,111.54 22.33,112.73 22.33,114.51 20.89,115.96 20.89,118.52 21.8,119.44 22.53,119.44 23.53,120.44 24.12,120.44 25.04,121.35 25.04,122.29 27.13,124.39 33,124.39 34.3,123.1 41.82,123.1 41.99,123.27 44.13,123.27 46.42,125.56 53.78,125.56 55.75,123.59 56.84,123.59 58.43,122 58.43,121.19 59.11,120.5 68.67,120.5 81.31,107.86 81.31,92.72 v2(81.59,92.44)
  TOP w0.254: v2(227.41,8.73) 226.98,8.73 225.9,9.81 R332.1 ; v2(240.06,45.63) 239.55,46.13 233.08,46.13 232.06,45.12 230.97,45.12 230.26,44.41 227.04,44.41 225.46,42.83 225.46,41.85 220.97,37.37 209.33,37.37 v2(209.23,37.27) ; v2(203.44,37.14) 203.41,37.12 197.14,37.12 196.5,36.48 196.5,32.93 v2(195.99,32.42)
  TOP w0.305: CPU1.AT22 161.54,111.94 v4(161.51,111.94) ; CPU1.AY14 v4(154.68,108.11) ; CPU1.AU15 155.14,111.03 v4(155.17,111.03) ; CPU1.AV13 v4(154.22,111.03) ; CPU1.AW16 v4(156.05,109.2)
  TOP w0.356: v4(153.28,119.26) 153.74,118.8 CPU1.AJ13 ; CPU1.AY9 v4(148.35,110.1) ; CPU1.AJ17 157.42,118.83 v4(157.86,119.26) ; CPU1.AU20 159.76,111.92 v4(159.74,111.94) ; CPU1.AJ20 160.17,118.83 v4(160.6,119.26) 161.06,118.8 CPU1.AJ21 ; v4(147.44,111.93) 147.43,111.92 146.99,111.46 CPU1.AV8 ; CPU1.AJ15 155.57,118.8 v4(155.11,119.26) ; CPU1.AY12 152.85,108.19 v4(152.77,108.11) ; CPU1.AV23 v4(163.39,111.03) 163.82,111.46 CPU1.AU24 ; CPU1.AJ28 v4(167.94,119.26) CPU1.AJ29 ; v4(157.88,111.03) CPU1.AV18 ; v4(157.88,111.96) 157.44,112.4 CPU1.AT17 ; CPU1.AJ25 v4(164.28,119.26) CPU1.AJ24 ; CPU1.AJ9 v4(148.37,120.17) ; CPU1.AJ12 v4(152.39,119.26) ; v4(151.31,110.22) 151.66,110.57 CPU1.AV11 ; CPU1.AV10 v4(148.35,111.02)
  TOP w0.381: C134.1 157.92,75.29 157.93,75.27 DIMM4.60 ; C132.1 152.05,76.49 152.05,74.9 DIMM4.66 ; DIMM4.72 145.93,76.47 C131.1 ; v4(143.75,58.45) 143.96,58.23 C177.1 R113.1
  TOP w0.508: C152.1 148.88,49.06 DIMM3.189 ; C46.2 162.59,57.18 162.85,57.44 v2(162.85,58.07) ; DIMM2.179 159.67,60.59 C45.2 ; C146.1 v2(153.35,36.26) ; DIMM3.78 139.99,54.87 C158.1 C154.1 ; R576.2 155.86,23.5 155.07,23.5 154.31,24.26 154.31,24.7 v2(153.83,25.18) ; C171.1 141,49.05 DIMM3.197 ; DIMM3.179 158.91,49.1 C167.1 ; C169.1 155.96,60.3 DIMM2.183 ; v4(166.99,55.89) 167.42,56.32 C150.1 ; C155.1 v2(155.51,36.26) ; v2(213.11,56.17) 213.48,56.53 C182.1 215.22,56.53 R120.1 ; C173.1 146.84,49.03 DIMM3.191 ; C133.1 139.93,76.52 DIMM4.78 ; C151.1 v2(151.19,36.26) ; C157.1 158.94,37.88 158.93,37.88 DIMM1.179 ; DIMM2.197 140.93,59.38 C164.1 141.35,58.96 C43.2 143.24,58.96 v4(143.75,58.45) ; C170.1 157.39,55.37 DIMM3.60 ; DIMM1.170 168.91,40.7 170.02,39.59 C149.1 ; C130.1 163.94,74.79 DIMM4.54 ; DIMM1.66 151.93,45.92 C153.1 ; v2(213.06,59.95) 213.75,59.95 214.1,59.6 C181.1 R119.1 ; C44.2 152.65,57.18 C175.1 151.93,56.39 151.93,54.83 DIMM3.66 ; C145.1 143.48,36.99 C142.1 v2(144.72,36.26) ; C176.1 154.72,48.9 DIMM3.183 ; DIMM3.54 164.28,55.16 C172.1 ; DIMM3.62 155.93,55.81 155.93,55.81 C165.1 ; C147.1 v2(146.88,36.26) ; C148.1 v2(149.04,36.26) ; C166.1 166.02,60.24 DIMM2.173 ; DIMM3.72 145.93,54.83 145.93,55.91 145.92,55.92 C143.1 ; C141.1 164.88,49.06 DIMM3.173 ; v4(158.81,60.08) 158.38,60.08 158.15,59.85 C174.1 ; C163.1 C168.1 164.56,37.63 164.93,38.01 DIMM1.173 ; C144.1 v4(168.82,56.17) ; C156.1 v2(157.67,36.26)
  BOTTOM w0.203: v2(81.59,92.44) 81.67,92.36 83.85,92.36 v2(88.04,88.17) ; v2(16.29,105.06) 15.91,105.44 15.91,112.68 v2(16.03,112.81)
  BOTTOM w0.254: v2(203.44,37.14) 203.87,37.57 208.92,37.57 v2(209.23,37.27) ; v2(195.99,32.42) 195.64,32.06 195.64,27.24 194.08,25.69 177.63,25.69 176.92,24.98 154.03,24.98 v2(153.83,25.18) ; v2(240.06,45.63) 240.04,45.6 240.04,40.49 240.93,39.61 240.93,29.38 237.08,25.53 237.08,23.15 238.48,21.75 238.48,20.42 237.08,19.02 237.08,17.62 228.19,8.73 v2(227.41,8.73)
  BOTTOM w0.508: SR22.2 168.28,122.68 168.24,122.65 ; v2(153.83,25.18) 150.91,28.1 150.91,29.62
  vias: v2(94.14,61.81) v2(94.14,61.04) v2(94.14,60.28) v2(94.39,78.77) v2(94.39,77.88) v2(95.16,78.77) v2(95.66,85.12) v2(95.79,83.98) v2(97.06,85.12) v2(97.19,83.98) v2(98.71,85.12) v2(98.71,83.98) v2(100.24,85.12) v2(102.27,92.36) v2(102.27,91.47) v2(102.27,90.46) v2(102.27,89.31) v2(102.27,88.17) v2(103.03,32.54) v2(103.28,92.36) v2(103.28,91.47) v2(103.28,90.46) v2(103.28,89.31) v2(103.28,88.17) v2(103.79,32.54) v2(104.55,32.54) v2(105.32,32.54) v2(106.08,32.54) v2(130.97,31.78) v2(132.24,32.93) v2(132.24,30.51) v2(133.26,31.78) v2(133.64,35.34) v2(137.95,31.66) v2(139.22,32.93) v2(139.22,30.51) v2(140.49,31.66) v2(144.05,32.8) v2(144.05,31.4) v2(145.7,31.27) v2(147.35,31.53) v2(148.11,30.64) v2(149.38,30.26) v2(150.53,30.64) v2(150.91,120.81) v2(151.16,32.93) v2(151.42,31.66) v2(152.05,122.46) v2(152.05,121.7) v2(152.43,29.62) v2(153.19,120.81) v2(153.58,30.89) v2(154.85,32.93) v2(155.23,120.81) v2(156.37,122.46) v2(156.37,121.7) v2(157.51,120.81) v2(159.54,120.81) v2(160.69,122.33) v2(160.69,121.57) v2(161.83,120.81) v2(163.86,120.81) v2(165.01,122.33) v2(165.01,121.57) v2(166.15,120.81) v2(168.31,120.81)
