# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_RX_N1: length 157.1
  TOP w0.102: PCH1.G18 53.57,98.58 v3(53.29,98.86)
  TOP w0.127: RN39.5 111.82,210.57 112.12,210.27 112.12,209.94 109.94,207.75 109.94,204.93 v1(109.51,204.5) 109.94,204.07 109.94,197.73 v2(109.54,197.34)
  BOTTOM w0.102: 64.29,105.49 64.24,105.54 63.52,105.54 59.1,101.12 58.41,101.12 56.61,99.33 53.13,99.33 52.98,99.18 52.98,98.92 53.05,98.86 v3(53.29,98.86)
  BOTTOM w0.127: 64.29,105.49 69.45,105.49 75.29,111.34 82.73,111.34 86.12,114.72 86.12,184.67 96.93,195.49 104.1,195.49 106.84,198.23 109.63,198.23 110.07,197.8 110.07,197.26 109.94,197.14 109.75,197.14 v2(109.54,197.34)
USB3_RX_N1_R: length 18
  TOP w0.127: RN39.6 111.82,213.37 112.01,213.56 112.01,214.24 111.91,214.34 D17.4 D17.7 111.91,216.26 112.01,216.35 112.01,219.37 113.14,220.5 113.14,222.79 111.87,224.06 111.87,225.97 110.8,227.04 110.8,228.03 110.03,228.8 USB3_LAN.14
USB3_RX_N4: length 67.7
  TOP w0.102: v3(52.46,97.82) 52.43,97.82 52.14,97.53 PCH1.K20
  TOP w0.127: RN24.1 31.2,49.87 31.48,50.15 33.51,50.15 34.12,50.76 34.12,52.04 v2(34.07,52.09)
  BOTTOM w0.102: v3(52.46,97.82) 52.2,97.57 52.2,97.21 51.24,96.25 51.24,93.33 50.53,92.62 50.53,91.43 50.92,91.04 51.48,91.04 52.43,90.08 52.43,87.46 53.21,86.68 53.26,86.68
  BOTTOM w0.127: 53.26,86.68 53.67,86.27 53.67,80.7 55.25,79.12 55.25,75.97 v1(55.6,75.62) 55.25,75.28 55.25,73.72 49.51,67.98 46.97,67.98 42.75,63.76 40.09,63.76 37.85,61.53 37.85,60.41 33.1,55.66 33.1,53.63 33.76,52.97 33.76,52.39 v2(34.07,52.09)
USB3_RX_N4_R: length 15.5
  TOP w0.127: RN24.2 28.21,49.87 27.91,50.17 27.34,50.17 27.25,50.09 D3.1 D3.10 25.24,50.09 25.15,50.17 23.3,50.17 22.36,49.23 22.36,46.44 20.35,44.43 18.8,44.43 USB3F1.2
USB3_RX_N5: length 67.2
  TOP w0.102: v3(51.23,98.87) 51.23,98.87 51.23,98.86 51.43,98.66 PCH1.L18
  TOP w0.127: v2(32.15,51.38) 31.83,51.7 31.5,51.7 31.3,51.49 RN24.5
  BOTTOM w0.102: 52.32,84.82 52.36,84.85 52.36,85.67 51.72,86.31 51.72,89.77 51.16,90.33 50.58,90.33 49.72,91.18 49.72,92.91 50.48,93.67 50.48,96.61 51.04,97.17 51.04,98.03 51.39,98.39 51.39,98.7 v3(51.23,98.87)
  BOTTOM w0.127: 52.32,84.82 52.32,80.17 53.4,79.1 53.4,73.65 49.04,69.3 46.51,69.3 42.3,65.08 39.25,65.08 36.28,62.11 36.28,60.66 31.71,56.09 31.15,56.09 30.46,55.4 30.46,53.47 v1(30.13,53.14) 30.46,52.81 30.46,52.1 31.02,51.54 31.98,51.54 v2(32.15,51.38)
USB3_RX_N5_R: length 13.6
  TOP w0.127: USB3F1.18 19.96,46.07 20.37,46.48 20.95,46.48 21.42,46.95 21.42,49.69 23.45,51.72 25.17,51.72 25.31,51.59 D3.7 D3.4 27.08,51.59 27.16,51.67 28.02,51.67 28.2,51.49 RN24.6
USB3_RX_P0: length 153.9
  TOP w0.102: PCH1.G20 53.2,97.64 v3(53.2,97.77)
  TOP w0.127: v2(107.64,197.26) 107.73,197.26 107.93,197.47 107.93,198.84 v1(107.6,199.17) 107.93,199.5 107.93,207.37 110.37,209.81 110.37,210.27 110.1,210.54 CMK30.4
  BOTTOM w0.102: v3(53.2,97.77) 53.27,97.77 53.47,97.97 53.47,98.23 53.7,98.46 54.61,98.46 55.07,98.91 56.88,98.91 58.68,100.72 59.49,100.72 63.51,104.74 64.23,104.74 64.29,104.81
  BOTTOM w0.127: v2(107.64,197.26) 107.83,197.26 107.93,197.16 107.93,196.45 106.33,194.85 97.2,194.85 86.75,184.41 86.75,114.46 82.9,110.6 75.45,110.6 69.66,104.81 64.29,104.81
USB3_RX_P0_R: length 29.3
  TOP w0.127: USB3_LAN.6 111.52,232 111.36,232.16 111.36,232.7 111.84,233.18 111.84,234.22 111.08,234.98 109.74,234.98 108.44,233.69 108.44,231.43 109.1,230.77 109.1,229.58 108.81,229.29 108.81,226.74 109.33,226.22 109.33,224.06 110.52,222.87 110.52,216.37 110.41,216.26 D17.10 D17.1 110.41,214.34 110.51,214.24 110.51,214.03 110.37,213.89 110.37,213.52 110.1,213.25 CMK30.3
USB3_RX_P1: length 157.1
  TOP w0.102: v3(52.58,98.86) 52.85,98.58 PCH1.H18
  TOP w0.127: v2(110.56,197.34) 110.42,197.34 110.24,197.52 110.24,205.62 v1(110.65,206.03) 110.24,206.43 110.24,207.63 112.43,209.81 112.43,210.37 112.63,210.57 RN39.7
  BOTTOM w0.102: 64.29,105.8 64.27,105.8 64.22,105.75 63.43,105.75 59.01,101.33 58.33,101.33 56.53,99.53 53.05,99.53 52.78,99.26 52.78,99.06 v3(52.58,98.86)
  BOTTOM w0.127: 64.29,105.8 69.32,105.8 75.16,111.64 82.61,111.64 85.81,114.85 85.81,184.8 96.81,195.79 103.97,195.79 106.71,198.53 109.76,198.53 110.37,197.92 110.37,197.53 v2(110.56,197.34)
USB3_RX_P1_R: length 18
  TOP w0.127: RN39.8 112.63,213.32 112.31,213.63 112.31,214.24 112.41,214.34 D17.5 D17.6 112.41,216.26 112.31,216.35 112.31,219.25 113.44,220.38 113.44,222.92 112.17,224.19 112.17,226.09 111.1,227.17 111.1,227.98 USB3_LAN.15
USB3_RX_P4: length 67.7
  TOP w0.102: v3(51.8,97.82) 51.43,97.46 PCH1.L20
  TOP w0.127: RN24.3 31.17,50.68 31.4,50.45 33.38,50.45 33.81,50.88 33.81,51.54 33.6,51.76 33.6,51.99 33.41,52.18 33.24,52.18 v2(33.15,52.09)
  BOTTOM w0.102: 53.04,86.47 53.04,86.56 52.23,87.37 52.23,90 51.39,90.84 50.83,90.84 50.32,91.35 50.32,92.7 51.04,93.41 51.04,96.33 52,97.3 52,97.62 v3(51.8,97.82)
  BOTTOM w0.127: 53.04,86.47 53.37,86.14 53.37,80.58 54.95,79 54.95,77.46 v1(54.6,77.12) 54.95,76.78 54.95,73.85 49.38,68.28 46.84,68.28 42.63,64.07 39.96,64.07 37.55,61.65 37.55,60.54 32.8,55.79 32.8,53.5 33.46,52.84 33.46,52.33 33.22,52.09 v2(33.15,52.09)
USB3_RX_P4_R: length 15.6
  TOP w0.127: RN24.4 28.18,50.68 27.97,50.48 27.34,50.48 27.23,50.59 D3.2 D3.9 25.18,50.59 25.07,50.48 23.17,50.48 22.05,49.36 22.05,46.57 20.22,44.73 18.71,44.73 17.96,45.48 USB3F1.3
USB3_RX_P5: length 67.3
  TOP w0.102: v3(51.91,98.86) 51.92,98.86 51.92,98.56 PCH1.K18
  TOP w0.127: v2(32.15,52.27) 31.88,52 31.45,52 31.15,52.31 RN24.7
  BOTTOM w0.102: 52.63,84.82 52.56,84.89 52.56,85.76 51.92,86.39 51.92,89.86 51.25,90.53 50.66,90.53 49.93,91.27 49.93,92.83 50.68,93.58 50.68,96.53 51.24,97.09 51.24,97.95 51.59,98.31 51.59,98.69 51.77,98.86 v3(51.91,98.86)
  BOTTOM w0.127: v2(32.15,52.27) 32.21,52.2 32.21,51.95 32.11,51.85 31.15,51.85 30.77,52.23 30.77,54.21 v1(31.15,54.59) 30.77,54.97 30.77,55.28 31.27,55.79 31.83,55.79 36.58,60.54 36.58,61.98 39.38,64.78 42.42,64.78 46.64,68.99 49.17,68.99 53.7,73.53 53.7,79.22 52.63,80.3 52.63,84.82
USB3_RX_P5_R: length 13.5
  TOP w0.127: RN24.8 28.3,52.31 27.97,51.98 27.26,51.98 27.15,52.09 D3.5 D3.6 25.31,52.09 25.25,52.03 23.32,52.03 21.11,49.82 21.11,47.07 20.82,46.78 20.33,46.78 19.96,47.15 USB3F1.17
USB3_TX_N0: length 152.9
  TOP w0.102: v2(62.87,100.24) 63.02,100.24 63.18,100.08 63.18,99.85 63.05,99.73 62.13,99.73 61.26,98.86 57.87,98.86 57.48,98.46 56.62,98.46 PCH1.B18
  TOP w0.127: v2(113.85,200.08) 113.56,200.38 113.56,201.37 113.94,201.75 113.94,202.69 v1(114.28,203.03) 113.94,203.37 113.94,205.54 C500.1
  BOTTOM w0.102: v2(62.87,100.24) 62.87,99.94 62.71,99.78 62.41,99.78 62.19,100.01 62.19,100.84 63.87,102.52 64.23,102.52 64.28,102.47 64.29,102.47
  BOTTOM w0.127: 64.29,102.47 70.53,102.47 76.47,108.41 83.83,108.41 88.95,113.53 88.95,183.51 98,192.56 110.27,192.56 113.95,196.25 113.95,198.89 113.61,199.23 113.61,199.84 v2(113.85,200.08)
USB3_TX_N0_C: length 5.5
  TOP w0.127: RN40.7 116.44,210.45 116.19,210.19 116.19,209.79 113.91,207.51 113.91,207.3 C500.2
USB3_TX_N0_R: length 30.7
  TOP w0.127: USB3_LAN.8 116.18,232 116.54,232.37 116.54,232.7 116.03,233.21 116.03,234.32 116.82,235.11 118.04,235.11 119.46,233.69 119.46,231.4 118.76,230.7 118.76,229.56 119.07,229.26 119.07,226.87 119.9,226.04 119.9,224.06 118.52,222.69 118.52,221.27 116.12,218.87 116.12,216.35 116.22,216.26 D16.1 D16.10 116.22,214.54 116.12,214.44 116.12,214.22 116.19,214.15 116.19,213.8 116.44,213.55 RN40.8
USB3_TX_N1: length 146.4
  TOP w0.102: PCH1.B15 56.29,99.61 56.29,99.51 56.84,98.96 57.26,98.96 57.66,99.37 60.6,99.37 60.87,99.63 60.87,99.88 60.69,100.06 60.51,100.06 v2(60.45,99.99)
  TOP w0.127: v2(111.16,198.8) 111.48,199.12 111.48,199.89 v1(111.08,200.29) 111.48,200.68 111.48,202.82 C503.1
  BOTTOM w0.102: v2(60.45,99.99) 60.62,99.99 60.79,100.16 60.79,100.83 63.7,103.74 64.23,103.74 64.28,103.79 64.29,103.79
  BOTTOM w0.127: 64.29,103.79 70.09,103.79 75.95,109.66 83.29,109.66 87.69,114.07 87.69,184.02 97.51,193.83 109.33,193.83 111.45,195.95 111.45,198.61 111.26,198.8 v2(111.16,198.8)
USB3_TX_N1_C: length 8.3
  TOP w0.127: CMK31.4 113.91,210.54 114.18,210.27 114.18,209.99 111.6,207.41 111.6,205.2 111.03,204.63 C503.2
USB3_TX_N1_R: length 17.6
  TOP w0.127: USB3_LAN.17 116.8,227.93 116.8,223.98 115.68,222.87 115.68,220.76 114.32,219.4 114.32,216.35 114.22,216.26 D16.5 D16.6 114.22,214.54 114.32,214.44 114.32,214.03 114.18,213.89 114.18,213.52 113.91,213.25 CMK31.3
USB3_TX_N4: length 85.2
  TOP w0.102: PCH1.D15 55.54,100.15 55.79,100.21 56.18,100.21 56.39,100.29 56.73,100.29 56.8,100.23 57.35,100.23 57.51,100.38 58.9,100.38 59.29,100.77 61.04,100.77 61.47,101.2 64.1,101.2 64.15,101.25 64.17,101.25
  TOP w0.127: C364.1 34.41,53.49 34.81,53.49 v2(35.05,53.25) ; 64.17,101.25 65.06,101.25 65.92,100.39 65.92,97.59 66.89,96.63 66.89,94.21 70.85,90.25 70.85,87.36 72.6,85.6 72.6,83.98 70.06,81.44 70.06,78.48 64.33,72.75 61.5,72.75 v2(61.2,72.45)
  BOTTOM w0.127: v2(35.05,53.25) 35.45,53.65 35.63,53.65 38.08,56.11 38.08,56.65 38.44,57 v1(38.92,57) 38.92,57.49 40.04,58.6 40.76,58.6 48.1,65.95 50.13,65.95 54.51,70.32 57.15,70.32 57.47,70.64 59.82,70.64 61.04,71.86 61.04,72.3 v2(61.2,72.45)
USB3_TX_N4_C: length 3
  TOP w0.127: C364.2 32.67,53.54 32.33,53.54 31.71,54.16 31.43,54.16 31.2,53.93 RN25.1
USB3_TX_N4_R: length 13.1
  TOP w0.127: CMK21.3 28.32,53.84 28.05,54.11 27.47,54.11 27.33,54.25 26.96,54.25 26.86,54.15 D2.1 D2.10 25.09,54.15 24.98,54.26 24.59,54.26 20.76,50.43 18.8,50.43 USB3F1.5
USB3_TX_N5: length 87.7
  TOP w0.102: PCH1.B14 56.16,100.62 56.62,100.62 56.87,100.87 58.65,100.87 59.11,101.33 60.53,101.33 61.34,102.14 64.12,102.14 64.17,102.19
  TOP w0.127: v2(35.3,55.53) 34.98,55.85 34.48,55.85 C366.1 ; v2(58.3,72.65) 58.5,72.65 59.91,71.24 64.16,71.24 71.08,78.16 71.08,81.06 73.54,83.52 73.54,86.06 71.79,87.81 71.79,90.64 67.9,94.53 67.9,97.14 66.86,98.18 66.86,100.79 65.46,102.19 64.17,102.19
  BOTTOM w0.127: v2(35.3,55.53) 35.56,55.79 36.15,55.79 36.99,56.62 36.99,58.02 39.4,60.43 v1(39.91,60.43) 39.91,60.94 40.49,61.53 41.94,61.53 47.38,66.96 49.82,66.96 54.44,71.58 57.59,71.58 58.12,72.12 58.12,72.47 v2(58.3,72.65)
USB3_TX_N5_C: length 2.8
  TOP w0.127: C366.2 32.65,55.84 31.54,55.84 31.26,55.56 RN25.5
USB3_TX_N5_R: length 10.9
  TOP w0.127: USB3F1.15 19.96,51.6 20.78,52.43 21.23,52.43 24.57,55.76 24.98,55.76 25.08,55.65 D2.7 D2.4 26.86,55.65 26.96,55.75 27.4,55.75 27.46,55.81 27.97,55.81 28.23,55.56 RN25.6
USB3_TX_P0: length 153
  TOP w0.102: v2(62.87,99.26) 62.61,99.52 62.22,99.52 61.35,98.65 57.96,98.65 57.56,98.26 56.54,98.26 56.25,98.41 56.22,98.44 PCH1.C18
  TOP w0.127: C501.1 113.63,205.49 113.63,204.85 v1(113.29,204.5) 113.63,204.16 113.63,201.87 113.25,201.49 113.25,200.18 113.15,200.08 v2(112.96,200.08)
  BOTTOM w0.102: v2(62.87,99.26) 62.55,99.58 62.33,99.58 61.98,99.92 61.98,100.92 63.79,102.72 64.23,102.72 64.28,102.78 64.29,102.78
  BOTTOM w0.127: 64.29,102.78 70.4,102.78 76.34,108.72 83.7,108.72 88.64,113.66 88.64,183.64 97.87,192.87 110.14,192.87 113.65,196.37 113.65,198.76 113.3,199.11 113.3,199.74 v2(112.96,200.08)
USB3_TX_P0_C: length 5.5
  TOP w0.127: C501.2 113.61,207.3 113.61,207.64 115.88,209.91 115.88,210.19 115.63,210.45 RN40.5
USB3_TX_P0_R: length 30.7
  TOP w0.127: RN40.6 115.63,213.55 115.88,213.8 115.88,214.03 115.82,214.09 115.82,214.41 115.72,214.51 D16.9 D16.2 115.72,216.26 115.82,216.35 115.82,218.99 118.22,221.39 118.22,222.82 119.59,224.19 119.59,225.91 118.76,226.74 118.76,229.14 118.46,229.44 118.46,230.83 119.16,231.53 119.16,233.56 117.91,234.8 116.95,234.8 116.34,234.2 116.34,233.33 116.85,232.82 116.85,231.86 117.08,231.63 117.55,231.63 USB3_LAN.9
USB3_TX_P1: length 146.4
  TOP w0.102: PCH1.B16 56.24,99.29 56.76,98.76 57.34,98.76 57.75,99.16 60.68,99.16 61.07,99.55 61.07,99.73 v2(61.34,99.99)
  TOP w0.127: C504.1 111.78,202.87 111.78,202.25 v1(112.22,201.81) 111.78,201.37 111.78,199.07 v2(112.05,198.8)
  BOTTOM w0.102: 64.29,103.49 64.27,103.49 64.22,103.54 63.79,103.54 60.99,100.74 60.99,100.34 v2(61.34,99.99)
  BOTTOM w0.127: v2(112.05,198.8) 111.75,198.51 111.75,195.83 109.46,193.53 97.64,193.53 88,183.89 88,113.94 83.41,109.35 76.08,109.35 70.21,103.49 64.29,103.49
USB3_TX_P1_C: length 8.4
  TOP w0.127: CMK31.1 114.76,210.54 114.48,210.27 114.48,209.86 111.91,207.28 111.91,205.07 111.74,204.91 111.74,204.65 C504.2
USB3_TX_P1_R: length 17.6
  TOP w0.127: USB3_LAN.18 117.85,228.8 117.1,228.05 117.1,223.86 115.98,222.74 115.98,220.63 114.62,219.27 114.62,216.35 114.72,216.26 D16.4 D16.7 114.72,214.51 114.62,214.41 114.62,213.9 114.48,213.76 114.48,213.62 114.76,213.35 CMK31.2
USB3_TX_P4: length 85.2
  TOP w0.102: PCH1.C15 55.75,99.82 55.91,99.89 56.25,100.02 56.43,100.09 56.65,100.09 56.71,100.03 57.44,100.03 57.59,100.18 58.99,100.18 59.38,100.57 61.12,100.57 61.55,101 64.12,101 64.17,100.95
  TOP w0.127: v2(60.1,72.45) 60.1,72.88 60.56,73.34 61.3,73.34 61.58,73.06 64.2,73.06 69.76,78.61 69.76,81.57 72.3,84.11 72.3,85.48 70.54,87.23 70.54,90.13 66.58,94.09 66.58,96.5 65.62,97.47 65.62,100.26 64.93,100.95 64.17,100.95 ; v2(35.05,54.13) 34.71,53.79 34.39,53.79 34.04,54.14 C365.1
  BOTTOM w0.127: v2(60.1,72.45) 60.59,72.45 60.74,72.3 60.74,71.99 59.7,70.95 57.35,70.95 57.02,70.63 54.38,70.63 50.01,66.25 47.97,66.25 40.63,58.91 39.91,58.91 39.76,58.76 v1(39.25,58.76) 39.25,58.25 37.78,56.78 37.78,56.23 35.5,53.96 35.23,53.96 v2(35.05,54.13)
USB3_TX_P4_C: length 3.1
  TOP w0.127: C365.2 32.67,53.84 32.46,53.84 31.83,54.46 31.45,54.46 31.17,54.74 RN25.3
USB3_TX_P4_R: length 13.2
  TOP w0.127: CMK21.2 28.32,54.69 28.05,54.41 27.59,54.41 27.45,54.55 26.96,54.55 26.86,54.65 D2.2 D2.9 25.16,54.65 25.08,54.57 24.47,54.57 20.63,50.73 18.73,50.73 17.96,51.5 USB3F1.6
USB3_TX_P5: length 87.7
  TOP w0.102: 64.17,101.89 64.15,101.89 64.1,101.94 61.42,101.94 60.61,101.12 59.2,101.12 58.74,100.66 57.11,100.66 PCH1.A14
  TOP w0.127: 64.17,101.89 65.34,101.89 66.56,100.67 66.56,98.05 67.6,97.01 67.6,94.4 71.48,90.52 71.48,87.69 73.24,85.94 73.24,83.65 70.77,81.19 70.77,78.29 64.03,71.55 60.04,71.55 58.88,72.7 58.88,73.06 58.57,73.37 57.44,73.37 57.18,73.11 57.18,72.75 v2(57.31,72.63) ; v2(35.3,56.42) 35.04,56.15 34.43,56.15 C367.1
  BOTTOM w0.127: v2(57.31,72.63) 57.59,72.63 57.82,72.4 57.82,72.24 57.46,71.89 54.32,71.89 49.69,67.27 47.25,67.27 42.63,62.64 v1(42.15,62.64) 42.15,62.16 41.82,61.83 40.37,61.83 36.68,58.15 36.68,56.75 36.02,56.09 35.44,56.09 35.3,56.23 v2(35.3,56.42)
USB3_TX_P5_C: length 2.8
  TOP w0.127: C367.2 32.68,56.14 31.55,56.14 31.33,56.37 RN25.7
USB3_TX_P5_R: length 10.9
  TOP w0.127: RN25.8 28.23,56.37 27.97,56.12 27.34,56.12 27.28,56.05 26.96,56.05 26.86,56.15 D2.5 D2.6 25.02,56.15 24.94,56.06 24.44,56.06 21.11,52.73 20.8,52.73 USB3F1.14
USB+3: length 15.3
  TOP w0.127: CMK37.3 11.18,130.34 10.83,130.69 10.5,130.69 10.19,130.39 9.42,130.39 8.86,130.94 8.86,131.37 U26.6 8.86,131.62 8.86,132.31 8.3,132.86 8.3,137.03 7.63,137.7 6.23,137.7 5.24,138.69 4.86,138.69 4.48,138.31 F_USB3.3
USB+6: length 18.5
  TOP w0.127: F_USB1.6 7.27,115.32 7.53,115.58 8.82,115.58 9.1,115.86 9.1,119.59 10.09,120.58 12.86,120.58 13.19,120.25 13.19,119.74 12.99,119.54 12.99,117.84 13.57,117.25 13.57,116.4 U14.6 13.57,116.12 13.57,115.55 13.15,115.13 13.15,114.71 12.88,114.45 RN19.6
USB+7: length 21.8
  TOP w0.127: F_USB1.5 4.6,114.33 4.6,115.3 4.78,115.48 5.57,115.48 5.85,115.2 5.85,113.46 6.54,112.77 8.67,112.77 10.24,114.35 10.24,119.54 10.42,119.72 10.85,119.72 11.03,119.54 11.03,117.75 11.67,117.12 11.67,116.39 U14.4 11.67,116.12 11.67,115.48 11.46,115.27 11.46,114.71 11.26,114.51 RN19.2
USB+8: length 11.9
  TOP w0.127: CMK17.3 133.47,214.36 133.74,214.64 133.74,214.94 133.97,215.17 133.97,215.82 U17.4 133.97,216.09 133.97,216.7 133.33,217.33 133.33,219.41 132.95,219.8 132.95,224.06 132.72,224.29 USB2X4.A3
USB+9: length 16.1
  TOP w0.127: USB2X4.B3 132.76,226.91 132.95,226.73 132.95,226.05 133.53,225.46 134.7,225.46 134.98,225.18 134.98,220.76 135.29,220.45 135.29,217.2 135.87,216.62 135.87,216.09 U17.6 135.87,215.81 135.87,215.25 135.44,214.81 135.44,214.54 135.19,214.28 RN21.6
USB+10: length 19.7
  TOP w0.127: USB2X4.C3 132.69,229.53 132.94,229.28 132.94,228.39 132.63,228.08 130.92,228.08 130.59,227.74 130.59,222.21 129.32,220.94 129.32,217.53 129.9,216.95 129.9,216.09 U18.3 129.9,215.81 129.9,215.17 129.47,214.74 129.47,214.41 129.22,214.15 RN22.6
USB+11: length 24.1
  TOP w0.127: CMK20.3 127.5,214.34 127.77,214.61 127.77,214.94 128,215.17 128,215.82 U18.1 128,216.09 128,216.82 127.41,217.41 127.41,221.06 128.28,221.93 128.28,230.26 129.01,230.99 132.7,230.99 132.92,231.22 132.92,231.93 132.71,232.15 USB2X4.D3
USB+12: length 10.5
  TOP w0.127: RN20.6 10.68,96.72 10.45,96.49 10.43,96.49 9.56,95.61 9.56,95.07 U15.3 9.61,94.74 9.61,94.14 10.19,93.55 10.19,91.6 9.63,91.04 8.8,91.04 8.14,91.7 7.53,91.7 7.27,91.45 F_USB2.6
USB+13: length 17.3
  TOP w0.127: F_USB2.5 4.73,91.45 5.01,91.73 5.7,91.73 5.85,91.57 5.85,90.05 6.51,89.39 8.19,89.39 8.74,89.95 10.8,89.95 12.15,91.3 12.15,93.45 11.51,94.09 11.51,94.74 U15.1 11.51,95.02 11.51,95.51 11.61,95.61 11.61,96.07 12.17,96.63 12.17,97 RN20.2
USB-3: length 15.3
  TOP w0.127: F_USB3.2 4.48,139.38 4.86,139 5.37,139 6.36,138.01 7.75,138.01 8.6,137.16 8.6,134.12 U26.1 8.6,133.87 8.6,132.99 9.16,132.43 9.16,131.07 9.54,130.69 10.07,130.69 10.37,130.99 10.83,130.99 11.18,131.35 CMK37.2
USB-6: length 18.5
  TOP w0.127: RN19.8 13.7,114.51 13.46,114.75 13.46,115.01 13.88,115.43 13.88,117.38 13.29,117.96 13.29,118.62 U14.1 13.29,118.89 13.29,119.41 13.49,119.62 13.49,120.38 12.99,120.89 9.96,120.89 8.8,119.72 8.8,115.98 8.69,115.88 7.53,115.88 7.27,116.14 F_USB1.4
USB-7: length 21.9
  TOP w0.127: RN19.4 12.07,114.48 11.77,114.79 11.77,115.15 11.97,115.35 11.97,117.24 11.34,117.88 11.34,118.56 U14.3 11.34,118.95 11.34,119.67 10.98,120.02 10.29,120.02 9.94,119.67 9.94,114.47 8.54,113.08 6.66,113.08 6.15,113.58 6.15,115.32 5.7,115.78 4.99,115.78 4.73,116.03 F_USB1.3
USB-8: length 11.9
  TOP w0.127: CMK17.2 134.32,214.36 134.04,214.64 134.04,214.81 134.27,215.04 134.27,216.82 133.64,217.46 133.64,218.26 U17.3 133.64,218.65 133.64,219.54 133.25,219.92 133.25,224.06 133.48,224.29 USB2X4.A2
USB-9: length 16
  TOP w0.127: RN21.8 136,214.28 135.74,214.54 135.74,214.69 136.18,215.12 136.18,216.75 135.59,217.33 135.59,218.32 U17.1 135.59,218.59 135.59,220.58 135.29,220.89 135.29,225.31 134.83,225.76 133.66,225.76 133.25,226.17 133.25,226.62 133.54,226.91 USB2X4.B2
USB-10: length 19.6
  TOP w0.127: USB2X4.C2 133.57,229.53 133.24,229.2 133.24,228.26 132.75,227.77 131.05,227.77 130.89,227.62 130.89,222.08 129.62,220.81 129.62,218.59 U18.4 129.62,218.32 129.62,217.66 130.21,217.08 130.21,215.04 129.78,214.61 129.78,214.41 130.03,214.15 RN22.8
USB-11: length 24.2
  TOP w0.127: CMK20.2 128.35,214.34 128.07,214.61 128.07,214.81 128.3,215.04 128.3,216.95 127.72,217.53 127.72,218.31 U18.6 127.72,218.59 127.72,220.94 128.58,221.8 128.58,230.13 129.14,230.69 132.82,230.69 133.23,231.09 133.23,231.92 133.46,232.15 USB2X4.D2
USB-12: length 10.6
  TOP w0.127: F_USB2.4 7.07,93.17 7.07,92.18 7.25,92.01 8.26,92.01 8.92,91.35 9.51,91.35 9.89,91.73 9.89,92.24 U15.4 9.89,92.52 9.89,93.43 9.3,94.01 9.3,95.79 9.9,96.39 9.9,96.96 9.86,97 RN20.8
USB-13: length 17.2
  TOP w0.127: F_USB2.3 4.73,92.16 4.86,92.03 5.82,92.03 6.15,91.7 6.15,90.18 6.64,89.69 8.06,89.69 8.62,90.25 10.68,90.25 11.84,91.42 11.84,92.19 U15.6 11.84,92.57 11.84,93.33 11.21,93.96 11.21,95.63 11.31,95.74 11.31,96.2 11.54,96.43 11.54,96.98 11.55,96.97 CMK15.2
USB_EN: length 36.1
  TOP w0.102: R295.1 R359.1 15.4,126.24 15.4,125 14.55,124.15 14.55,122.96 14.24,122.65 13.02,122.65 12.4,122.03 9,122.03 8.41,121.44 v2(7.91,121.44) ; RJ3.2 RJ4.2 15.4,107.6 15.4,108.36 15.28,108.48 13.06,108.48 12.95,108.59 11.46,108.59 11.05,109 R294.2 11.05,109.41 10.04,110.42 v2(7.78,110.42)
  BOTTOM w0.102: v2(7.78,110.42) 7.8,110.42 8.36,110.98 8.36,120.99 v2(7.91,121.44)
USB_EN1: length 133
  TOP w0.102: U25.4 13.75,133.94 v2(13.75,132.37) ; v2(8.03,124.87) 8.29,125.13 8.29,125.76 9.63,127.11 11.44,127.11 11.72,127.39 13.3,127.39 R359.2 C405.1 12.73,125.76 U13.4 12.56,124.97 v2(13.34,124.19) ; U12.4 12.6,108.36 8.87,108.36 8.29,107.78 v2(5.8,107.78) ; v2(2.95,35.47) 3.16,35.26 5.32,35.26 5.67,34.91 7.75,34.91 8.31,35.47 U19.2
  BOTTOM w0.102: v2(13.75,132.37) 13.62,132.24 13.62,124.47 v2(13.34,124.19) ; v2(8.03,124.87) 5.8,122.64 v2(5.8,107.78) 6.38,107.2 v1(6.38,106.33) 6.38,99.98 5.77,99.37 5.77,86.38 3.28,83.89 3.28,74.92 4.26,73.95 4.94,73.95 7.12,71.77 7.12,63.13 7.35,62.9 7.35,60.2 2.24,55.09 2.24,36.18 2.95,35.47 v2(2.95,35.47)
USB_EN2: length 259.6
  TOP w0.102: v2(75.7,125) 74.21,125 67.02,132.19 59.4,132.19 58.74,132.85 50.42,132.85 46.87,136.4 46.85,136.42 46.85,137.47 45.72,138.61 45.54,138.61 43.85,140.3 43.85,141.13 43.59,141.38 43.59,143.36 42.64,144.3 42.45,144.3 41.49,145.27 41.49,151.81 40.23,153.07 39.15,153.07 37.88,154.34 35.2,154.34 34.18,155.35 27.34,155.35 26.71,154.72 23.28,154.72 22.28,153.73 18.84,153.73 17.88,152.76 17.07,152.76 15.69,151.38 15.69,150.5 11.27,146.08 v2(8.95,146.08) ; 123.17,202.95 123.12,202.9 119.34,202.9 108.69,192.26 108.69,188.45 103.41,183.17 v2(103.41,182.02) ; 123.17,202.95 123.22,202.9 126.07,202.9 127.34,204.17 129.39,204.17 129.7,203.87 139.99,203.87 143.5,207.38 U16.4 ; 123.17,202.95 123.17,203.99 122.59,204.58 120.86,204.58 120.65,204.79 120.65,205.24 120.65,207.08 120.43,207.3 U29.2 ; v2(10.27,129.67) 13.3,129.67 C355.1 R295.2 ; v2(98.97,148.5) 98.71,148.75 98.71,150.02 98.97,150.27 98.97,180.37 v2(99.35,180.75) ; v2(75.7,126.96) 77.78,129.04 77.78,148.01 78.14,148.37 79.09,148.37 80.08,149.36 83.24,149.36 84.28,148.32 85.83,148.32 86.43,148.93 89.35,148.93 89.52,148.75 90.08,148.75 v2(90.33,148.5)
  BOTTOM w0.102: v2(10.27,129.67) 10.68,130.08 10.68,138.61 9.25,140.04 9.25,145.63 8.95,145.93 v2(8.95,146.08) ; v2(75.7,126.96) 75.67,126.93 75.67,125.03 v2(75.7,125) ; v2(99.35,180.75) 100.62,182.02 v1(101.12,182.02) 101.12,182.02 v2(103.41,182.02) ; v2(98.97,148.5) 98.58,148.11 91.09,148.11 90.71,148.5 v2(90.33,148.5)
USB_N0: length 187.7
  TOP w0.102: PCH1.AV10 37.22,102.54 37.29,102.47 37.29,102.37 37.09,102.17 36.86,102.17 36.4,102.63 35.79,102.63 35.49,102.93 34.63,102.93 33.97,103.59 32.59,103.59 31.52,104.66 31.5,104.66
  TOP w0.127: RN38.7 93.71,211.92 93.43,212.2 93.1,212.2 92.36,211.46 92.36,211.06 92.56,210.85 92.8,210.85 v2(92.89,210.95) ; 31.5,104.66 30.97,105.19 30.51,105.19 30.39,105.06 30.39,104.76 30.53,104.61 v2(30.75,104.61)
  BOTTOM w0.127: v2(30.75,104.61) 30.75,104.74 30.28,105.21 30.28,105.42 29.66,106.04 26.16,106.04 25.31,106.89 25.31,113.44 25.99,114.13 25.99,199.85 31.17,205.04 32.19,205.04 32.62,205.47 v1(33.13,205.47) 33.13,205.98 34.6,207.45 35.92,207.45 37.35,208.87 44.89,208.87 47.92,205.84 54.06,205.84 54.78,206.55 64.65,206.55 66.48,208.38 91.5,208.38 92.67,209.54 92.67,210.72 v2(92.89,210.95)
USB_N0_R: length 45.2
  TOP w0.127: v2(103.99,233.5) 104.21,233.28 104.71,233.28 105.44,232.54 105.44,228.89 107.27,227.06 107.27,222.28 103.33,218.35 103.33,212.76 102.32,211.74 99.98,211.74 99.4,212.33 98.74,212.33 U28.3 98.47,212.33 97.52,212.33 97.21,212.02 96.63,212.02 96.43,211.82 CMK28.2
  BOTTOM w0.127: v2(103.99,233.5) 104.29,233.2 108.11,233.2 109.89,234.98 113.72,234.98 114.1,234.6 114.1,233.94 114.55,233.5 USB3_LAN.2
USB_N1: length 192.6
  TOP w0.102: PCH1.AV11 37.23,101.88 36.85,101.88 36.43,102.29 35.63,102.29 35.3,102.62 34.47,102.62 33.99,103.11 30.97,103.11 30.66,103.41 v2(30.66,103.76)
  TOP w0.127: RN38.1 93.61,214.36 93.4,214.15 92.72,214.15 92.31,213.75 92.31,213.14 90.2,211.03 90.2,210.81 v2(89.99,210.6)
  BOTTOM w0.127: v2(89.99,210.6) 90.18,210.41 90.18,209.63 89.96,209.42 66.05,209.42 64.22,207.59 54.34,207.59 53.63,206.88 48.56,206.88 45.46,209.98 36.9,209.98 35.72,208.8 32.57,208.8 30.26,206.48 28.33,206.48 27.01,205.16 v1(26.5,205.16) 26.5,204.65 26.17,204.32 26.17,201.53 24.95,200.31 24.95,114.66 23.88,113.6 23.88,105.06 26.27,102.67 29.93,102.67 30.39,103.13 30.39,103.48 v2(30.66,103.76)
USB_N1_R: length 36.3
  TOP w0.127: RN38.2 96.48,214.36 96.88,213.95 98.47,213.95 U28.1 98.74,213.95 99.41,213.95 100.05,214.59 101.89,214.59 102.22,214.92 102.22,219.11 106.15,223.04 106.15,226.35 105.25,227.25 105.14,227.36 104.62,227.36 104.5,227.25 104.5,226.98 104.67,226.82 v2(104.81,226.82)
  BOTTOM w0.127: v2(104.81,226.82) 104.68,226.94 104.68,227.24 104.81,227.36 114.21,227.36 115.09,228.25 115.09,229.32 114.89,229.52 114.89,230.27 USB3_LAN.11
USB_N2: length 175.2
  TOP w0.102: PCH1.AN14 39.72,101.02 v3(40.01,101.31)
  TOP w0.127: v2(57.67,201.71) 57.37,201.71 57.18,201.9 57.18,202.88 49.04,211.03 40.24,211.03 38.6,212.67 38.6,216.99 41.42,219.81 41.42,228.87 42.01,229.46 42.73,229.46 42.86,229.32 R950.2
  BOTTOM w0.102: v3(40.01,101.31) 39.78,101.53 39.78,101.76 39.53,102.01 38.14,102.01 37.19,102.96 37.19,103.72 35.97,104.93 35.97,105.52 34.85,106.65 34.85,106.72 34.83,106.74
  BOTTOM w0.127: 34.83,106.74 32.57,108.99 32.57,111.92 29.85,114.64 29.85,116.09 31.02,117.25 31.02,118.68 29.67,120.02 29.67,191.22 31.4,192.95 32.47,192.95 33.61,194.09 33.61,195.49 35.64,197.52 38.01,197.52 39.2,198.71 40.52,198.71 41.87,200.06 42.88,200.06 44.15,198.79 50.81,198.79 v1(51.14,198.46) 51.47,198.79 55.15,198.79 57.25,200.88 57.25,201.52 57.44,201.71 v2(57.67,201.71)
USB_N3: length 64.7
  TOP w0.102: v3(42.29,100.06) 41.85,99.62 PCH1.AJ16
  TOP w0.127: v2(16.03,113.8) 15.88,113.95 15.88,115.88 15.27,116.49 15.27,123.81 16.21,124.75 16.21,130.41 15.63,130.99 14.79,130.99 14.44,131.35 CMK37.1
  BOTTOM w0.102: 30.73,102.23 30.75,102.25 30.75,102.32 30.89,102.46 32.57,102.46 33.48,101.55 33.48,100.83 33,100.35 33,99.67 33.4,99.27 33.92,99.27 v1(34.27,98.91) 34.63,99.27 35.02,99.27 35.17,99.42 36.09,99.42 37.01,98.51 38,98.51 38.78,97.72 39.82,97.72 40.3,98.2 41.82,98.2 42.25,98.63 42.25,99.27 42.09,99.43 42.09,99.86 v3(42.29,100.06)
  BOTTOM w0.127: v2(16.03,113.8) 15.86,113.8 15.65,114 15.65,114.79 15.87,115.01 16.33,115.01 16.87,114.46 16.87,112.61 17.74,111.74 20.42,111.74 22.94,109.21 22.94,104.93 25.94,101.94 30.44,101.94 30.73,102.23
USB_N4: length 71.4
  TOP w0.102: PCH1.AU15 37.03,99.76 36.97,99.73 36.89,99.7 36.79,99.7 36.7,99.74 36.65,99.77 36.65,99.78 36.59,99.83 36.41,99.88 35.67,99.88 35.62,99.93 35.14,99.93 34.63,100.44 33.16,100.44 32.96,100.24 30.36,100.24 30.31,100.18 30.28,100.18
  TOP w0.127: RN23.1 31.22,57.87 31.35,58 31.78,58 v2(32.1,57.68) ; 30.28,100.18 30.01,100.18 29.07,101.12 26.23,101.12 21.17,96.06 21.17,93.12 21.79,92.5 21.79,90.93 v2(21.98,90.74)
  BOTTOM w0.127: v2(21.98,90.74) 21.72,90.48 21.72,87.1 v1(22.08,86.75) 21.72,86.39 21.72,83.52 20.63,82.43 20.63,73.06 20.38,72.8 20.38,67.9 28.12,60.15 29.37,60.15 30.61,61.4 32.65,61.4 33.56,60.48 33.56,58.86 32.56,57.86 32.27,57.86 v2(32.1,57.68)
USB_N4_R: length 12.2
  TOP w0.127: USB3F1.8 17.96,55.67 18.71,56.43 22.19,56.43 23.2,57.44 25.23,57.44 25.81,58.02 26.42,58.02 U20.1 26.69,58.02 27.95,58.02 28.1,57.87 RN23.2
USB_N5: length 69
  TOP w0.102: PCH1.AU12 37.48,101.2 37.08,101.2 36.96,101.13 36.69,101.13 36.64,101.18 35.64,101.18 35.06,101.76 33.8,101.76 33.44,102.12 30.33,102.12 30.28,102.17 30.26,102.17
  TOP w0.127: RN23.5 31.05,59.49 31.41,59.86 31.66,59.86 v2(31.97,59.56) ; 30.26,102.17 25.78,102.17 20.07,96.46 20.07,91.73 19.65,91.31 19.65,90.8 19.59,90.74 v2(19.23,90.74)
  BOTTOM w0.127: v2(19.23,90.74) 19.46,90.51 19.46,87.64 19.03,87.21 19.03,82.38 19.55,81.86 19.55,73.71 19.31,73.46 19.31,67.47 27.95,58.83 30.13,58.83 31.03,59.74 31.79,59.74 v2(31.97,59.56)
USB_N5_R: length 10.3
  TOP w0.127: USB3F1.12 19.96,57.67 20.81,58.53 21.19,58.53 22,59.34 24.8,59.34 25.38,59.93 26.41,59.93 U20.3 26.7,59.93 27.39,59.93 27.68,59.63 28.19,59.63 28.33,59.49 RN23.6
USB_N6: length 33.8
  TOP w0.102: v2(32.37,101.02) 32.61,101.26 33.21,101.26 33.5,100.97 34.83,100.97 35.36,100.44 35.83,100.44 35.87,100.4 36.31,100.4 36.46,100.4 PCH1.AV14
  TOP w0.127: v2(17.03,110.62) 17.08,110.58 17.08,110.27 16.9,110.09 14.26,110.09 13.42,110.93 13.42,111.51 13.79,111.89 CMK14.1
  BOTTOM w0.102: 31.35,101.96 31.36,101.96 31.41,101.91 31.73,101.91 32.06,101.58 32.06,101.33 v2(32.37,101.02)
  BOTTOM w0.127: v2(17.03,110.62) 17.44,110.22 20.85,110.22 21.8,109.27 21.8,106.97 v1(22.16,106.61) 21.8,106.26 21.8,105.37 25.71,101.45 30.59,101.45 31.1,101.96 31.35,101.96
USB_N7: length 38.9
  TOP w0.102: v3(33.26,98.15) 33.66,98.56 34.09,98.56 34.34,98.81 35.12,98.81 35.43,98.5 35.86,98.5 36.02,98.66 36.63,98.66 36.63,98.66 36.65,98.66 36.71,98.6 36.96,98.6 37.08,98.67 37.23,98.67 37.25,98.69 37.5,98.69 PCH1.AU17
  TOP w0.127: v2(18.14,108.31) 18.17,108.29 18.17,107.93 18.07,107.83 17.74,107.83 16.31,109.25 13.37,109.25 11.77,110.85 11.77,111.49 12.07,111.79 RN19.3
  BOTTOM w0.102: 30.51,99.27 30.55,99.27 31.09,98.74 33.4,98.74 33.51,98.63 33.51,98.28 33.38,98.15 v3(33.26,98.15)
  BOTTOM w0.127: v2(18.14,108.31) 17.91,108.08 17.28,108.08 16.72,107.53 16.72,105.77 17.2,105.29 19.31,105.29 v1(19.62,104.99) 19.92,105.29 20.15,105.29 25.03,100.41 29.34,100.41 30.48,99.27 30.51,99.27
USB_N8: length 236.9
  TOP w0.102: v3(33.69,99.91) 34.09,99.5 34.67,99.5 34.75,99.42 36.23,99.42 PCH1.AW16
  TOP w0.127: v2(130.92,219.36) 131.1,219.18 131.1,218.49 132.44,217.14 132.44,211.28 132.87,210.85 133.76,210.85 134.04,211.13 134.04,211.34 134.32,211.61 CMK17.1
  BOTTOM w0.102: v3(33.69,99.91) 33.9,99.91 34.06,100.06 34.06,101.87 32.52,103.4 32.52,103.97 32.29,104.19 32.22,104.19 32.2,104.21
  BOTTOM w0.127: 32.2,104.21 29.83,106.59 27.03,106.59 25.94,107.68 25.94,113.37 26.42,113.85 26.42,199.45 31.43,204.45 33.64,204.45 37.6,208.41 44.61,208.41 47.62,205.4 54.24,205.4 54.95,206.12 64.83,206.12 66.66,207.94 91.74,207.94 94.85,211.06 103.77,211.06 104.74,210.08 106.61,210.08 108.91,212.38 111.23,212.38 116.24,217.38 120.68,217.38 121.95,218.65 129.37,218.65 v1(129.83,219.11) 130.28,218.65 131.07,218.65 131.27,218.85 131.27,219.01 v2(130.92,219.36)
USB_N9: length 229.9
  TOP w0.102: v3(40.01,99.98) 39.72,99.68 PCH1.AN16
  TOP w0.127: v2(131.1,215.89) 131.31,216.11 131.6,216.11 131.71,216.01 131.71,210.69 132.48,209.91 134.78,209.91 135.74,210.88 135.74,211.49 136,211.74 RN21.7
  BOTTOM w0.102: 34.13,106.14 34.15,106.12 34.15,106.05 34.74,105.46 34.74,103.91 35.64,103 36.24,103 37.99,101.25 38.42,101.25 38.85,100.82 39.49,100.82 39.73,100.58 39.73,100.25 v3(40.01,99.98)
  BOTTOM w0.127: 34.13,106.14 31.83,108.44 31.83,111.59 28.94,114.48 28.94,191.8 30.11,192.97 30.11,198.58 32.42,200.9 35.26,200.9 36.13,200.03 37.98,200.03 39.25,201.3 40.6,201.3 42.02,202.72 43.09,202.72 43.47,202.34 43.47,201.81 43.97,201.3 46.06,201.3 47.07,200.29 54.08,200.29 56.23,202.43 63.96,202.43 65.48,202.43 68.48,205.43 98.14,205.43 100.27,207.56 107.65,207.56 109.94,209.85 113.23,209.85 117.22,213.84 127.73,213.84 128.48,214.59 v1(128.96,214.59) 128.96,215.07 130.27,216.38 131.16,216.38 131.29,216.25 131.29,216.08 v2(131.1,215.89)
USB_N10: length 230.4
  TOP w0.102: v3(41.58,98.86) 41.85,98.59 PCH1.AJ18
  TOP w0.127: v2(124.09,215.12) 124.33,214.88 124.33,214.65 125.79,213.19 125.79,210.78 126.78,209.79 128.68,209.79 129.85,210.95 129.85,211.31 130.03,211.49 RN22.7
  BOTTOM w0.102: v3(41.58,98.86) 41.3,99.14 41.3,99.22 41.06,99.47 39.08,99.47 38.49,100.06 37.5,100.06 36.94,100.62 36.94,101.56 36.08,102.42 35.44,102.42 34.09,103.77 34.09,105.04 33.97,105.16
  BOTTOM w0.127: v2(124.09,215.12) 124.09,214.92 124.24,214.76 124.54,214.76 124.63,214.85 124.63,215.69 124.19,216.14 122.84,216.14 121.66,214.95 117.01,214.95 112.64,210.59 109.63,210.59 107.35,208.3 103.47,208.3 102.7,209.07 95.46,209.07 92.55,206.17 67.4,206.17 66.39,205.16 66.39,204.38 65.17,203.17 64.27,203.17 64.27,203.17 55.93,203.17 53.98,201.23 48.32,201.23 45.68,203.87 44.61,203.87 42.07,206.41 38.41,206.41 34.35,202.34 32.11,202.34 28.2,198.43 28.2,113.77 29.57,112.4 29.57,111.87 v1(29.93,111.51) 29.57,111.16 29.57,109.56 33.97,105.16
USB_N11: length 231.6
  TOP w0.102: PCH1.AP18 38.96,98.42 39.35,98.81 v3(39.35,98.84)
  TOP w0.127: v2(125.93,215.93) 125.98,215.93 126.15,215.77 126.15,214.66 126.54,214.26 126.54,211.17 127.03,210.67 127.9,210.67 128.23,211.01 128.23,211.44 128.4,211.61 RN22.3
  BOTTOM w0.102: 33.03,105.03 33.17,104.89 33.17,104.82 33.28,104.71 33.28,103.82 35.21,101.89 35.21,101.56 37.26,99.5 38.03,99.5 38.77,98.76 39.1,98.43 39.51,98.43 39.63,98.55 39.63,98.69 39.48,98.84 v3(39.35,98.84)
  BOTTOM w0.127: v2(125.93,215.93) 125.93,215.44 126.17,215.2 126.35,215.2 126.5,215.35 126.5,217.18 126.14,217.53 122.79,217.53 121.27,216.01 116.73,216.01 112.05,211.32 109.33,211.32 107.04,209.04 104.01,209.04 103.11,209.94 95.28,209.94 92.24,206.9 67.09,206.9 65.65,205.46 65.65,204.69 64.87,203.91 55.62,203.91 54.6,202.89 50.86,202.89 v1(50.53,202.56) 50.2,202.89 47.75,202.89 45.93,204.71 44.91,204.71 42.35,207.27 38.03,207.27 33.99,203.23 31.78,203.23 27.46,198.92 27.46,113.32 27.26,113.11 27.26,109.63 27.77,109.13 28.93,109.13 33.03,105.03
USB_N12: length 41.5
  TOP w0.102: v3(31.6,98.15) 32.01,98.56 32.46,98.56 32.7,98.32 32.7,97.96 32.83,97.83 33.04,97.62 34.88,97.62 35.25,97.99 36.22,97.99 36.33,98.09 PCH1.AW18
  TOP w0.127: RN20.7 9.86,99.14 10.14,99.42 10.14,100.36 12.07,102.29 13.89,102.29 v2(14.1,102.5)
  BOTTOM w0.127: v2(14.1,102.5) 13.9,102.5 13.72,102.32 13.72,102.12 13.9,101.94 14.46,101.94 14.64,102.12 17.2,102.12 v1(17.53,102.45) 17.86,102.12 20.66,102.12 21.24,101.53 21.24,100.52 20.76,100.03 17.76,100.03 17.43,99.7 17.43,99.07 17.72,98.78 29.47,98.78 29.94,98.31 31.45,98.31 v3(31.6,98.15)
USB_N13: length 36.1
  TOP w0.102: PCH1.AP20 39.01,97.22 v3(38.59,96.81)
  TOP w0.127: RN20.3 11.49,99.47 11.74,99.73 11.74,100.13 12.22,100.62 15.09,100.62 v2(15.27,100.79)
  BOTTOM w0.102: v3(38.59,96.81) 38.82,97.04 38.82,97.1 38.71,97.21 36.99,97.21 36.71,97.49 35.08,97.49 33.89,96.3 32.34,96.3 32.29,96.25
  BOTTOM w0.127: v2(15.27,100.79) 14.97,100.49 14.08,100.49 13.75,100.16 13.75,99.55 15.65,97.64 25.69,97.64 27.08,96.25 29.42,96.25 v1(29.75,95.92) 30.08,96.25 32.29,96.25
USB_OC0_L: length 6.7
  TOP w0.089: 43.87,86.21 43.85,86.19 43.85,85.83
  TOP w0.102: PCH1.AE40 43.94,86.82 43.94,86.28 43.87,86.21 ; 43.85,85.83 43.85,85.14 43.52,84.81 43.52,83.66 43.28,83.42 RN14.2
USB_OC2_L: length 7.2
  TOP w0.102: RN14.6 44.35,81.25 44.17,81.44 44.17,82.9 44.81,83.54 44.81,86.27 44.85,86.31 44.85,86.63 44.79,86.68 44.78,86.71 44.7,87 PCH1.AD39
USB_OC3_L: length 6.3
  TOP w0.102: RN14.4 43.85,82.97 44.6,83.72 44.6,86.24 44.54,86.3 PCH1.AD40
USB_OC4_L: length 7.7
  TOP w0.102: RN13.4 41.31,82.17 42.5,83.36 42.5,84.68 43.24,85.42 43.24,86.24 43.23,86.25 43.13,86.4 43.13,86.66 43.43,86.96 PCH1.AF39
USB_OC5_L: length 5.6
  TOP w0.102: PCH1.AC41 45.29,81.8 44.93,81.44 RN14.8
USB_OC6_L: length 6.6
  TOP w0.102: PCH1.AF40 43.43,86.31 43.44,86.3 43.44,85.32 42.73,84.61 42.73,83.3 41.81,82.38 RN13.6
USB_OC7_L: length 7.4
  TOP w0.089: 43.04,85.8 43.04,86.15 43.02,86.16 43.02,86.17
  TOP w0.102: RN13.2 40.74,81.88 42.3,83.45 42.3,84.79 43.04,85.53 43.04,85.8 ; PCH1.AG40 42.82,86.38 43.02,86.17
USB_P0: length 187.8
  TOP w0.102: PCH1.AU10 37.32,102.78 36.71,102.95 36.47,102.83 35.87,102.83 35.58,103.13 34.71,103.13 34.05,103.79 32.67,103.79 31.72,104.74 31.72,104.87
  TOP w0.127: v2(91.89,210.95) 92.06,211.11 92.06,211.59 92.97,212.5 93.5,212.5 93.73,212.73 RN38.5 ; 31.72,104.87 31.1,105.49 30.39,105.49 30.08,105.19 30.08,104.85 v2(29.84,104.61)
  BOTTOM w0.127: v2(91.89,210.95) 91.94,210.95 92.36,210.52 92.36,209.67 91.38,208.68 66.36,208.68 64.53,206.85 54.65,206.85 53.94,206.14 48.05,206.14 45.02,209.18 37.22,209.18 35.8,207.75 34.48,207.75 33.92,207.19 v1(33.43,207.19) 33.43,206.71 32.06,205.34 31.05,205.34 25.69,199.98 25.69,114.26 25,113.57 25,106.76 26.03,105.73 29.54,105.73 29.98,105.29 29.98,104.87 29.84,104.74 v2(29.84,104.61)
USB_P0_R: length 45.3
  TOP w0.127: v2(103.99,232.35) 103.83,232.35 103.69,232.49 103.69,232.82 103.84,232.98 104.58,232.98 105.14,232.42 105.14,228.76 106.97,226.93 106.97,222.41 103.03,218.47 103.03,212.88 102.19,212.05 101.25,212.05 U28.4 100.96,212.05 100.11,212.05 99.52,212.63 97.39,212.63 97.09,212.33 96.73,212.33 96.38,212.67 CMK28.3
  BOTTOM w0.127: v2(103.99,232.35) 103.99,232.76 104.13,232.9 108.24,232.9 110.01,234.68 113.59,234.68 113.8,234.47 113.8,233.75 113.55,233.5 USB3_LAN.3
USB_P1: length 192.5
  TOP w0.102: v2(29.65,103.74) 30.04,103.74 30.88,102.9 33.91,102.9 34.39,102.42 35.21,102.42 35.54,102.09 36.14,102.09 PCH1.AW11
  TOP w0.127: RN38.3 93.61,213.54 93.3,213.85 92.84,213.85 92.62,213.62 92.62,213.01 90.51,210.9 90.51,210.6 90.63,210.47 90.88,210.47 v2(91,210.6)
  BOTTOM w0.127: v2(91,210.6) 90.61,210.6 90.48,210.47 90.48,209.51 90.09,209.11 66.18,209.11 64.35,207.28 54.47,207.28 53.76,206.57 48.43,206.57 45.33,209.67 37.03,209.67 35.85,208.49 32.7,208.49 30.39,206.18 28.45,206.18 26.47,204.2 26.47,203.79 v1(26.83,203.44) 26.47,203.08 26.47,201.4 25.25,200.18 25.25,114.54 24.19,113.47 24.19,105.19 26.4,102.98 29.8,102.98 30.16,103.33 30.16,103.84 30,103.99 29.91,103.99 v2(29.65,103.74)
USB_P1_R: length 36.4
  TOP w0.127: RN38.4 96.43,213.54 96.53,213.65 99.54,213.65 100.17,214.28 100.91,214.28 U28.6 101.3,214.28 102.01,214.28 102.52,214.79 102.52,218.98 106.46,222.92 106.46,226.47 105.26,227.67 104.97,227.67 v2(104.81,227.83)
  BOTTOM w0.127: USB3_LAN.12 113.68,230.3 114.79,229.19 114.79,228.38 114.08,227.67 104.97,227.67 v2(104.81,227.83)
USB_P2: length 175.3
  TOP w0.102: v3(39.25,101.31) 39.28,101.28 39.28,100.88 PCH1.AP14
  TOP w0.127: R951.2 42.47,229.76 41.88,229.76 41.12,229 41.12,219.93 38.3,217.11 38.3,212.54 40.11,210.73 48.91,210.73 56.88,202.76 56.88,201.91 v2(56.67,201.71)
  BOTTOM w0.102: 34.61,106.52 34.63,106.5 34.7,106.5 35.77,105.43 35.77,104.85 36.99,103.63 36.99,102.88 38.06,101.81 39.45,101.81 39.58,101.68 39.58,101.49 39.4,101.31 v3(39.25,101.31)
  BOTTOM w0.127: v2(56.67,201.71) 56.94,201.44 56.94,201.01 55.02,199.09 50.02,199.09 v1(49.66,199.45) 49.31,199.09 44.28,199.09 43.01,200.36 41.74,200.36 40.39,199.02 39.07,199.02 37.88,197.82 35.52,197.82 33.31,195.61 33.31,194.22 32.34,193.25 31.28,193.25 29.37,191.34 29.37,119.9 30.72,118.55 30.72,117.38 29.55,116.21 29.55,114.51 32.27,111.79 32.27,108.87 34.61,106.52
USB_P3: length 64.6
  TOP w0.102: PCH1.AK16 41.53,99.8 v3(41.53,100.08)
  TOP w0.127: CMK37.4 14.44,130.34 14.79,130.69 15.5,130.69 15.91,130.28 15.91,124.87 14.97,123.93 14.97,116.37 15.58,115.76 15.58,113.98 15.42,113.82 v2(15.15,113.82)
  BOTTOM w0.102: 30.51,102.45 30.53,102.46 30.6,102.46 30.8,102.66 32.66,102.66 33.69,101.63 33.69,100.74 33.2,100.26 33.2,99.75 33.48,99.47 34.93,99.47 35.08,99.63 35.36,99.63 v1(35.69,99.96) 36.02,99.63 36.18,99.63 37.09,98.71 38.08,98.71 38.87,97.92 39.73,97.92 40.22,98.41 41.74,98.41 42.04,98.71 42.04,99.19 41.89,99.34 41.89,99.99 41.8,100.08 v3(41.53,100.08)
  BOTTOM w0.127: 30.51,102.45 30.31,102.24 26.07,102.24 23.25,105.06 23.25,109.34 20.54,112.05 17.86,112.05 17.18,112.73 17.18,114.59 16.45,115.31 15.74,115.31 15.35,114.92 15.35,114.03 v2(15.15,113.82)
USB_P4: length 71.6
  TOP w0.102: PCH1.AV15 36.83,99.99 36.71,99.99 36.7,100.01 36.44,100.08 35.76,100.08 35.71,100.13 35.22,100.13 34.71,100.64 33.08,100.64 32.87,100.44 30.44,100.44 30.41,100.48 30.32,100.48 30.31,100.49 30.28,100.49
  TOP w0.127: v2(32.1,58.57) 31.83,58.3 31.53,58.3 31.15,58.68 RN23.3 ; 30.28,100.49 30.13,100.49 29.19,101.43 26.11,101.43 20.86,96.18 20.86,93 21.48,92.37 21.48,90.75 21.39,90.66 21.14,90.66 v2(21.06,90.74)
  BOTTOM w0.127: v2(21.06,90.74) 21.32,90.74 21.42,90.63 21.42,88.58 v1(21.06,88.22) 21.42,87.87 21.42,83.65 20.33,82.56 20.33,73.18 20.07,72.93 20.07,67.77 28,59.85 29.5,59.85 30.74,61.09 32.52,61.09 33.26,60.36 33.26,58.99 32.43,58.16 32.18,58.16 32.04,58.3 32.04,58.51 v2(32.1,58.57)
USB_P4_R: length 12.2
  TOP w0.127: USB3F1.9 18.8,56.73 22.06,56.73 23.07,57.74 23.91,57.74 U20.6 24.2,57.74 25.1,57.74 25.69,58.33 27.87,58.33 28.23,58.68 RN23.4
USB_P5: length 68.8
  TOP w0.102: 30.26,101.86 30.28,101.86 30.33,101.91 33.36,101.91 33.71,101.56 34.97,101.56 35.55,100.98 36.55,100.98 36.61,100.93 37.02,100.93 37.14,101 37.62,101 37.64,101.02 37.88,101.14 PCH1.AT12
  TOP w0.127: 30.26,101.86 25.9,101.86 20.38,96.34 20.38,91.6 19.96,91.18 19.96,90.93 v2(20.15,90.74) ; RN23.7 31.07,60.31 31.21,60.17 31.69,60.17 v2(31.97,60.45)
  BOTTOM w0.127: v2(20.15,90.74) 20.1,90.74 19.77,90.41 19.77,87.51 19.34,87.08 19.34,82.51 19.86,81.99 19.86,73.58 19.62,73.34 19.62,67.6 28.07,59.14 30.01,59.14 30.91,60.04 31.95,60.04 32.06,60.15 32.06,60.35 v2(31.97,60.45)
USB_P5_R: length 10.2
  TOP w0.127: USB3F1.11 20.7,58.83 21.06,58.83 21.88,59.65 22.13,59.65 22.21,59.65 23.92,59.65 U20.4 24.19,59.65 24.67,59.65 25.25,60.23 27.51,60.23 27.81,59.94 28.06,59.94 28.43,60.31 RN23.8
USB_P6: length 33.8
  TOP w0.102: v2(31.5,101.05) 31.75,101.05 32.28,101.58 33.18,101.58 33.59,101.18 34.91,101.18 35.44,100.64 35.92,100.64 35.96,100.6 36.24,100.6 PCH1.AW14
  TOP w0.127: CMK14.4 12.94,111.76 13.11,111.59 13.11,110.8 14.13,109.79 16.85,109.79 v2(17.03,109.61)
  BOTTOM w0.102: 31.35,101.66 31.36,101.66 31.41,101.71 31.65,101.71 31.86,101.5 31.86,101.15 31.76,101.05 v2(31.5,101.05)
  BOTTOM w0.127: v2(17.03,109.61) 17.03,109.71 17.23,109.91 20.72,109.91 21.5,109.14 21.5,108.54 v1(21.14,108.19) 21.5,107.83 21.5,105.24 25.59,101.15 30.72,101.15 31.22,101.66 31.35,101.66
USB_P7: length 38.7
  TOP w0.102: PCH1.AT17 37.74,98.49 37.33,98.49 37.31,98.47 37.14,98.47 37.02,98.4 36.62,98.4 36.56,98.46 36.54,98.46 36.54,98.46 36.11,98.46 35.95,98.3 35.35,98.3 35.04,98.61 34.42,98.61 33.97,98.15 v3(33.92,98.15)
  TOP w0.127: v2(18.14,107.35) 17.96,107.53 17.61,107.53 16.19,108.95 13.24,108.95 11.46,110.73 11.46,111.54 11.26,111.74 RN19.1
  BOTTOM w0.102: 30.68,99.51 30.7,99.49 30.7,99.42 31.17,98.94 33.48,98.94 33.71,98.71 33.71,98.36 v3(33.92,98.15)
  BOTTOM w0.127: 30.68,99.51 29.47,100.72 25.15,100.72 20.28,105.59 18.47,105.59 v1(18.12,105.95) 17.76,105.59 17.33,105.59 17.03,105.9 17.03,107.4 17.41,107.78 18.09,107.78 18.22,107.65 18.22,107.42 v2(18.14,107.35)
USB_P8: length 236.9
  TOP w0.102: PCH1.AV16 36.74,99.47 36.61,99.53 36.47,99.63 34.83,99.63 v3(34.55,99.91)
  TOP w0.127: CMK17.4 133.47,211.79 133.74,211.51 133.74,211.26 133.64,211.16 133,211.16 132.75,211.41 132.75,217.27 131.4,218.61 131.4,219.49 131.6,219.69 131.83,219.69 132.09,219.44 v2(132.09,219.36)
  BOTTOM w0.102: v3(34.55,99.91) 34.5,99.91 34.26,100.15 34.26,101.95 32.72,103.49 32.72,104.05 32.44,104.34 32.44,104.41 32.42,104.43
  BOTTOM w0.127: v2(132.09,219.36) 131.71,219.36 131.58,219.23 131.58,218.73 131.2,218.35 128.68,218.35 v1(128.3,217.96) 127.92,218.35 122.08,218.35 120.81,217.08 116.36,217.08 111.36,212.07 109.04,212.07 106.74,209.77 104.62,209.77 103.64,210.75 94.98,210.75 91.87,207.64 66.79,207.64 64.96,205.81 55.08,205.81 54.37,205.1 47.49,205.1 44.48,208.11 37.73,208.11 33.76,204.15 31.55,204.15 26.73,199.32 26.73,113.72 26.25,113.24 26.25,107.8 27.16,106.89 29.95,106.89 32.42,104.43
USB_P9: length 229.9
  TOP w0.102: PCH1.AP16 39.25,99.64 v3(39.25,99.98)
  TOP w0.127: v2(131.1,216.91) 130.97,216.78 130.97,216.59 131.15,216.42 131.73,216.42 132.01,216.14 132.01,210.82 132.61,210.22 134.65,210.22 135.44,211 135.44,211.49 135.19,211.74 RN21.5
  BOTTOM w0.102: 33.91,105.92 33.93,105.91 34,105.91 34.54,105.37 34.54,103.82 35.56,102.8 36.15,102.8 37.9,101.05 38.34,101.05 38.77,100.62 39.4,100.62 39.53,100.49 39.53,100.25 v3(39.25,99.98)
  BOTTOM w0.127: v2(131.1,216.91) 130.87,216.68 130.14,216.68 129.75,216.29 v1(129.27,216.29) 129.27,215.81 127.6,214.14 117.09,214.14 113.11,210.15 109.81,210.15 107.53,207.87 100.15,207.87 98.01,205.73 68.35,205.73 65.35,202.74 65.31,202.74 56.1,202.74 53.96,200.59 47.2,200.59 46.18,201.61 44.1,201.61 43.77,201.94 43.77,202.47 43.21,203.03 41.89,203.03 40.47,201.61 39.12,201.61 37.85,200.34 36.25,200.34 35.39,201.2 32.29,201.2 29.8,198.71 29.8,193.1 28.63,191.93 28.63,114.36 31.53,111.46 31.53,108.31 33.91,105.92
USB_P10: length 230.4
  TOP w0.102: v3(40.82,98.84) 41.14,98.53 PCH1.AK18
  TOP w0.127: v2(125.18,215.1) 125.18,215.35 125.05,215.48 124.82,215.48 124.63,215.28 124.63,214.78 126.09,213.32 126.09,210.9 126.91,210.09 128.56,210.09 129.55,211.08 129.55,211.31 129.22,211.64 RN22.5
  BOTTOM w0.102: 33.74,104.96 33.89,104.81 33.89,103.69 35.36,102.22 35.99,102.22 36.74,101.47 36.74,100.53 37.41,99.85 38.4,99.85 39,99.26 40.97,99.26 41.04,99.2 41.04,99.06 v3(40.82,98.84)
  BOTTOM w0.127: v2(125.18,215.1) 124.94,215.34 124.94,215.82 124.31,216.44 122.71,216.44 121.53,215.26 116.88,215.26 112.51,210.89 109.51,210.89 107.22,208.6 103.6,208.6 102.83,209.38 95.33,209.38 92.42,206.47 67.27,206.47 66.09,205.28 66.09,204.51 65.05,203.47 64.4,203.47 55.8,203.47 53.86,201.53 48.44,201.53 45.8,204.17 44.74,204.17 42.2,206.71 38.29,206.71 34.22,202.65 31.99,202.65 27.9,198.56 27.9,113.65 29.27,112.28 29.27,110.34 v1(28.94,110.01) 29.27,109.68 29.27,109.43 33.74,104.96
USB_P11: length 231.4
  TOP w0.102: PCH1.AN18 39.72,98.55 v3(40.01,98.84)
  TOP w0.127: v2(127,215.93) 127,216.02 126.78,216.24 126.6,216.24 126.45,216.08 126.45,214.79 126.85,214.39 126.85,211.29 127.16,210.98 127.77,210.98 127.92,211.13 127.92,211.36 127.59,211.69 RN22.1
  BOTTOM w0.102: v3(40.01,98.84) 39.83,98.67 39.83,98.47 39.59,98.23 39.02,98.23 38.63,98.62 37.95,99.3 37.18,99.3 35.01,101.47 35.01,101.8 33.08,103.73 33.08,104.62 33.02,104.68 32.95,104.68 32.81,104.82
  BOTTOM w0.127: 32.81,104.82 28.81,108.82 27.64,108.82 26.96,109.51 26.96,113.24 27.16,113.44 27.16,199.04 31.66,203.54 33.87,203.54 37.9,207.58 42.48,207.58 45.04,205.01 46.06,205.01 47.87,203.19 52.1,203.19 v1(52.46,203.55) 52.81,203.19 54.48,203.19 55.49,204.21 64.74,204.21 65.35,204.82 65.35,205.59 66.97,207.21 92.11,207.21 95.15,210.24 103.23,210.24 104.13,209.34 106.92,209.34 109.2,211.63 111.92,211.63 116.61,216.31 121.14,216.31 122.66,217.84 126.27,217.84 126.81,217.3 126.81,216.12 v2(127,215.93)
USB_P12: length 41.4
  TOP w0.102: v3(32.29,98.15) 32.29,98.08 32.95,97.41 34.96,97.41 35.33,97.78 36.41,97.78 PCH1.AV18
  TOP w0.127: v2(14.1,101.43) 14.33,101.67 14.33,101.84 14.18,101.99 12.2,101.99 10.45,100.24 10.45,99.47 10.68,99.24 RN20.5
  BOTTOM w0.127: v3(32.29,98.15) 31.8,97.66 31.44,97.66 31.02,98.08 29.74,98.08 29.34,98.47 17.6,98.47 17.13,98.94 17.13,99.83 17.63,100.34 20.63,100.34 20.94,100.64 20.94,101.4 20.53,101.81 19.39,101.81 v1(19.03,101.45) 18.68,101.81 14.76,101.81 14.38,101.43 v2(14.1,101.43)
USB_P13: length 36.1
  TOP w0.102: v3(39.35,96.81) 39.72,97.17 PCH1.AN20
  TOP w0.127: v2(15.32,99.68) 15.32,100.16 15.17,100.31 12.35,100.31 12.05,100.01 12.05,99.73 12.3,99.47 RN20.1
  BOTTOM w0.102: 32.28,96.55 32.33,96.5 33.81,96.5 35,97.7 36.79,97.7 37.07,97.42 38.79,97.42 39.02,97.19 39.02,96.88 39.1,96.81 v3(39.35,96.81)
  BOTTOM w0.127: 32.28,96.55 28.48,96.55 v1(28.1,96.93) 27.72,96.55 27.21,96.55 25.81,97.95 15.78,97.95 14.05,99.68 14.05,100.03 14.21,100.18 15.27,100.18 15.37,100.08 15.37,99.73 v2(15.32,99.68)
USBRBIAS: length 8.9
  TOP w0.191: R138.1 31.15,98.63 31.15,97.9 31.99,97.06 35.11,97.06 35.48,97.43 36.45,97.43 36.46,97.45 36.82,97.45 PCH1.AV20
  TOP w0.203: PCH1.AU20 PCH1.AV20
V_0P9_LAN: length 35.2
  TOP w0.203: ILAN.22 75.62,216.42 v2(75.72,216.31) ; v2(73.87,211.08) 73.71,211.24 ILAN.11 ; v2(75.72,213.52) 75.37,213.87 75.36,213.87 75.22,214.02 ILAN.16 ; ILAN.47 68.25,213.22 v2(68.1,213.37) 68.22,213.48 68.36,213.48 68.49,213.62 ILAN.46 ; ILAN.43 v2(68.1,214.82) ; ILAN.40 v2(68.1,216.02) ; v2(72.55,211.11) 72.51,211.14 ILAN.8 ; ILAN.37 v2(68.1,217.22)
  TOP w0.508: R441.1 80.93,208.06 80.93,209.46 v2(80.3,210.09)
  BOTTOM w0.508: 68.83,217.33 68.96,217.46 71.56,217.46 v1(72.22,218.12) 72.88,217.46 74.45,217.46 75.6,216.31 v2(75.72,216.31) v2(75.72,213.52) 75.72,212.79 SC38.2 76.28,212.17 76.28,210.78 ; v2(80.3,210.09) 80.3,210.17 79.69,210.78 76.28,210.78 ; 76.28,210.78 75.76,210.25 SC40.2 74.7,210.25 v2(73.87,211.08) 72.57,211.08 v2(72.55,211.11)
V_1P05_ME_5V_IN:
  vias: v2(80.19,60.48)
V_ME_COMP: length 5.6
  TOP w0.305: R618.2 83.98,62.14 83.82,62.29 C591.1 82.94,62.83 82.94,63.41 82.58,63.76 82.58,64.37 v2(82.33,64.62) 82.29,64.66 U33.10
V_ME_FB: length 5.8
  TOP w0.305: R616.2 R620.2 82.84,61.02 82.84,61.93 v2(82.2,62.57) 82.18,62.59 82.18,63.45 81.46,64.16 U33.9
V_ME_PHASE: length 3.5
  TOP w0.102: L6.1 71.46,64.11 v1(71.3,64.27)
VCORE_VCC_SEN: length 67.8
  TOP w0.203: CPU1.E40 178.85,140.75 180.77,142.67 180.77,143.4 v2(180.5,143.67) ; R851.1 233.97,140.11 v2(234.09,139.99)
  BOTTOM w0.203: v2(180.5,143.67) 180.75,143.92 180.75,145.37 184.06,148.67 189.44,148.67 189.9,149.13 190.35,149.13 v1(190.68,149.46) 191.02,149.13 193.22,149.13 193.83,149.74 196.5,149.74 198.38,147.86 201.79,147.86 203.32,146.34 205.39,146.34 210.42,141.31 216.75,141.31 217.56,140.49 225.2,140.49 226.35,141.64 233.04,141.64 233.79,140.89 233.79,140.24 234.04,139.99 v2(234.09,139.99)
VCORE_VSS_SEN: length 67.6
  TOP w0.203: v2(233.2,139.99) 232.82,140.37 R854.1 ; v2(181.39,143.67) 181.13,143.42 181.13,142.51 CPU1.F40
  BOTTOM w0.203: v2(233.2,139.99) 233.46,140.24 233.46,140.75 232.9,141.31 226.48,141.31 225.75,140.58 225.75,140.58 225.34,140.16 217.42,140.16 216.61,140.98 210.28,140.98 205.25,146.01 203.18,146.01 201.66,147.53 198.24,147.53 196.36,149.41 193.97,149.41 193.36,148.8 192.92,148.8 v1(192.62,148.5) 192.31,148.8 190.03,148.8 189.58,148.34 184.19,148.34 181.08,145.23 181.08,143.97 v2(181.39,143.67)
VGA_B: length 4.5
  TOP w0.102: FB5.2 159.13,214.45 C118.1 159.13,215.46 159.74,216.06 FB6.2 160.08,217.04 v1(160.08,218.14)
VGA_BLUE: length 221.2
  TOP w0.102: R146.2 44.3,113.53 44.3,115.9 C192.1 43.85,117.48 43.85,119.39 43.44,119.79 42.45,119.79 v2(42.32,119.67) ; FB5.1 158.03,213.79 157.54,213.3 C123.1 R112.2 157.29,211.49 v2(156.75,211.49)
  TOP w0.191: PCH1.AC3 44.79,106.58 45.14,106.93 45.14,107.44 45.14,110.66 44.86,110.93 R146.2
  BOTTOM w0.102: v2(42.32,119.67) 43.44,120.78 43.44,123.28 46.18,126.02 46.18,131.88 47.67,133.37 47.67,136.54 50.38,139.25 52.28,139.25 55.4,142.37 55.4,143.8 55,144.21 55,155.38 54.59,155.79 54.59,167.19 53.11,168.68 53.11,172.13 56.85,175.88 57.19,175.88 arc(57.43,175.78) 57.53,175.54 57.53,175.33 arc(57.64,175.07) 57.9,174.96 57.99,174.96 arc(58.19,175.04) 58.27,175.24 58.27,175.51 arc(58.63,175.88) 59,175.51 59,174.98 arc(59.37,174.61) 59.74,174.98 59.74,175.51 arc(60.11,175.88) 60.48,175.51 60.48,174.98 arc(60.84,174.61) 61.21,174.98 61.21,175.51 arc(61.32,175.77) 61.58,175.88 62.65,175.88 66.02,179.25 66.02,189.21 67.09,190.28 67.09,196.64 arc(67.46,197.01) 67.83,196.64 67.83,195.09 arc(68.19,194.72) 68.56,195.09 68.56,198.42 71.49,201.35 100.79,201.35 101.71,202.27 109.12,202.27 111.5,204.65 118.58,204.65 120.37,206.45 129.76,206.45 134.68,211.36 138.25,211.36 140.05,213.16 143.84,213.16 144.27,212.73 152.23,212.73 153.25,213.75 154.34,213.75 v1(155.2,212.88) 156.6,211.49 v2(156.75,211.49)
