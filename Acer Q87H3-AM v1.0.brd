# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VGA_BLUE_CONN: length 11
  TOP w0.102: FB6.1 158.34,217.17 158.75,217.59 C120.1 158.75,219.58 159.36,220.19 U7.4 160.83,220.19 161.42,220.78 161.42,224.54 VGA.3
VGA_DDCSCL_5V: length 25.3
  TOP w0.102: MN2.D 159.8,206.44 R805.1 158.78,206.63 158.78,205.14 158.96,204.96 164.07,204.96 164.24,205.14 164.24,205.92 164.73,206.41 166.39,206.41 166.95,206.97 v1(168.13,206.97) 168.71,206.97 169.88,208.14 169.88,212.15 169.42,212.61 168.89,212.61 168.08,213.42 168.08,213.9 167.75,214.23 166.87,214.23 R802.2
VGA_DDCSDA_5V: length 17.3
  TOP w0.102: R801.2 165.95,214 167.65,214 167.85,213.8 167.85,213.32 168.79,212.38 169.33,212.38 169.65,212.06 169.65,208.23 169.04,207.62 167.28,207.62 166.78,207.12 v1(165.39,207.12) 163.91,207.12 R804.1 163.48,206.69 MN1.D
VGA_G: length 2.8
  TOP w0.102: FB3.2 156.34,214.38 C119.1 156.34,215.65 156.81,216.12 FB4.2
VGA_GREEN: length 221.9
  TOP w0.102: v2(153.83,211.49) 154.5,211.49 R111.2 C125.1 154.75,213.74 FB3.1 ; R145.2 41.94,113.6 41.94,115.82 C191.1 42.07,116.97 42.07,118.45 42.41,118.78 42.81,118.78 v2(42.96,118.93)
  TOP w0.191: R145.2 43.72,111.82 43.72,110.4 44.32,109.8 44.32,108.03 44.43,107.92 44.43,106.94 PCH1.AE2
  BOTTOM w0.102: v2(42.96,118.93) 42.96,119.11 44.05,120.2 44.05,123.02 46.79,125.77 46.79,131.6 48.39,133.2 48.39,136.4 50.63,138.64 52.56,138.64 56.01,142.09 56.01,144.05 55.61,144.46 55.61,155.63 55.2,156.04 55.2,167.49 53.72,168.98 53.72,171.88 56.54,174.7 arc(57.06,174.7) 57.06,174.18 55.35,172.47 arc(55.35,171.95) 55.87,171.95 57.89,173.97 61.6,173.97 66.63,179 66.63,188.93 68.26,190.56 68.26,193.72 arc(68.63,194.09) 68.99,193.72 68.99,192.42 arc(69.36,192.06) 69.73,192.42 69.73,198.73 71.75,200.74 101.05,200.74 101.96,201.66 109.37,201.66 111.76,204.05 118.83,204.05 120.62,205.84 123.98,205.84 arc(124.24,205.73) 124.34,205.47 124.34,205 arc(124.71,204.63) 125.08,205 125.08,205.47 arc(125.45,205.84) 125.82,205.47 125.82,205 arc(126.19,204.63) 126.55,205 126.55,205.47 arc(126.92,205.84) 127.29,205.47 127.29,205 arc(127.66,204.63) 128.03,205 128.03,205.47 arc(128.14,205.73) 128.4,205.84 130.01,205.84 134.93,210.75 138.5,210.75 140.31,212.55 143.59,212.55 144.05,212.1 152.48,212.1 v1(152.74,211.84) 153.47,211.84 v2(153.83,211.49)
VGA_GREEN_CONN: length 11.7
  TOP w0.102: VGA.2 159.4,224.8 U7.6 158.59,222.09 158.14,221.64 158.14,219.61 157.36,218.83 156.09,218.83 155.26,218 C121.1 155.26,216.85 FB4.1
VGA_H_SYNC: length 8.9
  TOP w0.102: R954.2 C128.1 R799.2 164.47,213.52 166.73,213.52 v2(167.04,213.21) 167.28,213.21 168.88,211.61 U35.4
VGA_H_SYNC_R: length 18.4
  TOP w0.102: R954.1 163.26,217.23 164.19,218.16 164.19,220.31 163.93,220.57 U24.1 163.12,220.91 163.48,221.27 165.23,221.27 165.48,221.52 C708.1 165.56,222.24 165.56,225.79 164.37,226.98 164.37,228.03 VGA.13
VGA_HSYNC: length 217
  TOP w0.102: v2(39.28,120.28) 39.28,119.51 R142.1 ; R799.1 163.26,213.23 163.46,213.04 166.07,213.04 166.63,212.48 167.33,212.48 167.93,211.88 U35.2 U35.1 166.34,208.09 C245.1 164.97,208.09 164.75,208.31 164.75,209.23 v2(164.5,209.48)
  BOTTOM w0.102: v2(39.28,120.28) 39.66,120.28 41.41,118.52 41.41,116.96 42.26,116.11 44.2,116.11 44.99,116.9 44.99,118.22 45.27,118.5 45.27,119.01 45.88,119.62 45.88,122.45 48.5,125.06 48.5,130.87 50.22,132.6 50.22,135.83 51.08,136.68 53.14,136.68 57.72,141.26 57.72,144.91 57.44,145.19 57.31,145.31 57.31,156.34 56.9,156.74 56.9,169.91 59.26,172.27 62.34,172.27 68.33,178.27 68.33,188.14 75.6,195.41 75.6,196.5 77.64,198.55 79.01,198.55 80.02,197.54 83.65,197.54 85.1,198.99 101.7,198.99 102.67,199.96 110.15,199.96 112.54,202.34 116.92,202.34 118.5,200.77 129.12,200.77 134.55,206.2 134.55,207.91 135.41,208.77 140.01,208.77 140.32,209.07 162.01,209.07 v1(162.41,209.48) 162.69,209.2 164.22,209.2 v2(164.5,209.48)
VGA_PCH_DDCSCL: length 261.4
  TOP w0.089: 40.93,107.75 40.72,107.96 40.67,108.01 40.67,108.11
  TOP w0.102: 40.93,107.75 40.98,107.7 40.98,107.36 41.06,107.27 PCH1.AL2 ; MN2.S 160.81,202.63 R803.1 159.61,201.43 157.96,201.43 154.46,204.94 148.68,204.94 145.57,208.04 145.57,214.75 149.13,218.31 149.13,221.14 v2(148.11,222.16) ; v3(40.32,109.79) 40.67,109.43 40.67,108.11
  BOTTOM w0.102: v3(40.32,109.79) 39.78,109.79 39.3,109.3 37.87,109.3 36.28,110.9 36.28,112.04 37.69,113.46 37.69,116.17 35.36,118.5 33.91,118.5 33.68,118.72 32.82,119.58 32.82,120.26 30.32,122.76 30.32,179.8 31.06,180.53 31.06,181.53 30.59,182 30.59,190.7 31.92,192.03 32.86,192.03 35.56,194.73 36.72,194.73 37.02,195.03 37.99,195.03 39.21,196.25 40.55,196.25 41.82,197.52 43,197.52 44.2,196.32 49.19,196.32 50.28,197.42 52.23,197.42 52.61,197.03 54.34,197.03 58.1,200.79 59.13,200.79 60.05,201.71 65.69,201.71 68.76,204.78 98.45,204.78 100.58,206.92 107.92,206.92 110.21,209.2 113.51,209.2 116.63,212.32 120.87,212.32 121.65,211.54 129.62,211.54 133.69,215.6 137.04,215.6 139.23,217.79 v1(139.23,219.54) 140.09,220.41 140.65,220.41 141.76,221.52 147.48,221.52 v2(148.11,222.16)
VGA_PCH_DDCSDA: length 286.2
  TOP w0.089: 40.93,106.82 40.72,107.02 40.72,107.69 40.58,107.84 40.47,107.94 40.47,108.11
  TOP w0.102: PCH1.AL3 41.01,106.73 40.93,106.82 ; MN1.S 164.5,202.88 R978.1 162.81,201.2 157.87,201.2 154.44,204.63 148.62,204.63 145.32,207.93 145.32,214.82 148.88,218.38 148.88,220.54 147.61,221.81 147.61,222.41 v2(148.11,222.92) ; v3(40.22,109.15) 40.47,108.9 40.47,108.11
  BOTTOM w0.102: v2(148.11,222.92) 147.68,222.49 143.95,222.49 arc(143.77,222.31) 143.95,222.13 146.92,222.13 arc(147.1,221.95) 146.92,221.77 141.64,221.77 140.62,220.76 139.35,220.76 138.21,219.62 138.21,217.76 arc(138.03,217.58) 137.85,217.76 137.85,217.91 arc(137.81,218.02) 137.7,218.07 137.68,218.07 arc(137.55,218.01) 137.5,217.89 137.5,216.49 136.97,215.97 133.53,215.97 129.69,212.13 arc(129.44,212.13) 129.44,212.38 132.87,215.81 arc(132.87,216.06) 132.62,216.06 128.33,211.77 121.8,211.77 121.02,212.54 116.53,212.54 113.42,209.43 110.12,209.43 107.83,207.14 100.49,207.14 98.36,205.01 68.66,205.01 65.62,201.96 59.98,201.96 59.04,201.02 58.01,201.02 54.25,197.26 52.7,197.26 52.32,197.64 50.19,197.64 49.09,196.55 44.29,196.55 43.1,197.75 41.73,197.75 40.46,196.48 39.11,196.48 37.89,195.26 36.93,195.26 36.63,194.96 35.46,194.96 32.78,192.27 31.84,192.27 30.36,190.79 30.36,181.82 30.83,181.35 30.83,180.63 30.09,179.89 30.09,121.99 v1(31.05,121.04) 33.81,118.27 35.26,118.27 37.47,116.07 37.47,113.55 36.05,112.13 36.05,110.8 37.78,109.07 40.14,109.07 v3(40.22,109.15)
VGA_R: length 3
  TOP w0.102: FB2.2 152.5,216.48 153.54,215.43 C117.1 153.54,214.25 FB1.2
VGA_RED: length 221.2
  TOP w0.102: v2(42.93,117.89) 42.93,117.53 43.72,116.75 C190.1 43.14,115.88 43.14,113.55 R144.2 ; FB1.1 151.96,213.87 C126.1 R110.2 151.44,211.23 v2(151.44,210.98)
  TOP w0.191: PCH1.AC2 44.78,107.1 44.78,110 44.23,110.55 44.23,112.46 R144.2
  BOTTOM w0.102: v2(42.93,117.89) 43.47,117.89 43.87,118.29 43.87,118.65 44.18,118.96 44.18,119.46 44.66,119.95 44.66,122.77 47.4,125.51 47.4,131.33 49.03,132.95 49.03,136.18 50.81,137.95 52.76,137.95 56.62,141.82 56.62,144.38 56.22,144.78 56.22,155.88 55.81,156.29 55.81,167.75 54.34,169.22 54.34,171.19 arc(54.71,171.56) 55.07,171.19 55.07,169.67 arc(55.44,169.3) 55.81,169.67 55.81,170.36 58.81,173.36 61.86,173.36 67.24,178.75 67.24,188.63 72.8,194.19 72.8,198.29 arc(73.17,198.66) 73.54,198.29 73.54,196.23 arc(73.91,195.87) 74.28,196.23 74.28,198.74 75.67,200.13 101.3,200.13 102.21,201.05 109.7,201.05 112.09,203.44 118.07,203.44 119.41,202.09 119.76,202.09 arc(120,202.19) 120.1,202.44 120.1,202.86 arc(120.47,203.23) 120.84,202.86 120.84,202.46 arc(121.21,202.09) 121.58,202.46 121.58,202.86 arc(121.95,203.23) 122.31,202.86 122.31,202.46 arc(122.68,202.09) 123.05,202.46 123.05,202.86 arc(123.42,203.23) 123.79,202.86 123.79,202.46 arc(123.89,202.2) 124.16,202.09 128.89,202.09 129.83,203.03 arc(129.94,203.29) 129.83,203.55 129.48,203.89 arc(129.48,204.41) 130.01,204.41 130.35,204.07 arc(130.87,204.07) 130.87,204.59 130.53,204.93 arc(130.53,205.46) 131.05,205.46 131.39,205.11 arc(131.91,205.11) 131.91,205.63 131.57,205.98 arc(131.57,206.5) 132.09,206.5 132.47,206.12 arc(132.69,206.02) 132.92,206.12 133.14,206.34 133.14,208.1 135.18,210.14 138.76,210.14 140.53,211.92 143.31,211.92 144.41,210.83 v1(144.99,210.83) 145.55,211.39 151.04,211.39 v2(151.44,210.98)
VGA_RED_CONN: length 13.1
  TOP w0.102: VGA.1 154.8,222.5 154.8,221.04 155.51,220.33 156.76,220.33 U7.3 156.9,219.84 156.5,219.44 155.84,219.44 155.18,218.78 154.74,218.78 154.41,218.45 154.41,218.33 C122.1 153.89,217.81 FB2.1
VGA_V_SYNC: length 6.2
  TOP w0.102: R955.2 161.93,216.57 C127.1 R800.2 161.93,213.58 v2(162.52,212.99) 163.54,211.96 U36.4
VGA_V_SYNC_R: length 24.4
  TOP w0.102: R955.1 161.1,217.49 161.32,217.71 162.72,217.71 163.12,218.11 U24.3 161.51,218.67 161.2,218.98 161.2,219.69 162.03,220.53 162.03,221.22 162.21,221.39 162.93,221.39 163.32,221.79 C709.1 163.32,225.92 162.08,227.16 162.08,228.51 160.94,229.65 160.94,231.17 161.45,231.68 163.01,231.68 VGA.14
VGA_VSYNC: length 209.2
  TOP w0.102: v2(159.42,210.09) 159.54,209.96 159.54,208.82 160.02,208.34 C246.1 161.26,208.34 U36.1 U36.2 162.59,211.88 162.16,212.31 161.64,212.31 160.97,212.98 R800.1 ; R143.1 38.54,119.91 38.54,120.58 39.15,121.19 v2(39.28,121.19)
  BOTTOM w0.102: v2(159.42,210.09) 159.19,209.86 155.33,209.86 v1(155.1,210.09) 152.81,210.09 152.28,209.56 139.91,209.56 139.68,209.33 135.29,209.33 133.79,207.83 133.79,206.13 129.14,201.48 118.78,201.48 117.43,202.83 112.34,202.83 109.95,200.44 102.47,200.44 101.5,199.47 77.81,199.47 75.11,196.78 75.11,195.64 67.85,188.37 67.85,178.47 62.14,172.75 59.06,172.75 56.42,170.11 56.42,156.54 56.83,156.14 56.83,145.11 57.03,144.91 57.23,144.71 57.23,141.54 53.02,137.32 51.03,137.32 49.74,136.03 49.74,132.8 48.01,131.07 48.01,125.26 45.27,122.52 45.27,119.69 44.79,119.21 44.79,118.7 44.43,118.35 44.43,117.15 44.2,116.92 42.32,116.92 42.02,117.23 42.02,118.8 39.63,121.19 v2(39.28,121.19)
VI_SID_ARL: length 4.3
  TOP w0.102: v2(203.92,149.49) 204.05,149.35 R6.1 204.88,149.48 204.88,149.99 204.73,150.15 R12.1 R9.1
VID_ALERT_L_R: length 36.7
  TOP w0.102: CPU1.B37 175.71,144.47 177.2,145.96 179.61,145.96 184.79,151.14 195.68,151.14 arc(196.04,150.77) 195.68,150.4 194.2,150.4 arc(193.83,150.03) 194.2,149.66 197.7,149.66 R10.2 198.5,149.84 198.5,149.75 198.75,149.49 v2(201.3,149.49) 201.3,149.87 201.58,150.15 R12.2
VID_CK_R: length 42.9
  TOP w0.102: R11.1 201.49,147.86 198.79,147.86 198.18,148.46 R7.1 192.77,148.75 190.79,150.73 185.63,150.73 arc(185.33,150.43) 185.63,150.12 190.15,150.12 arc(190.46,149.82) 190.15,149.51 v2(184.94,149.51) 183.93,149.51 179.74,145.32 177.18,145.32 176.19,144.33 176.19,143.01 CPU1.C38
VR_B: length 4.1
  TOP w0.102: QN78.B 233.59,122.54 v2(233.15,122.97) 232.66,123.46 R890.2
VR_EN: length 53.8
  TOP w0.203: U39.1 226.49,148.13 226.19,147.84 224.26,147.84 223.45,147.02 221.27,147.02 220.56,146.31 v1(220.56,146.06) 220.56,145.75 220.98,145.32 C737.1
  TOP w0.254: v2(233.43,123.81) 234.02,123.81 QN78.C 234.35,122.97 234.35,121.7 234.6,121.44 QN77.C ; C6.2 228.32,128.81 QN2.C v2(233.33,128.81) ; v2(232.95,135.01) 232.55,135.01 229.07,138.49 224.47,138.49 223.43,137.45 220.99,137.45 219.36,139.07 219.36,141.89 219.62,142.15 220.35,142.15 R810.2 R815.1 C737.1
  BOTTOM w0.254: v2(232.95,135.01) 233.26,134.7 233.26,128.89 v2(233.33,128.81) 233.66,128.48 233.66,124.04 v2(233.43,123.81)
VR_GC: length 5
  TOP w0.102: QN79.C 230.69,123.32 v1(230.69,124.57) 230.74,124.62 R890.1 232.22,125.13 233.36,125.13 R886.1
VR_GR: length 2.5
  TOP w0.102: QN79.B 229.06,120.94 v1(228.61,121.39) 228.43,121.57 R894.2
VR_HOT_L: length 32.9
  TOP w0.102: R38.1 198.76,140.61 199.35,140.01 200.69,140.01 R35.1 201.8,141.13 203.54,141.13 203.74,140.93 204.17,140.93 C680.1 204.62,140.47 206.03,140.47 206.79,139.71 206.79,138.97 207.3,138.46 208.69,138.46 v2(209.46,137.7) ; v2(221.9,138.89) 222.46,138.89 223.32,139.76 223.32,143.44 223.81,143.92 R824.1
  BOTTOM w0.102: v2(221.9,138.89) 221.88,138.92 211.69,138.92 v1(211.11,138.34) 210.09,138.34 v2(209.46,137.7)
VR_HOT_L_95820: length 10.5
  TOP w0.102: R824.2 222.92,144.53 v1(222.92,144.3)
  TOP w0.203: R824.2 223.81,146.08 224.62,146.9 227.29,146.9 227.91,147.51 U39.4
  TOP w0.254: R819.2 224.31,143.38 224.31,145.07 223.97,145.42 R824.2
VR_READY: length 436.2
  TOP w0.102: v2(86.39,12.48) 84.84,14.03 84.84,19.82 87.15,22.13 v2(87.15,24.42) ; v2(64.93,58.33) 64.68,58.58 53.05,58.58 50.04,55.57 42.87,55.57 42.27,56.17 39.69,56.17 R255.2 ; U39.2 227.11,147.73 226.93,147.56 224.39,147.56 224.34,147.51 224.33,147.51 223.49,146.67 222.14,146.67 221.57,146.11 221.57,142.45 220.98,141.86 R820.2 220.98,138.93 221.52,138.39 222.46,138.39 223.5,139.43 230.59,139.43 234.73,135.29 R988.1 236.25,135.29 236.63,135.67 236.89,135.67 237.55,135.01 v2(237.55,134.25) 237.87,133.92 R62.2 ; v2(232.16,84.51) 232.09,84.51 230.59,83.01 230.59,76.15 236.79,69.96 236.79,66.83 236.43,66.48 236.43,65.59 235.74,64.9 235.74,55.02 243.44,47.33 243.44,21.06 v2(241.59,19.21)
  BOTTOM w0.102: v2(86.39,12.48) 86.39,10.32 86.7,10.01 87.66,9.05 87.66,7.04 92.51,2.19 103.33,2.19 106.13,4.99 108.87,4.99 112.66,1.2 112.66,1.2 112.79,1.07 224.1,1.07 226.73,3.7 230.02,3.7 231.95,5.63 231.95,8.89 241.59,18.53 v2(241.59,19.21) ; v2(232.16,84.51) 232.09,84.59 232.09,86.49 229.14,89.44 229.14,92.39 228.89,92.64 228.89,98.08 227.87,99.09 227.87,105.39 v1(229.04,106.56) 229.04,107.12 237.78,115.86 237.78,123.11 237.4,123.49 237.4,124.68 237.52,124.8 237.52,127.16 237.34,127.34 237.34,133.68 237.55,133.88 v2(237.55,134.25) ; v2(87.15,24.42) 87.19,24.38 87.37,24.38 89.31,26.32 89.31,29.62 87.03,31.91 87.03,33.73 82.29,38.46 80.79,38.46 79.03,40.22 79.03,43.82 78.69,44.15 77.5,45.34 77.5,56.17 76.18,57.49 65.77,57.49 v2(64.93,58.33)
VR_SVID_ALERT_L: length 38.7
  TOP w0.102: v2(201.52,151.16) 201.65,151.29 R9.2 ; U39.39 225.77,149.13 225.52,148.88 224.05,148.88 223.11,147.94 218.55,147.94 v2(217.71,147.1) R818.2
  BOTTOM w0.102: 202.98,151.16 203.99,151.16 210.17,144.99 214.71,144.99 arc(215.02,145.3) 214.71,145.6 211.34,145.6 arc(211.03,145.9) 211.34,146.21 216.82,146.21 v2(217.71,147.1) ; 202.98,151.16 v2(201.52,151.16) ; 202.98,151.16 v1(202.98,151.16)
VR_SVID_CK: length 38.7
  TOP w0.102: v2(199.87,148.75) R7.2 ; U39.40 225.94,148.73 225.69,148.47 224.22,148.47 223.28,147.53 219.29,147.53 v2(218.85,147.1) R814.2
  BOTTOM w0.102: v2(218.85,147.1) 218.85,146.21 218.45,145.8 216.21,145.8 215.86,145.45 215.86,143.85 v1(215.81,143.8) 214.92,142.91 212.07,142.91 arc(211.77,143.21) 212.07,143.52 213.09,143.52 arc(213.37,143.71) 213.3,144.04 arc(213.2,144.1) 213.09,144.13 210.33,144.13 204.35,150.11 204.34,150.11 204.22,150.22 203.3,150.22 201.83,148.75 v2(199.87,148.75)
VR_SVID_DATAOUT: length 38.7
  TOP w0.102: R816.2 v2(216.57,147.1) 217.81,148.34 222.95,148.34 223.89,149.28 225.35,149.28 225.58,149.52 225.58,149.53 U39.38 ; R8.2 v2(199.85,151.29)
  BOTTOM w0.102: v2(199.85,151.29) v1(200.62,152.05) 203.68,152.05 207.62,148.11 214.71,148.11 arc(215.02,147.81) 214.71,147.5 211.72,147.5 arc(211.41,147.2) 211.72,146.9 216.36,146.9 v2(216.57,147.1)
VR_SVID_DATAOUT_R: length 48.7
  TOP w0.102: R5.1 205.9,149.89 203.84,151.95 198.75,151.95 198.5,151.69 198.5,151.6 R8.1 196.71,152.76 192.06,152.76 arc(191.75,152.46) 192.06,152.15 195.84,152.15 arc(196.15,151.85) 195.84,151.54 183.55,151.54 v2(182.02,150.02) 180.37,148.37 179.1,148.37 175.28,144.55 175.28,143.01 CPU1.C37
VRD_THERMDA: length 331.9
  TOP w0.254: v2(236.96,41.76) 237.17,41.56 238.21,41.56 241.54,44.89 241.54,47.55 238.28,50.81 237.47,50.81 234.6,53.67 234.6,62.87 233.59,63.89 233.59,69.63 227.67,75.54 227.67,83.91 231.5,87.74 238.59,87.74 239.3,88.45 239.3,136.68 v2(239.05,136.94) ; U21.89 215.98,14.88 214.66,13.56 C815.1 215.3,12.83 215.3,11.59 v2(215.36,11.53) ; QN81.B 156.88,188.18 QN81.C 154.75,188.18 C816.1 154.15,188.79 v2(153.04,188.79) ; v2(234.04,22.32) 234.22,22.14 234.22,21.78 233.94,21.5 233.15,21.5 232.59,22.05 231,22.05 230.43,21.48 230.43,20.88 v2(230.23,20.68)
  BOTTOM w0.254: v2(215.36,11.53) 215.36,10.28 215.97,9.67 223.73,9.67 227.05,12.99 227.05,13.65 230.04,16.65 230.04,18.3 230.42,18.68 230.42,20.49 v2(230.23,20.68) ; v2(234.04,22.32) 234.22,22.5 234.22,22.85 233.92,23.16 233.92,24.2 234.8,25.09 234.8,28.79 234.98,28.97 234.98,37.12 236.23,38.36 236.23,41.21 236.79,41.76 v2(236.96,41.76) ; v2(239.05,136.94) 238.74,137.24 238.11,137.24 236.58,138.77 236.58,140.73 239.35,143.49 239.35,151.53 238.36,152.52 238.36,154.06 239.31,155.01 239.31,175.6 238.36,176.55 238.36,178.57 239.38,179.59 239.38,198.05 237.49,199.93 214.46,199.93 211.22,196.69 161.07,196.69 154.32,189.95 154.32,189.6 153.74,189.02 153.27,189.02 v2(153.04,188.79)
VRD_THERMDC: length 331.8
  TOP w0.254: v2(214.66,11.21) C815.2 214.19,12.51 213.84,12.16 R937.2 ; v2(239.05,138.08) 239.17,138.08 239.86,137.4 239.86,88.22 238.82,87.18 231.73,87.18 228.23,83.67 228.23,75.78 234.14,69.86 234.14,64.12 235.16,63.1 235.16,53.91 237.7,51.37 238.51,51.37 242.09,47.78 242.09,44.66 238.44,41 237.29,41 v2(237.04,40.75) ; v2(234.96,22.32) 234.78,22.14 234.78,21.54 234.17,20.94 232.92,20.94 232.36,21.5 231.23,21.5 230.99,21.25 230.99,20.84 v2(231.16,20.67) ; v2(153,189.74) 154.15,189.74 C816.2 154.56,189.68 155.04,189.2 QN81.E
  BOTTOM w0.254: v2(237.04,40.75) 236.79,40.49 236.79,38.13 235.54,36.88 235.54,28.73 235.36,28.56 235.36,24.86 234.47,23.97 234.47,23.39 234.78,23.08 234.78,22.5 v2(234.96,22.32) ; v2(153,189.74) 153.16,189.58 153.51,189.58 153.77,189.83 153.77,190.18 160.84,197.25 210.99,197.25 214.23,200.49 237.73,200.49 239.94,198.28 239.94,179.36 238.92,178.34 238.92,176.78 239.87,175.83 239.87,154.78 238.92,153.83 238.92,152.75 239.91,151.76 239.91,143.26 237.14,140.49 237.14,139 238.34,137.8 238.77,137.8 v2(239.05,138.08) ; v2(231.16,20.67) 230.98,20.49 230.98,18.45 230.6,18.07 230.6,16.42 227.6,13.42 227.6,12.75 223.96,9.11 215.74,9.11 214.8,10.05 214.8,11.07 v2(214.66,11.21)
VREF: length 7.7
  TOP w0.254: C507.1 20.89,232.44 20.02,231.57 v2(20.02,230.92) 20.02,226.79 20.2,226.61 CODEC.27
VSUM+: length 67.2
  TOP w0.102: v2(218.09,158.66) 218.73,159.29 R873.2 ; C761.1 238.13,148.46 C762.1 238.13,146.24 C764.1
  TOP w0.127: C764.1 237.97,144.95 R867.2 237.88,144.91 R868.2 ; U39.16 232.24,150.73 232.87,150.1 233.76,150.1 v2(234.09,149.77) 234.7,149.77 R939.1 235.27,149.19 237.4,149.19 C761.1 ; v2(207.3,158.66) R898.2 ; v2(210.73,158.66) R823.2 ; v2(214.15,158.66) R845.2
  BOTTOM w0.127: v2(234.09,149.77) 234.09,148.37 231.53,145.8 230.44,145.8 229.39,146.84 225.97,146.84 222.56,150.25 209.61,150.25 206.8,153.05 206.8,156.97 207.3,157.46 v2(207.3,158.66) 208.06,159.42 v1(208.57,159.42) 209.84,159.42 210.6,158.66 v2(210.73,158.66) 211.23,159.16 213.52,159.16 214.03,158.66 v2(214.15,158.66) 214.65,159.15 217.6,159.15 v2(218.09,158.66)
VSUM+_RC: length 110.6
  TOP w0.203: RT3.1 171.23,169.81 v2(170.8,170.24) ; v2(236.05,143.14) 236.18,143.26 237.24,143.26 R867.1
  BOTTOM w0.203: v2(236.05,143.14) 235.87,143.31 235.87,144.28 235.34,144.81 230.18,144.81 229.04,145.96 225.46,145.96 222.41,149 218.98,149 218.22,149.77 209.2,149.77 205.85,153.12 v1(205.85,153.6) 205.37,153.6 204.88,154.08 204.88,158.53 207.42,161.07 207.42,162.85 208.03,163.46 210.51,163.46 211.7,164.65 211.7,168.46 206.9,173.26 186.5,173.26 184.86,171.62 184.86,167.55 182.43,165.13 173.15,165.13 171.2,167.08 171.2,169.83 v2(170.8,170.24)
VSUM-: length 136.9
  TOP w0.203: v2(205.01,159.67) 205.01,158.53 205.68,157.86 R902.2 ; R874.1 R872.1 R875.1 236.03,146.62 C764.2 236.09,145.61 236.09,144.57 236.37,144.29 236.42,144.29 R868.1 235.97,143.96 235.9,144.03 C766.2 235.36,143.31 v2(235.19,143.14) ; RT3.2 171.23,168.13 v2(170.59,167.49)
  TOP w0.254: 216.44,157.86 R879.2 C767.2 ; 216.44,157.86 C755.2 ; 216.44,157.86 R881.2 ; R904.2 C775.2 ; C775.2 R902.2 ; C775.2 R832.2 C741.2 ; C741.2 R855.2 C755.2 ; C741.2 R835.2 ; C755.2 R859.2
  BOTTOM w0.203: v2(170.59,167.49) 170.8,167.29 170.8,166.91 172.98,164.73 182.6,164.73 185.26,167.39 185.26,171.45 186.67,172.85 206.73,172.85 211.3,168.29 211.3,164.82 210.34,163.86 207.86,163.86 207.02,163.01 207.02,161.24 205.45,159.67 v2(205.01,159.67) 205.01,159.23 204.48,158.7 204.48,153.92 206.15,152.24 v1(206.15,151.77) 206.62,151.77 209.03,149.36 218.05,149.36 218.81,148.6 222.24,148.6 225.29,145.55 228.87,145.55 230.01,144.41 235.17,144.41 235.47,144.11 235.47,143.42 v2(235.19,143.14)
WAKE_B_L: length 7.8
  TOP w0.102: U11.1 67.13,142.44 67.47,142.09 67.47,140.52 67.62,140.37 67.62,138.91 67.98,138.55 67.98,137.73 R278.1 68.64,136.46 v1(68.36,136.18)
WRST_L: length 7.1
  TOP w0.102: v2(197.31,27.29) 197.31,27.08 197.26,27.03 R345.1 197.77,25.78 197.77,25.18 198.08,24.87 199.44,24.87 C390.1 200.43,25.43 200.95,24.91 U21.50
XDP_P39: length 7.4
  TOP w0.102: v2(217.46,129.19) 217.36,129.29 R983.2 R982.2 v1(216.26,131.1)
  BOTTOM w0.102: v2(217.46,129.19) 218.09,129.83 218.85,129.83 219.27,129.41 SJ1.39
XDP_P40: length 6.1
  BOTTOM w0.102: SJ1.40 228.85,129.41 229.01,129.57 229.29,129.57 229.52,129.34 229.52,128.52 230.75,127.29 230.75,126.66 230.58,126.49 SR33.2
XDP_P41: length 6.8
  TOP w0.102: v2(223.81,129.95) 224.72,129.95 v1(224.9,130.13) 226.37,131.6 R984.2
  BOTTOM w0.102: SJ1.41 223.77,129.91 v2(223.81,129.95)
XDP_P42: length 6.1
  BOTTOM w0.102: SR34.2 231.01,126.78 231.01,127.39 229.78,128.62 229.78,129.45 229.39,129.83 228.91,129.83 228.82,129.91 SJ1.42
XDP_P45: length 6.3
  BOTTOM w0.102: SJ1.45 219.8,130.91 219.23,131.48 SR30.2 217.78,130.94 216.03,130.94 v1(215.63,131.35)
XDP_P46: length 6
  TOP w0.102: R986.2 222.56,129.83 v1(222.97,130.23) 223.32,130.59 224.44,130.59 v2(224.95,131.1)
  BOTTOM w0.102: v2(224.95,131.1) 225.13,130.91 SJ1.46
XDP_P60: length 44
  TOP w0.102: v2(219.11,124.49) 219.11,124.11 222.28,120.94 227.87,120.94 228.73,120.07 231.93,120.07 233.1,118.9 v2(233.59,118.9)
  BOTTOM w0.102: v2(219.11,124.49) 218.85,124.75 SR40.2 ; v2(233.59,118.9) 232.82,119.67 v1(232.82,120.28) 232.82,121.7 234.09,122.97 234.09,128.99 233.56,129.52 233.56,134.39 234.09,134.92 234.09,135.8 233.33,136.56 231.55,136.56 229.41,134.42 SJ1.60
XDP_VR_READY: length 19.3
  TOP w0.102: R988.2 R989.2 232.7,134.14 231.58,135.26 228.63,135.26 v1(226.96,133.59) 225.86,132.49 v2(223.81,132.49)
  BOTTOM w0.102: v2(223.81,132.49) 222.73,131.41 SJ1.47 219.68,131.41 218.47,132.62 SC43.2
XTAL_25M_PCH_IN: length 34.4
  TOP w0.102: v3(50.95,103.96) 50.68,104.23 PCH1.N7 ; X1.2 62.86,124.33 62.26,123.73 C198.2 61.85,123.51 R162.1 60.87,122.4 v2(60.87,121.44)
  BOTTOM w0.102: v3(50.95,103.96) 50.45,104.46 50.45,105.19 50.83,105.57 50.83,107.88 51.49,108.54 51.49,112.07 51.75,112.33 51.75,114.23 56.42,118.9 56.42,122.52 57.07,123.17 59.65,123.17 60.87,121.95 v2(60.87,121.44)
XTAL_25M_PCH_OUT: length 31.2
  TOP w0.102: v2(59.47,121.44) 59.47,122.4 R162.2 59.37,122.46 C199.2 57.78,124.05 X1.1 ; PCH1.N6 50.62,104.94 v3(50.94,104.63)
  BOTTOM w0.102: v2(59.47,121.44) 59.47,122.33 58.99,122.82 57.22,122.82 56.78,122.37 56.78,118.76 52.1,114.08 52.1,112.17 51.85,111.92 51.85,108.41 51.04,107.59 51.04,104.72 v3(50.94,104.63)
N23497998: length 8.7
  TOP w0.102: v2(188.81,18.55) 187.68,18.55 R991.2
  TOP w0.381: R991.2 188.14,17.88 188.14,16.96 188.5,16.6 188.5,14.38 188.72,14.16 C854.1 R995.1 R994.1
N23498029: length 7
  TOP w0.102: QN84.C 189.01,16.9 v2(189.36,16.54)
  TOP w0.381: QN83.B 191.04,22.26 189.87,21.08 R990.2 189.87,18.42 QN84.C
N23498035: length 1.5
  TOP w0.381: R994.2 191.42,16.42 QN84.B
N23702339: length 2.2
  TOP w0.102: QN35.C 19.59,87.21 v2(18.7,88.09) 18.63,88.17 R998.1
N23702342: length 3.7
  TOP w0.102: v2(20.35,86.14) QN35.B 21.88,85.34 R999.1
N23713553: length 7.8
  TOP w0.508: 19.62,204.95 C857.2 18.42,204.19 R1001.2 ; 19.62,204.95 C856.1 ; 19.62,204.95 21.56,204.95 21.94,205.33 22.77,205.33 QP9.G

## Copper pours and planes (outline as drawn)
+1.8VA on TOP (solid shape): 71.66,149.77 71.66,147.63 72.27,147.02 72.27,146.06 72.09,145.88 70.97,145.88 70.52,146.34 67.16,146.34 67.16,146.38 65.53,146.38 65.53,146.34 65.44,146.34 65.39,146.39 65.39,147 65.44,147.05 65.53,147.05 65.53,146.99 67.16,146.99 67.16,147.05 69.48,147.05 69.58,147.15 69.58,147.86 69.65,147.94 69.96,147.94 70.47,148.44 70.47,149.82 70.67,150.02 71.41,150.02
+3VSB on TOP (solid shape): 58.96,189.9 58.96,188.63 58.71,188.37 55.28,188.37 55.15,188.5 55.15,189.64 55.28,189.77 57.18,189.77 57.56,190.15 58.71,190.15
+3VSB on TOP (solid shape): 45.24,79.6 45.24,78.39 44.97,78.11 40.85,78.11 40.55,78.42 40.55,79.53 40.67,79.66 45.18,79.66
+3VSB on TOP (solid shape): 40.91,91.3 40.91,90.87 40.34,90.3 39.94,90.3 39.75,90.11 39.73,90.11 39.58,90.02 39.48,89.86 39.48,89.85 39.45,89.82 39.15,89.82 39.02,89.69 38.74,89.69 38.67,89.77 38.67,90.1 38.87,90.3 39.14,90.3 39.18,90.35 39.64,90.81 39.66,90.81 39.77,90.82 39.87,90.87 40.39,91.4 40.81,91.4
+3VSB on TOP (solid shape): outline of 183 points within 75.22,188.12 84.61,191.37
+3VSB on BOTTOM (solid shape): 40.67,91.37 40.67,90.99 39.81,90.13 39.79,90.12 39.58,90.02 39.47,89.8 39.47,89.78 38.54,88.86 37.83,88.86 36.64,87.67 35.93,87.67 35.26,87 33.03,84.77 32.54,84.77 32.14,85.17 32.14,85.52 36.06,89.44 37.99,89.44 38.9,90.35 39.27,90.35 39.35,90.35 40.08,91.08 40.08,91.33 40.21,91.47 40.57,91.47
+3VSB on BOTTOM (solid shape): outline of 330 points within 57.56,187.48 65.44,191.73
+3VSB on PWR (solid shape): outline of 237 points within 83.65,111.97 94.47,187.56
+3VSB on PWR (solid shape): outline of 324 points within 34.7,94.14 42.58,97.95
+5VA on TOP (solid shape): 22.69,229.76 22.69,228.43 22.51,228.25 22.51,224.7 22.38,224.57 21.11,224.57 21.05,224.64 21.05,226.28 21.24,226.47 21.24,228.25 20.99,228.51 20.73,228.51 20.48,228.76 20.48,229.65 20.73,229.9 22.55,229.9
+5VA on TOP (solid shape): 13.46,225.13 13.49,225.06 13.52,224.99 13.57,224.93 13.62,224.87 13.68,224.82 13.74,224.77 13.8,224.73 13.87,224.7 13.94,224.67 14.02,224.66 14.09,224.64 14.17,224.64 14.25,224.64 14.32,224.66 14.4,224.67 14.47,224.7 14.54,224.73 14.6,224.77 14.66,224.82 14.72,224.87 14.77,224.93 14.81,224.99 14.85,225.06 14.88,225.13 14.91,225.2 15.15,225.2 15.27,225.08 15.27,223.33 15.18,223.24 13.44,223.24 13.44,223.17 12.99,223.17 12.54,223.62 13.44,223.62 13.44,223.54 14.96,223.54 14.96,223.62 15.09,223.62 15.09,224.31 13.31,224.31 13.31,223.62 12.54,223.62 12.48,223.68 9.68,223.68 9.43,223.93 9.43,225.08 9.48,225.13 12.94,225.13 13.02,225.2 13.43,225.2
+5VA on BOTTOM (solid shape): 11.34,225.08 11.34,223.81 11.21,223.68 9.81,223.68 9.63,223.86 9.63,225.03 9.81,225.2 11.21,225.2
+5VA on BOTTOM (solid shape): 23.15,229.78 23.15,227.62 23.02,227.49 21.75,227.49 21.62,227.62 21.62,229.78 21.75,229.9 23.02,229.9
+5VSB on TOP (solid shape): 124.32,205.11 125.92,205.11 126.02,205.01 126.02,203.36 125.76,203.11 123.98,203.11 123.86,203.23 123.86,205.01 123.98,205.14 124.32,205.14
+5VSB on TOP (solid shape): 87.66,58.33 87.66,56.04 86.77,55.15 86.77,52.99 86.39,52.61 85.25,52.61 84.87,52.99 84.87,54.64 85.25,55.02 85.25,56.29 85.76,56.8 85.76,58.33 86.01,58.58 87.41,58.58
+5VSB on TOP (solid shape): 83.22,53.5 83.22,52.48 83.09,52.36 82.2,52.36 81.57,51.72 81.57,50.83 81.44,50.71 80.8,50.71 80.42,51.09 80.42,53.37 80.68,53.63 83.09,53.63
+5VSB on TOP (solid shape): 142.4,25.94 143.67,25.94 143.92,25.69 143.92,24.16 142.78,23.02 139.86,23.02 139.48,22.64 139.48,21.37 138.97,20.86 138.08,20.86 137.19,19.97 136.43,19.97 136.18,20.23 136.18,21.24 137.45,22.51 137.45,23.65 137.83,24.04 137.83,25.18 138.21,25.56 138.84,25.56 139.48,24.92 140.88,24.92 141.13,25.18 141.13,25.94 141.38,26.19 142.15,26.19
+12V on TOP (solid shape): 127.41,193.83 127.41,190.41 126.6,189.6 121.49,189.6 121.32,189.77 121.32,194.6 121.57,194.85 126.4,194.85
+12V on TOP (solid shape): 95.41,113.21 95.41,111.34 95.05,110.98 95.05,109.51 90.74,105.19 87.79,105.19 87.36,105.62 87.36,108.74 88.53,109.91 91.35,109.91 94.8,113.37 95.26,113.37
+12V on TOP (solid shape): 113.9,15.4 124.24,15.4 124.62,15.02 124.62,10.95 123.48,9.81 109.02,9.81 107.91,10.93 107.91,15.15 108.16,15.4 112.71,15.4 112.96,15.65 113.65,15.65
+12V on TOP (solid shape): 85.76,33.81 85.76,31.15 88.55,28.35 88.55,26.32 88.3,26.07 86.52,26.07 85.76,25.31 85.76,24.16 84.67,23.07 82.15,23.07 81.95,23.27 81.95,33.94 82.46,34.45 85.12,34.45
+12V on TOP (solid shape): outline of 93 points within 234.47,93 238.67,109.63
+12V on TOP (solid shape): outline of 144 points within 92.11,9.94 102.27,19.21
+12V on TOP (solid shape): outline of 186 points within 88.3,60.1 93.38,74.45
+12V on TOP (solid shape): outline of 1004 points within 16.67,190.2 89.82,204.88
+12V on BOTTOM (solid shape): 101.95,19.08 101.95,17.88 101.76,17.69 92.87,17.69 92.74,17.81 92.74,19.08 92.87,19.21 101.82,19.21
+12V on BOTTOM (solid shape): 102.14,16.29 102.14,15.59 101.7,15.15 92.87,15.15 92.74,15.27 92.74,16.54 92.87,16.67 101.76,16.67
+12V on BOTTOM (solid shape): 85.76,33.81 85.76,31.15 88.55,28.35 88.55,26.32 88.3,26.07 86.52,26.07 85.76,25.31 85.76,24.16 84.67,23.07 82.15,23.07 81.95,23.27 81.95,33.94 82.46,34.45 85.12,34.45
+12V on PWR (solid shape): outline of 9396 points within 40.98,9.86 144.38,204.96
+12V_4P on TOP (solid shape): 238.22,197.96 238.22,193.77 237.65,193.2 230.54,193.2 228.76,191.42 222.79,191.42 222.41,191.8 222.41,198.66 222.79,199.04 237.14,199.04
+12V_4P on BOTTOM (solid shape): 238.16,198.03 238.16,193.71 237.65,193.2 230.54,193.2 228.89,191.55 222.66,191.55 222.41,191.8 222.41,198.53 222.92,199.04 237.14,199.04
+12V_4P on PWR (solid shape): 238.16,197.99 238.16,193.61 237.75,193.2 230.51,193.2 228.73,191.42 222.82,191.42 222.41,191.83 222.41,198.63 222.82,199.04 237.11,199.04
+12VIN on TOP (solid shape): outline of 260 points within 53.63,19.84 81.19,39.53
+12VIN on BOTTOM (solid shape): 68.36,30.51 68.36,28.1 68.1,27.85 64.8,27.85 63.79,28.86 63.79,30.51 64.04,30.77 68.1,30.77
+12VIN on BOTTOM (solid shape): 75.47,22.89 75.47,21.75 75.22,21.5 71.15,21.5 70.9,21.75 70.9,24.16 71.15,24.42 73.95,24.42
+12VIN on BOTTOM (solid shape): 81.19,29.75 81.19,23.53 80.93,23.27 80.17,23.27 76.49,26.96 76.49,29.62 77.12,30.26 80.68,30.26
+12VIN on BOTTOM (solid shape): 75.6,35.47 75.6,31.91 75.34,31.66 71.28,31.66 70.26,32.67 65.06,32.67 64.42,33.31 64.42,34.58 65.18,35.34 70.9,35.34 70.91,35.35 71.67,35.35 72.04,35.72 75.34,35.72
+12VIN on PWR (solid shape): outline of 267 points within 54.01,21.24 81.19,39.53
+VCC on TOP (solid shape): 11.23,135.44 11.23,134.12 11.11,133.99 9.71,133.99 9.3,134.4 9.3,135.39 9.51,135.59 11.08,135.59
+VCC on TOP (solid shape): 151.54,6.89 151.54,4.35 151.05,3.86 145.17,3.86 144.81,4.22 144.81,6.76 145.32,7.27 151.16,7.27
+VCC on TOP (solid shape): 142.48,211.31 142.48,210.8 142.37,210.7 141.89,210.7 141.79,210.6 141.79,209.3 140.62,209.3 140.49,209.43 140.49,211.06 140.85,211.41 142.37,211.41
+VCC on TOP (solid shape): 10.85,126.19 10.85,124.82 11.03,124.64 11.72,124.64 11.84,124.52 11.84,122.44 11.72,122.31 9.07,122.31 8.95,122.44 8.95,124.87 10.29,126.22 10.83,126.22
+VCC on TOP (solid shape): 205.26,212.25 205.26,212 205.65,211.61 206.03,211.61 206.15,211.49 206.15,210.34 206.03,210.22 204.38,210.22 204.25,210.34 204.25,212.25 204.38,212.38 205.14,212.38
+VCC on TOP (solid shape): 14.36,106.13 14.36,104.63 14.71,104.27 14.71,103.54 14.59,103.41 12.88,103.41 12.76,103.54 12.76,105.09 12.35,105.49 12.35,106.1 12.38,106.13 12.38,106.15 12.45,106.23 14.26,106.23
+VCC on TOP (solid shape): 8.2,34.55 9.71,34.55 9.81,34.45 9.81,33.94 9.71,33.84 8.2,33.84 8.2,33.81 8.16,33.81 7.91,33.56 7.91,32.8 7.53,32.42 6.32,32.42 5.87,32.86 5.87,34.32 6.13,34.58 8.2,34.58
+VCC on TOP (solid shape): 105.06,23.3 105.06,19.84 104.81,19.59 102.78,19.59 102.52,19.84 93.2,19.84 92.82,20.23 92.82,23.22 93.12,23.53 104.83,23.53
+VCC on TOP (solid shape): 118.55,207.68 118.55,206.64 118.78,206.41 118.79,206.41 118.82,206.38 120.33,206.38 120.43,206.28 120.43,205.77 120.33,205.67 118.82,205.67 118.79,205.65 118.78,205.65 118.4,205.26 116.49,205.26 116.31,205.44 116.31,207.68 116.44,207.8 118.42,207.8
+VCC on TOP (solid shape): 102.27,9.05 102.27,7.34 103.73,5.87 106.52,5.87 106.78,5.62 106.78,4.99 105.76,3.97 89.19,3.97 88.17,4.99 88.17,5.62 88.3,5.75 89.06,5.75 89.31,6 92.11,6 92.74,6.64 92.74,9.05 93.12,9.43 101.89,9.43
+VCC on TOP (solid shape): 179.46,205.52 179.46,202.5 179.18,202.22 176.56,202.22 175.99,202.79 175.99,204.15 175.72,204.41 175.72,205.72 175.98,205.98 176.61,205.98 176.92,206.28 178.7,206.28
+VCC on TOP (solid shape): 71.41,15.4 71.41,14.38 69.76,12.73 69.76,5.62 69.37,5.24 62.14,5.24 61.44,5.94 61.44,7.91 61.69,8.16 62.14,8.16 63.53,6.76 63.91,6.76 64.29,7.14 64.29,7.53 63.15,8.67 63.15,10.07 63.41,10.32 63.41,11.08 67.98,15.65 71.15,15.65
+VCC on TOP (solid shape): outline of 234 points within 112.81,5.24 126.02,9.43
+VCC on TOP (solid shape): outline of 1944 points within 15.65,116.11 45.69,134.42
+VCC on BOTTOM (solid shape): 151.16,6 151.16,4.1 150.91,3.84 145.07,3.84 144.69,4.22 144.69,6.13 144.94,6.38 150.78,6.38
+VCC on BOTTOM (solid shape): 67.72,9.81 67.72,5.87 67.22,5.37 64.55,5.37 63.15,6.76 63.15,9.68 63.66,10.19 67.34,10.19
+VCC on PWR (solid shape): outline of 39201 points within 0.51,0.51 243.49,224.64
+VCC3 on TOP (solid shape): 63.41,70.39 63.41,66.58 63.15,66.33 61.63,66.33 61.5,66.45 61.5,70.39 61.63,70.52 63.28,70.52
+VCC3 on TOP (solid shape): 42.4,64.04 42.4,62.77 41.94,62.31 40.44,62.31 40.32,62.44 40.32,62.97 40.39,63.05 40.82,63.05 40.9,63.13 40.9,64.07 40.98,64.14 42.3,64.14
+VCC3 on TOP (solid shape): 229.39,209.46 229.39,205.52 229.01,205.14 224.57,205.14 224.31,205.39 224.31,206.15 225.2,207.04 225.2,209.58 225.46,209.84 229.01,209.84
+VCC3 on TOP (solid shape): 15.85,217.64 15.85,216.13 15.78,216.06 15.02,216.06 14.51,215.55 14.51,213.01 14.13,212.63 12.61,212.63 12.48,212.76 12.48,213.9 12.73,214.15 13.11,214.15 13.24,214.28 13.24,216.31 14.64,217.71 15.78,217.71
+VCC3 on TOP (solid shape): 29.75,86.47 29.75,85.94 29.66,85.85 29.2,85.85 28.99,85.63 28.99,83.78 29.14,83.62 29.67,83.62 29.75,83.55 29.75,83.14 29.6,82.99 28.33,82.99 27.97,83.34 27.34,83.34 27.21,83.47 27.21,85.25 27.34,85.38 27.97,85.38 29.14,86.54 29.67,86.54
+VCC3 on TOP (solid shape): 97.82,108.13 97.82,107.47 97.31,106.97 97.06,106.97 96.81,106.71 96.81,105.82 95.92,104.93 95.92,101.38 94.65,100.11 94.65,98.84 94.27,98.46 89.95,98.46 89.44,97.95 89.44,90.2 87.54,88.3 87.54,87.54 86.77,86.77 85.63,86.77 85.25,87.15 85.25,89.06 86.27,90.08 87.28,90.08 87.54,90.33 87.54,94.27 87.41,94.39 87.41,99.85 87.79,100.24 91.09,100.24 91.6,100.74 92.87,100.74 93.76,101.63 93.76,103.41 93.73,103.44 93.73,105.8 96.55,108.62 97.34,108.62
+VCC3 on TOP (solid shape): 25.86,94.7 26.85,94.7 26.98,94.57 26.98,93.76 27.26,93.48 29.39,93.48 29.47,93.4 29.47,90.91 29.32,90.76 28.79,90.76 28.65,90.9 28.65,91.39 28.63,91.44 28.64,91.49 28.41,92.08 27.84,91.81 27.83,91.78 25.74,91.78 25.58,91.93 25.58,93.71 25.41,93.89 25.41,94.57 25.56,94.72 25.84,94.72
+VCC3 on TOP (solid shape): outline of 102 points within 38.77,42.58 61.75,55.79
+VCC3 on TOP (solid shape): 62.09,193.15 62.18,193.09 62.17,192.98 62.37,191.97 63.31,192.39 63.38,192.46 63.48,192.44 63.58,192.34 64.14,192.34 64.26,192.22 64.29,192.14 64.26,192.07 64.03,191.46 64.42,190.95 64.42,190.68 63.56,189.82 60.61,189.82 60.51,189.89 60.55,190.01 60.18,191.22 59.82,190.01 59.86,189.89 59.76,189.82 59.6,189.82 58.91,190.51 58.91,192.13 59.35,192.57 59.46,192.6 59.52,192.51 60.43,191.94 60.69,192.98 60.68,193.09 60.77,193.15
+VCC3 on TOP (solid shape): outline of 119 points within 29.62,101.2 43.11,115.35
+VCC3 on TOP (solid shape): outline of 409 points within 99.73,37.12 103.03,71.15
+VCC3 on BOTTOM (solid shape): 61.75,55.02 61.75,52.04 61.31,51.59 60.36,51.59 57.44,48.67 55.15,48.67 54.64,49.18 54.64,52.66 57.51,55.53 61.25,55.53
+VCC3 on BOTTOM (solid shape): 38.13,106.46 39.02,106.46 39.15,106.33 39.15,105.32 39.53,104.94 39.53,104.93 39.61,104.81 39.73,104.73 39.74,104.73 39.78,104.68 40.16,104.68 40.29,104.55 40.29,104.17 40.04,103.92 39.06,103.92 39.04,103.93 38.85,103.99 38.66,103.95 38.63,103.93 36.74,105.82 36.74,106.84 36.91,107.02 37.57,107.02
+VCC3 on PWR (solid shape): 106.03,105.88 106.03,104.23 106.38,103.87 107.73,103.87 107.93,103.66 107.93,103.08 105.52,103.08 105.24,103.36 105.24,105.26 103.87,106.64 100.16,106.64 99.88,106.35 99.79,106.32 99.71,106.38 99.11,106.54 99.06,105.92 98.26,105.11 97.52,105.11 97.43,105.16 97.42,105.26 97.06,105.85 96.7,105.26 96.69,105.16 96.61,105.11 95.72,105.11 95.23,104.63 95.23,103.36 94.83,102.95 93.68,102.95 93.68,105.75 94.85,106.92 97.9,106.92 98.28,107.3 104.61,107.3
+VCC3 on PWR (solid shape): outline of 5876 points within 191.07,10.5 238.36,37.57
+VCC3 on PWR (solid shape): outline of 31367 points within 13.67,38.69 94.83,193.15
+VCC_VGA_S on TOP (solid shape): 174.78,205.39 174.78,203.11 174.4,202.72 167.93,202.72 167.67,202.98 167.67,204.38 167.8,204.5 170.21,204.5 170.59,204.88 170.59,205.65 170.85,205.9 174.28,205.9
+VDD33 on TOP (solid shape): 24.48,204.35 27.41,204.35 27.92,203.84 27.92,202.93 27.44,202.45 25.13,202.45 24.92,202.65 24.92,202.66 23.97,202.66 22.7,203.93 22.7,204.63 22.96,204.88 23.95,204.88
+VDD33 on TOP (solid shape): 55,225.28 55,224.44 55.01,224.43 55.01,224.27 54.84,223.93 55.01,223.6 55.01,223.57 55.15,223.43 55.15,221.9 55.53,221.52 55.53,219.49 55.4,219.36 53.37,219.36 53.25,219.49 53.25,221.14 53.37,221.27 53.88,221.27 54.13,221.52 54.13,222.66 54.42,222.95 54.42,224.14 54.69,224.41 54.69,225.27 54.8,225.38 54.89,225.38
+VDD33 on BOTTOM (solid shape): outline of 602 points within 42.58,218.35 58.96,233.71
+VIN on TOP (solid shape): outline of 240 points within 137.45,176.94 221.65,198.53
+VIN on BOTTOM (solid shape): 212,193.96 212,193.33 211.74,193.07 190.6,193.07 190.34,193.33 190.34,194.09 190.6,194.34 211.61,194.34
+VIN on BOTTOM (solid shape): 221.65,198.03 221.65,194.09 221.01,193.45 218.22,193.45 215.04,196.63 215.04,197.64 215.93,198.53 221.14,198.53
+VIN on BOTTOM (solid shape): 187.42,194.09 187.42,192.95 187.1,192.63 183.61,192.63 183.29,192.95 175.04,192.95 174.78,193.2 174.78,194.09 175.04,194.34 187.17,194.34
+VIN on BOTTOM (solid shape): 172.12,194.09 172.12,192.82 171.93,192.63 168.24,192.63 167.99,192.88 161.89,192.88 161.45,193.33 161.45,193.71 162.08,194.34 171.86,194.34
+VIN on BOTTOM (solid shape): 155.86,196.25 155.86,194.66 151.04,189.83 145.7,189.83 144.5,188.63 137.95,188.63 137.57,189.01 137.57,191.74 141.83,195.99 142.84,195.99 143.8,196.95 155.16,196.95
+VIN on PWR (solid shape): outline of 234 points within 137.45,176.94 221.65,198.53
GND on TOP (solid shape): 12.91,20.15 12.91,17.38 12.58,17.05 11.51,17.05 11.31,17.25 11.31,20.45 11.61,20.76 12.3,20.76
GND on TOP (solid shape): 45.31,54.71 45.31,54.01 45.12,53.82 42.51,53.82 42.26,54.07 42.26,54.52 42.64,54.9 45.12,54.9
GND on TOP (solid shape): 47.48,46.44 47.48,45.65 47.33,45.5 43.97,45.5 42.91,46.57 42.91,47.63 43.03,47.76 46.16,47.76
GND on TOP (solid shape): 54.52,34.83 54.52,32.29 54.39,32.16 51.85,32.16 51.72,32.29 51.72,34.83 51.85,34.96 54.39,34.96
GND on TOP (solid shape): 55.28,232.82 55.28,225.71 55.15,225.58 48.04,225.58 47.91,225.71 47.91,232.82 48.04,232.95 55.15,232.95
GND on TOP (solid shape): 73.44,216.42 73.44,213.62 73.18,213.37 70.52,213.37 70.26,213.62 70.26,216.42 70.52,216.67 73.18,216.67
GND on TOP (solid shape): 119.92,210.98 119.92,209.84 119.79,209.71 117.76,209.71 117.51,209.96 117.51,210.9 117.71,211.11 119.79,211.11
GND on TOP (solid shape): 123.48,208.19 123.48,205.14 123.1,204.76 121.44,204.76 121.06,205.14 121.06,207.93 121.57,208.44 123.22,208.44
GND on TOP (solid shape): 126.27,22.89 126.27,22.26 126.14,22.13 122.84,22.13 122.71,22.26 122.71,23.91 123.1,24.29 124.87,24.29
GND on TOP (solid shape): 154.34,182.79 154.34,179.61 154.08,179.36 151.92,179.36 151.54,179.74 151.54,182.91 151.67,183.04 154.08,183.04
GND on TOP (solid shape): 170.59,185.58 170.59,184.56 169.83,183.8 167.67,183.8 165.39,186.09 165.39,187.23 165.51,187.36 168.82,187.36
GND on TOP (solid shape): 171.48,9.68 171.48,6.64 171.1,6.26 168.43,6.26 167.93,6.76 167.93,9.3 168.56,9.94 171.23,9.94
GND on TOP (solid shape): 174.9,185.05 174.9,179.72 174.66,179.48 172.24,179.48 171.99,179.74 171.99,185.2 172.37,185.58 174.37,185.58
GND on TOP (solid shape): 207.04,242.98 207.04,231.81 206.79,231.55 202.22,231.55 201.71,232.06 201.71,243.11 202.09,243.49 206.53,243.49
GND on TOP (solid shape): 230.28,152.18 230.28,148.88 230.16,148.75 226.85,148.75 226.73,148.88 226.73,152.18 226.85,152.31 230.16,152.31
GND on TOP (solid shape): 205.32,223.12 205.32,221.32 205.14,221.14 202.32,221.14 202.17,221.29 202.17,223.12 202.34,223.3 205.14,223.3
GND on TOP (solid shape): 107.6,212.88 107.6,211.87 107.47,211.74 106.59,211.74 105.87,212.45 105.87,212.86 106.28,213.27 107.22,213.27
GND on TOP (solid shape): 200.97,223.02 200.97,221.29 200.82,221.14 197.9,221.14 197.77,221.27 197.77,223.04 198.03,223.3 200.69,223.3
GND on TOP (solid shape): 228,168.18 228,165.41 227.21,164.62 225.41,164.62 224.97,165.06 224.97,168.14 225.14,168.31 227.87,168.31
GND on TOP (solid shape): 12.87,15.85 13.3,15.85 13.56,15.59 13.56,15.21 13.11,14.76 13.11,13.27 12.81,12.96 11.69,12.96 11.41,13.24 11.41,15.86 12.86,15.86
GND on TOP (solid shape): 47.33,19.92 47.33,16.34 47.15,16.16 44.86,16.16 44.36,16.67 44.36,19.84 44.62,20.1 47.14,20.1
GND on TOP (solid shape): 172.88,35.59 172.88,32.93 172.37,32.42 169.32,32.42 169.2,32.54 169.2,33.81 169.7,34.32 169.7,35.72 169.96,35.97 172.5,35.97
GND on TOP (solid shape): 189.39,185.33 189.39,183.04 189.14,182.79 187.87,182.79 186.6,184.06 183.83,184.06 183.52,184.36 183.52,185.45 183.65,185.58 189.14,185.58
GND on TOP (solid shape): 102.27,34.32 102.27,31.91 102.14,31.78 101.12,31.78 100.87,31.53 100.87,30.39 100.74,30.26 99.09,30.26 97.06,32.29 97.06,35.85 98.08,36.86 99.73,36.86
GND on TOP (solid shape): 149,183.93 149,183.74 147.99,182.72 147.8,182.72 147.73,182.79 147.73,183.29 147.54,183.48 146.4,183.48 146.34,183.55 146.34,184.31 146.4,184.37 148.56,184.37
GND on TOP (solid shape): 180.75,9.68 180.75,8.8 181.77,7.78 181.77,6.64 181.26,6.13 177.96,6.13 177.45,6.64 177.45,9.56 177.83,9.94 180.5,9.94
GND on TOP (solid shape): 85.5,68.87 85.5,67.85 85.25,67.6 83.52,67.6 82.38,66.45 81.19,66.45 80.93,66.71 80.93,67.09 81.57,67.72 81.57,68.99 81.82,69.25 85.12,69.25
GND on TOP (solid shape): 121.62,188.76 121.62,187.94 121.83,187.74 123.48,187.74 123.6,187.61 123.6,185.71 123.48,185.58 120.56,185.58 120.3,185.83 120.3,188.75 120.48,188.93 121.44,188.93
GND on TOP (solid shape): 138.08,12.86 138.08,5.87 137.45,5.24 131.33,5.24 130.89,5.67 130.89,13.01 131.5,13.62 137.32,13.62
GND on TOP (solid shape): 74.2,15.4 74.2,14 71.41,11.21 71.41,6.26 71.15,6 70.14,6 70.01,6.13 70.01,12.35 71.79,14.13 71.79,15.4 72.04,15.65 73.95,15.65
GND on TOP (solid shape): 104.43,86.65 104.43,81.69 101.51,78.77 96.43,78.77 95.54,79.66 95.54,81.44 95.92,81.82 101.38,81.82 101.89,82.33 101.89,85.5 103.41,87.03 104.05,87.03
GND on TOP (solid shape): 147.48,28.99 147.99,28.99 148.11,28.86 148.11,27.91 147.99,27.78 144.62,27.78 143.8,28.61 143.8,28.99 144.05,29.24 147.23,29.24
GND on TOP (solid shape): 150.27,188.75 150.27,187.23 150.08,187.04 149.58,187.04 149.32,187.29 149.32,188.18 149.13,188.37 148.11,188.37 147.73,187.99 145.83,187.99 145.7,188.12 145.7,188.88 145.83,189.01 150.02,189.01
GND on TOP (solid shape): 155.73,9.81 155.73,8.67 154.59,7.53 154.34,7.53 153.45,8.41 152.94,8.41 152.69,8.67 152.69,9.81 152.81,9.94 155.61,9.94
GND on TOP (solid shape): 13.11,36.86 13.11,33.56 12.1,32.54 8.41,32.54 8.16,32.8 8.16,33.05 8.29,33.18 9.94,33.18 10.19,33.43 10.19,36.86 10.32,36.99 12.99,36.99
GND on TOP (solid shape): 37.75,108.36 37.75,108.32 37.74,108.3 37.74,107.46 37.62,107.35 37.5,107.35 37.06,106.91 36.25,106.91 36.08,107.09 36.08,107.09 35.97,107.2 35.97,109.63 36.04,109.7 36.42,109.7
GND on TOP (solid shape): 70.39,140.62 71.41,140.62 71.66,140.37 73.31,140.37 73.57,140.11 73.57,139.1 74.96,137.7 74.96,136.81 74.71,136.56 72.55,136.56 70.26,138.84 69.63,138.84 69.25,139.22 69.25,140.75 69.37,140.88 70.14,140.88
GND on TOP (solid shape): 201.2,243.11 201.2,232.32 200.69,231.81 199.8,231.81 199.3,232.32 199.3,234.47 198.41,235.36 185.07,235.36 184.82,235.11 184.82,232.19 184.56,231.93 180.75,231.93 180.12,232.57 180.12,243.11 180.5,243.49 200.82,243.49
GND on TOP (solid shape): 74.96,54.39 76.11,54.39 76.23,54.26 76.23,48.93 76.11,48.8 75.6,48.8 75.47,48.93 75.47,50.2 74.96,50.71 73.82,50.71 73.62,50.91 73.62,54.44 73.69,54.52 74.84,54.52
GND on TOP (solid shape): 76.61,44.86 76.61,42.83 76.87,42.58 76.87,40.67 76.49,40.29 71.2,40.29 70.8,40.7 70.8,41.03 71.46,41.69 72.91,41.69 73.62,42.4 73.62,46.06 73.82,46.26 75.22,46.26
GND on TOP (solid shape): 164.37,35.21 164.37,33.94 164.46,33.85 166.06,33.85 166.15,33.76 166.15,33.28 166,33.13 165.08,33.13 164.37,32.42 161.2,32.42 161.07,32.54 161.07,35.21 161.32,35.47 164.12,35.47
GND on TOP (solid shape): 238.16,192.06 238.16,183.04 237.01,181.9 217.84,181.9 217.46,182.28 217.46,186.09 217.71,186.34 221.52,186.34 222.41,187.23 222.41,190.28 222.79,190.66 229.01,190.66 230.79,192.44 237.78,192.44
GND on TOP (solid shape): 44.36,105.9 44.89,105.9 45.08,106.1 45.08,106.3 45.23,106.44 45.52,106.44 46.33,105.63 46.33,105.53 46.09,105.29 45.44,105.29 45.36,105.36 44.9,105.36 44.83,105.29 44.38,105.29 43.49,106.17 43.49,106.31 43.68,106.51 43.76,106.51
GND on TOP (solid shape): 76.87,72.55 76.87,70.14 76.49,69.76 70.01,69.76 69.76,69.5 64.55,69.5 64.29,69.76 64.29,70.42 66.56,72.68 76.74,72.68
GND on TOP (solid shape): 152.38,176.28 152.38,175.44 152.69,175.14 153.4,175.14 153.7,174.84 153.7,174.66 154.32,174.04 154.32,170.17 154.24,170.09 151.54,170.09 151.42,170.21 151.42,176.28 151.54,176.41 152.25,176.41
GND on TOP (solid shape): 164.12,8.67 164.12,6.76 163.74,6.38 162.21,6.38 161.83,6.76 161.83,7.4 161.2,8.03 160.18,8.03 159.8,8.41 159.8,9.68 160.05,9.94 162.85,9.94
GND on TOP (solid shape): 79.79,210.34 79.79,209.33 80.3,208.82 80.3,208.06 80.04,207.8 76.36,207.8 76.23,207.68 76.23,206.92 76.11,206.79 75.6,206.79 75.47,206.92 75.47,208.69 75.6,208.82 76.11,208.82 76.34,209.06 76.34,209.98 76.83,210.47 79.66,210.47
GND on TOP (solid shape): 173.01,175.67 173.26,175.67 173.31,175.62 173.74,175.62 173.9,175.47 173.9,175.04 174.91,174.02 174.91,170.09 174.78,169.96 172.63,169.96 171.86,170.72 171.86,174.02 171.23,174.66 171.23,175.8 171.42,175.99 172.69,175.99
GND on TOP (solid shape): 66.01,108.05 66.01,105.51 65.95,105.44 65.95,105.19 66.33,104.81 69.63,104.81 69.76,104.68 69.76,101.51 69.37,101.12 68.36,101.12 68.1,101.38 68.1,101.41 65.96,103.55 65.95,103.54 65.69,103.79 63.66,103.79 63.53,103.92 63.53,107.22 64.55,108.24 65.82,108.24
GND on TOP (solid shape): 103,204.17 103,203.26 102.72,202.98 100.36,202.98 100.24,202.85 100.24,201.58 99.98,201.33 97.95,201.33 97.82,201.45 97.82,201.96 97.95,202.09 98.84,202.09 98.97,202.22 98.97,203.49 99.09,203.61 100.87,203.61 101.76,204.5 102.67,204.5
GND on TOP (solid shape): 44.99,14.13 44.99,13.24 45.24,12.99 46.39,12.99 46.51,12.86 46.51,12.61 47.35,11.77 47.35,8.24 47.15,8.03 46.26,8.03 46.01,8.29 46.01,8.8 44.48,10.32 44.48,12.61 44.23,12.86 44.23,14.13 44.36,14.26 44.86,14.26
GND on TOP (solid shape): 179.61,242.73 179.61,236.32 179.23,235.94 176.82,235.94 175.67,237.08 175.67,240.57 174.59,241.65 152.05,241.65 151.29,240.89 151.29,235.62 150.78,235.11 143.03,235.11 142.02,236.13 142.02,243.11 142.4,243.49 178.85,243.49
GND on TOP (solid shape): 225.46,242.6 225.46,232.06 225.08,231.68 224.06,231.68 223.55,232.19 223.55,235.24 223.24,235.55 209.52,235.55 209.33,235.36 209.33,231.93 209.07,231.68 208.06,231.68 207.55,232.19 207.55,242.98 208.06,243.49 224.57,243.49
GND on TOP (solid shape): 226.6,176.18 226.6,175.8 226.85,175.55 227.62,175.55 228.63,174.53 228.63,171.1 228.51,170.97 227.87,170.97 227.79,171.05 227.79,171.89 227.72,171.97 226.58,171.97 226.35,172.19 226.35,172.37 225.97,172.75 225.2,172.75 224.96,172.99 224.96,176.47 225.05,176.56 226.22,176.56
GND on TOP (solid shape): 243.44,240.75 243.44,225.38 242.93,224.87 240.21,224.87 239.43,225.66 239.43,237.4 238.92,237.9 229.65,237.9 229.14,237.4 229.14,227.87 228.76,227.49 226.35,227.49 225.97,227.87 225.97,242.98 226.47,243.49 240.7,243.49
GND on TOP (solid shape): 100.49,219.49 100.49,217.84 100.36,217.71 98.2,217.71 97.19,216.69 91.6,216.69 91.35,216.95 91.35,218.5 91.36,218.52 91.48,218.66 91.52,218.83 91.93,219.23 93.5,219.23 93.89,218.85 98.84,218.85 99.6,219.61 100.36,219.61
GND on TOP (solid shape): 101.86,28.68 101.86,26.78 102.06,26.58 104.93,26.58 105.19,26.32 105.19,24.09 104.88,23.78 94.77,23.78 94.52,24.04 94.52,26.07 95.03,26.58 100.95,26.58 101.15,26.78 101.15,28.68 101.23,28.76 101.78,28.76
GND on TOP (solid shape): 97.95,58.96 97.95,58.33 97.57,57.94 97.57,56.17 97.44,56.04 96.55,56.04 96.17,55.66 94.14,55.66 93.76,56.04 88.04,56.04 87.92,56.17 87.92,57.44 88.04,57.56 95.28,57.56 95.54,57.82 95.54,58.33 95.66,58.45 96.68,58.45 97.31,59.09 97.82,59.09
GND on TOP (solid shape): 135.24,183.24 135.24,179.43 135.16,179.36 133.89,179.36 133.64,179.1 133.64,176.64 133.46,176.46 133.46,175.57 133.47,175.56 133.47,175.38 134.18,174.67 134.89,174.67 135.24,174.33 135.24,170.14 135.06,169.96 133.64,169.96 132.37,171.23 132.37,183.17 132.62,183.42 135.06,183.42
GND on TOP (solid shape): 79.97,64.88 79.97,62.44 79.66,62.14 79.28,62.14 79.08,61.93 79.08,61.25 79.03,61.25 78.9,61.12 78.52,61.12 77.5,62.14 77.5,62.64 77.63,62.77 77.63,62.82 78.44,62.82 78.57,62.95 78.57,63.86 78.42,64.02 77.6,64.02 77.55,64.07 77.55,64.27 77.58,64.29 78.37,64.29 78.54,64.47 78.54,64.93 78.67,65.06 79.79,65.06
GND on TOP (solid shape): 65.31,161.2 67.47,161.2 67.72,160.94 67.72,160.05 67.34,159.67 65.06,159.67 64.55,160.18 62.77,160.18 62.07,159.48 62.07,158.47 60.99,157.39 58.33,157.39 57.82,157.89 57.82,159.93 58.58,160.69 62.01,160.69 62.14,160.81 62.14,161.45 62.52,161.83 64.68,161.83
