# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_G22: length 18.4
  TOP w0.102: v3(53.22,96.81) 53.22,96.69 PCH1.G22 ; v2(68.49,98.84) 68.49,98.55 R131.2
  BOTTOM w0.102: v2(68.49,98.84) 68.2,98.55 57.91,98.55 v1(57.31,97.95) 56.98,97.62 54.44,97.62 54.09,97.26 53.68,97.26 v3(53.22,96.81)
PCH_GPIO0: length 13.1
  TOP w0.089: 53.88,85.24 53.88,85.5 53.76,85.62 53.76,86.27 53.9,86.41
  TOP w0.102: PCH1.G38 53.74,87.8 53.74,87.66 53.96,87.44 53.96,86.47 53.9,86.41 ; 53.88,85.24 53.88,84.82 55.74,82.96 R193.1
PCH_GPIO1: length 48.6
  TOP w0.102: v2(21.05,71.66) 21.59,71.66 C225.1 21.59,71.15 19.99,71.15 18.35,69.51 15.41,69.51 14.38,68.49 OBR.1 ; v2(32.5,88.6) 32.2,88.3 31.53,88.3 31.07,87.84 28.46,87.84 27.99,87.38 R180.1 25.53,87.38 v2(24.42,86.27) ; PCH1.AT31 38.85,91.26 v3(38.89,91.22)
  BOTTOM w0.102: v2(24.42,86.27) 23.02,86.27 22.38,85.63 22.38,83.41 21.05,82.07 v2(21.05,71.66) ; v3(38.89,91.22) 37.12,91.22 36,90.1 35.74,90.1 32.04,86.39 31.66,86.39 31.15,86.9 31.15,87.24 v2(32.5,88.6)
PCH_GPIO2: length 15
  TOP w0.102: PCH1.AR30 38.45,91.84 38.17,92.12 36.61,92.12 36.54,92.19 33.9,92.19 31.22,89.52 28.68,89.52 28.2,90 26.45,90 25.9,90.55 RN12.1
PCH_GPIO4: length 11.4
  TOP w0.102: PCH1.AV28 36.78,93.1 36.51,92.82 33.61,92.82 31.04,90.25 28.91,90.25 28.48,90.69 27.69,90.69 27.55,90.82 RN12.7
PCH_GPIO5: length 8.8
  TOP w0.102: RN11.3 31.67,91.55 33.5,93.38 36.52,93.38 36.57,93.33 37,93.33 37.21,93.43 37.57,93.43 37.88,93.5 PCH1.AT27
PCH_GPIO8: length 366.6
  TOP w0.089: 45.5,85.46 45.49,85.47 45.49,85.76 45.57,85.83 45.57,86.15 45.38,86.34
  TOP w0.102: R245.1 235.74,111.46 235.06,110.78 230.74,110.78 230.49,110.52 224.19,110.52 223.81,110.9 222.97,110.9 v2(222.65,110.58) ; 45.38,86.34 45.29,86.42 PCH1.AC40 ; v2(81.49,46.77) 81.1,46.77 79.33,48.54 79.33,57.35 76.93,59.75 74.18,59.75 72.88,61.04 66.53,61.04 65.72,61.86 60.41,61.86 59.8,61.25 52.31,61.25 48.94,57.88 43.85,57.88 43.25,58.48 41.9,58.48 39.88,60.49 39.88,65.49 41.31,66.91 41.31,75.77 R203.1 41.94,77.45 42.4,77.91 45.19,77.91 45.5,78.21 45.5,85.46
  BOTTOM w0.102: v2(81.49,46.77) 82.33,45.93 82.33,41.43 90.38,33.38 90.38,31.87 93.51,28.73 111.26,28.73 112.55,27.44 118.75,27.44 120.53,25.66 122.44,25.66 123.17,24.92 124.96,24.92 126.53,23.35 148.4,23.35 151.6,20.15 156.06,20.15 157.21,19.01 166.38,19.01 167.14,19.77 178.14,19.77 179.53,21.17 190.7,21.17 191.51,20.35 193.24,20.35 193.9,19.69 197.7,19.69 198.76,20.76 200.71,20.76 201.8,21.85 205.96,21.85 211.34,27.24 223.68,27.24 225.73,29.28 229.96,29.28 233.53,32.86 233.53,37.74 234.65,38.85 234.65,42.66 235.97,43.98 235.97,50.3 239.48,53.81 239.48,64.22 238.3,65.4 238.3,66.95 236.48,68.76 234.93,68.76 228.48,75.22 228.48,81.71 222.51,87.68 222.51,98.6 218.73,102.39 218.73,107.22 v1(220.73,109.23) 222.09,110.58 v2(222.65,110.58)
PCH_GPIO15: length 218.9
  TOP w0.102: D23.2 93.5,183.17 97.19,183.17 97.62,182.73 97.62,156.13 96.27,154.78 96.27,132.03 94.37,130.12 94.37,115.2 92.11,112.94 90.96,112.94 90.44,113.46 88.06,113.46 84.87,110.27 84.87,91.07 81.44,87.64 77.99,87.64 v2(77.53,88.09) ; v2(65.31,59.85) 65.18,59.72 52.9,59.72 49.66,56.48 43.25,56.48 42.94,56.79 42.64,57.08 41.32,57.08 38.34,60.07 38.34,67.77 R205.1 37.98,68.54 37.98,74.58 38.18,74.78 38.18,79.3 37.98,79.51 37.98,81.03 38.39,81.44 38.9,81.44 39.11,81.65 v3(39.11,82.24) ; v3(44.51,91.14) 44.85,90.81 PCH1.AC32
  BOTTOM w0.102: v3(44.51,91.14) 44.05,90.69 43.49,90.69 42.63,91.55 41.28,91.55 41.04,91.31 41.04,90.84 41.36,90.52 41.36,90.1 41.13,89.87 40.86,89.87 40.6,89.61 40.6,87.04 40.22,86.66 40.22,85.2 38.95,83.93 v1(38.95,83.29) 38.95,82.4 v3(39.11,82.24) ; v2(77.53,88.09) 77.25,87.81 77.25,84.84 74.53,82.13 74.53,76.4 77.25,73.68 77.25,70.52 70.72,63.99 69.07,63.99 65.31,60.23 v2(65.31,59.85)
PCH_GPIO16: length 24.2
  TOP w0.089: 50.72,86.59 50.72,86.39 50.81,86.3 50.81,85.7 50.74,85.63 50.74,85.62
  TOP w0.102: 50.72,86.59 50.72,87.02 PCH1.M39 ; 50.74,85.62 50.74,84.08 51.7,83.12 52.02,83.12 53.55,81.59 53.55,79.52 54.68,78.39 54.68,71.47 v1(55.05,71.1) 56.35,69.8 56.85,69.8 57.43,69.22 R169.1 57.2,68.72 57.2,67.14 R168.1
PCH_GPIO18: length 22.2
  TOP w0.102: PCH1.P39 49.66,86.89 49.83,86.71 49.89,86.65 49.91,86.62 49.91,86.3 49.87,86.26 49.87,83.69 51.63,81.92 51.87,81.92 52.64,81.16 52.64,79.14 53.77,78.01 53.77,69.13 52.61,67.98 R201.1
PCH_GPIO19: length 24.4
  TOP w0.102: R179.1 66.68,77.22 v1(65.59,76.13) 65.34,75.88 R173.1 64.26,75.88 64.04,76.11 64.04,77.3 63.68,77.65 62.24,77.65 61.75,78.14 61.75,79.52 59.84,81.43 57.61,81.43 56.34,80.17 55.28,80.17 54.92,80.53 54.92,82.06 52.66,84.32 52.66,84.82 52.46,85.02 52.46,85.5 52.31,85.65 52.31,86.22 52.22,86.3 PCH1.J40
PCH_GPIO20: length 27.9
  TOP w0.102: PCH1.P37 49.66,87.79 49.97,87.47 49.97,86.98 50.07,86.75 50.09,86.72 50.11,86.67 50.11,86.22 50.07,86.18 50.07,83.81 51.73,82.15 51.98,82.15 52.86,81.26 52.86,79.23 53.99,78.1 53.99,68.98 53.09,68.08 53.09,65.13 52.94,64.98 v2(52.94,64.88) 52.94,64.63 R209.1 R206.1
PCH_GPIO21: length 26.8
  TOP w0.102: R167.1 60.67,67.62 v1(59.77,67.62) 59.05,67.62 58.35,68.32 58.35,70.16 57.79,70.72 56.57,70.72 55.14,72.16 55.14,78.58 54.01,79.71 54.01,81.77 51.99,83.79 51.61,83.79 51.15,84.25 51.15,85.4 51.21,85.46 51.21,86.22 51.33,86.33 51.33,87.72 PCH1.M37
PCH_GPIO24: length 70.3
  TOP w0.102: PCH1.AE34 44.35,90.09 v3(44.58,90.33) ; R208.1 35.24,71.28 v2(35.09,71.12) 34.34,70.37 34.34,68.05 31.39,65.11 25.25,65.11 24.99,65.37 v2(23.91,65.37) ; R997.1 17.08,86.87 20.23,83.73 21.21,83.73 R999.2 21.88,84.36 v2(22.89,85.38)
  BOTTOM w0.102: v2(35.09,71.12) 35.86,71.89 35.86,73.82 35.59,74.08 35.59,74.63 36.4,75.44 37,75.44 41.92,80.36 v1(42.51,80.36) 43.01,80.86 43.01,86.62 43.49,87.1 43.49,88.24 43.97,88.72 43.97,89.3 44.13,89.46 44.13,89.87 v3(44.58,90.33) ; v2(23.91,65.37) 21.75,67.53 21.75,70.01 21.53,70.23 21.53,72.64 21.34,72.83 21.34,81.92 22.89,83.47 v2(22.89,85.38)
PCH_GPIO24_DIS_ME: length 2.4
  TOP w0.102: RJ12.3 22.38,89.77 22.38,88.68 QN35.E
PCH_GPIO25: length 13.9
  TOP w0.089: 45.7,86.34 45.76,86.27 45.76,85.69 45.7,85.63 45.7,85.46
  TOP w0.102: R218.1 42.65,76.84 v1(42.65,77.32) 42.93,77.6 45.21,77.6 45.72,78.12 45.72,84.3 45.7,84.32 45.7,85.46 ; PCH1.AA39 45.96,86.98 45.66,86.68 45.66,86.37 45.7,86.34
PCH_GPIO26: length 23
  TOP w0.102: v2(46.97,76.56) 46.96,76.56 46.46,76.07 46.46,73.2 46.72,72.95 46.72,72.12 48.64,70.2 R219.1 ; v3(46.65,89.03) 47,89.38 PCH1.W35
  BOTTOM w0.102: v3(46.65,89.03) 46.65,88.91 46.24,88.5 46.24,86.9 45.91,86.57 45.91,83.14 45.96,83.09 45.96,79.3 45.69,79.03 v1(45.69,77.24) 46.36,76.56 v2(46.97,76.56)
PCH_GPIO28: length 14.2
  TOP w0.102: PCH1.V41 48.04,85.78 48.04,83.15 47.7,82.81 47.7,78.67 49.13,77.24 49.13,75.53 50.45,74.21 50.45,73.51 R211.1
PCH_GPIO31: length 23.7
  TOP w0.102: R231.1 24.67,78.9 v2(25.56,78.01) ; v3(39.91,89.1) 40.03,89.1 PCH1.AM36
  BOTTOM w0.102: v2(25.56,78.01) 26.3,78.75 30.88,78.75 32.16,80.03 35.22,80.03 36.66,81.46 36.66,82.48 39.43,85.25 v1(39.43,86.37) 39.43,87.5 40.13,88.2 40.13,88.66 39.91,88.87 v3(39.91,89.1)
PCH_GPIO32: length 33.3
  TOP w0.102: v3(49.72,90.41) 50.12,90.81 PCH1.N32 ; R195.1 42.58,68.47 v2(42.58,67.47)
  BOTTOM w0.102: v3(49.72,90.41) 50.29,89.85 50.29,88.34 49.87,87.92 49.87,85.1 v1(50.22,84.74) 50.4,84.56 50.4,84 51.47,82.94 51.47,79.66 52.53,78.59 52.53,74 49.54,71 46.15,71 44.36,69.21 43.68,69.21 42.58,68.1 v2(42.58,67.47)
PCH_GPIO33: length 18.6
  TOP w0.102: PCH1.AV26 36.75,94.33 36.41,94.67 35.75,94.67 35.44,94.98 34.92,94.98 34.08,94.14 32.54,94.14 32.16,93.76 31.01,93.76 R199.1 30,93.76 28.07,93.76 26.9,94.93 24.21,94.93 v2(23.98,94.7) 23.48,94.19 23.48,91.99 R196.1
PCH_GPIO34: length 32.2
  TOP w0.102: R202.1 41.76,68.16 v2(41.94,67.98) ; v3(49.73,89.78) 50.05,90.09 PCH1.N34
  BOTTOM w0.102: v2(41.94,67.98) 41.94,68.74 42.64,69.44 44.27,69.44 46.08,71.25 49.46,71.25 49.56,71.35 49.56,71.35 52.31,74.1 52.31,78.26 51.19,79.38 51.19,81.34 v1(50.86,81.67) 50.65,81.67 49.6,82.72 49.6,83.89 49.38,84.11 49.38,89.43 v3(49.73,89.78)
PCH_GPIO35: length 25.4
  TOP w0.102: PCH1.M40 51.01,86.58 51.01,85.55 50.95,85.48 50.95,84.16 51.65,83.45 51.99,83.45 53.78,81.67 53.78,79.61 54.91,78.48 54.91,72.06 55.65,71.32 56.84,70.14 v1(57.36,70.14) 57.82,69.68 58.02,69.68 58.12,69.58 58.12,68.23 59.64,66.71 R133.1
PCH_GPIO36: length 21.4
  TOP w0.089: 52.74,86.19 52.74,86.18 52.69,86.13 52.69,85.85 52.84,85.7
  TOP w0.102: 52.84,85.7 52.86,85.68 52.86,85.28 53.07,85.08 53.07,84.49 55.33,82.23 55.33,81.89 55.6,81.62 56.04,81.62 56.75,82.33 60.26,82.33 62.65,79.94 64.55,79.94 65.92,81.31 R170.1 65.98,81.12 R174.1 67.52,80.17 v1(67.85,80.5) ; PCH1.H40 52.84,86.76 52.84,86.29 52.74,86.19
PCH_GPIO37: length 21.9
  TOP w0.102: PCH1.N41 50.27,85.92 50.27,83.93 51.8,82.4 52.05,82.4 53.09,81.36 53.09,79.33 54.22,78.2 54.22,68.87 53.75,68.4 R175.1 54.52,67.44 R171.1
PCH_GPIO40: length 113.4
  TOP w0.102: v2(40.55,76.42) 40.29,76.68 40.29,79.79 40.42,79.92 42.07,79.92 42.39,80.23 RN13.8 42.39,82.52 42.93,83.07 42.93,84.51 43.65,85.23 43.65,86.27 43.74,86.36 43.74,87.72 PCH1.AF37 ; v2(8.21,99.04) 9.39,100.22 9.39,100.83 11.72,103.16 14.76,103.16 15.91,104.3 16.45,104.3 16.8,104.65 16.8,105.7 16.54,105.95 RJ3.3 ; v2(21.88,73.06) 20.37,73.06 17.95,70.64 14.93,70.64 14.55,70.26 9.05,70.26 8.16,71.15 v2(7.65,71.15)
  BOTTOM w0.102: v2(8.21,99.04) 6,96.83 6,86.29 3.51,83.8 3.51,75.02 4.36,74.18 5.03,74.18 7.65,71.56 v2(7.65,71.15) ; v2(40.55,76.42) 40.55,75.6 37.62,72.68 37.62,68.8 36.8,67.98 36.8,64.74 34.96,62.9 31.27,62.9 v1(30.77,62.39) 29.5,61.12 29.18,61.12 28.39,61.91 27.38,61.91 24.44,64.84 24.44,65.72 24.04,66.13 23.53,66.13 21.98,67.68 21.98,70.1 21.76,70.32 21.76,72.94 v2(21.88,73.06)
PCH_GPIO44: length 20.3
  TOP w0.102: v3(45.63,89.09) 46.04,88.67 PCH1.AA36 ; v2(43.75,77.05) 43.52,76.82 43.52,75.29 43.72,75.09 43.72,73.55 R240.1 42.9,72.96 R239.1
  BOTTOM w0.102: v2(43.75,77.05) 44.23,77.53 44.23,80.87 44.61,81.25 v1(44.61,81.69) 44.17,82.14 44.17,83.34 45.24,84.42 45.24,86.77 44.94,87.08 44.94,88.12 45.62,88.8 v3(45.62,89.09)
PCH_GPIO45: length 105.8
  TOP w0.102: v2(33.68,47.91) 33.56,47.91 33.18,47.53 27.78,47.53 22,41.76 22,32.93 v2(22.26,32.67) ; v2(47.73,77.3) 47.73,73.57 48.17,73.13 48.17,72.04 50.04,70.17 R197.1 49.94,69.79 49.94,67.02 47.4,64.48 47.4,63.28 48.42,62.26 v2(48.8,62.26) ; v2(16.82,24.42) 16.82,14.98 14.96,13.11 v2(14.19,13.11) ; PCH1.W32 46.99,90.81 v3(46.64,90.45)
  BOTTOM w0.102: v2(33.68,47.91) 33.75,47.91 41.49,55.66 43.09,55.66 46.3,58.87 46.3,60.32 47.73,61.75 48.29,61.75 v2(48.8,62.26) ; v2(47.73,77.3) 47.34,77.69 47.34,78.9 46.77,79.47 v1(46.77,81.12) 46.69,81.2 46.69,84.16 46.36,84.49 46.36,86.44 46.77,86.85 46.77,87.88 47.07,88.18 47.07,90.02 v3(46.64,90.45) ; SR48.1 12.26,13.62 13.69,13.62 v2(14.19,13.11) 14.45,12.86 SQP1.B ; v2(22.26,32.67) 22.26,31.02 16.82,25.58 v2(16.82,24.42)
PCH_GPIO46: length 16.7
  TOP w0.102: PCH1.AA40 45.97,86.52 45.97,85.57 45.9,85.5 45.9,84.43 45.95,84.38 45.95,78.02 44.97,77.05 v1(44.58,77.05) 44.51,77.05 43.75,76.28 43.75,75.57 43.97,75.34 43.97,73.03 R220.1 43.29,71.83 R215.1
PCH_GPIO49: length 27.5
  TOP w0.089: 50.41,86.43 50.62,86.22 50.62,85.83 50.54,85.75 50.54,85.74
  TOP w0.102: R176.1 R172.1 56.12,64.25 56.12,65.77 v2(55.61,66.28) 55.53,66.35 55.53,67.22 55.02,67.72 54.52,67.72 54.26,67.98 54.26,68.49 54.45,68.68 54.45,78.29 53.32,79.42 53.32,81.46 52.01,82.78 51.71,82.78 50.54,83.95 50.54,85.74 ; PCH1.N40 50.35,86.49 50.41,86.43
PCH_GPIO50: length 18.4
  TOP w0.102: v3(42.19,94.76) 42.5,94.45 PCH1.AH26
  BOTTOM w0.102: SR57.1 28.19,89.19 29.12,89.19 29.62,88.68 v1(30,88.68) 30.39,88.68 33.03,91.32 35.36,91.32 37.44,93.41 38.43,93.41 38.68,93.16 40.27,93.16 40.62,93.51 40.62,93.89 40.85,94.11 41.55,94.11 v3(42.19,94.76)
PCH_GPIO51: length 14.4
  TOP w0.102: PCH1.AU31 37.35,90.95 34.91,90.95 33.26,89.29 32.14,89.29 30.92,88.07 28.36,88.07 28.14,87.85 27.18,87.85 26.89,88.14 R178.1 26.81,88.4 25.62,88.4 R177.1
PCH_GPIO52: length 18.9
  TOP w0.102: PCH1.AJ26 41.85,93.69 v3(41.79,93.63)
  BOTTOM w0.102: SR58.1 27.22,86.67 29.14,86.67 v1(29.5,87.03) 33.38,90.91 35.52,90.91 36.95,92.34 38.2,92.34 38.58,92.72 40.51,92.72 41,93.21 41.39,93.21 41.79,93.62 v3(41.79,93.63)
PCH_GPIO53: length 7.6
  TOP w0.102: R137.1 31.18,88.68 31.99,89.49 33.17,89.49 34.83,91.15 36.74,91.15 PCH1.AV31
PCH_GPIO54: length 7.2
  TOP w0.102: R136.1 31.15,87.41 31.68,87.94 32.49,87.94 34.98,90.42 PCH1.AW33
PCH_GPIO55: length 22.3
  TOP w0.102: v3(48.72,91.83) 49.06,92.17 PCH1.R30 ; v2(48.44,74.28) 48.7,74.28 49.18,73.79 49.18,72.84 R139.1
  BOTTOM w0.102: v3(48.72,91.83) 48.7,91.8 48.7,91.62 47.92,90.85 47.92,88.38 48.3,88 48.3,84.4 47.71,83.8 47.71,82.28 48.34,81.64 48.34,78.32 48.93,77.73 48.93,75.88 v1(48.65,75.6) 48.44,75.39 v2(48.44,74.28)
PCH_GPIO57: length 173
  TOP w0.102: v2(3.59,131.73) 3.18,131.33 3.18,61.99 3.79,61.37 4.28,61.37 4.76,60.89 6.73,60.89 10.07,64.23 15.4,64.23 16.17,65.01 22.99,65.01 23.18,64.82 31.46,64.82 34.56,67.92 34.56,69.74 v2(35.08,70.26) R191.1 ; PCH1.AC36 45.02,88.62 44.58,89.06 v3(44.58,89.04)
  BOTTOM w0.102: v3(44.58,89.04) 44.58,88.75 44.28,88.45 44.28,86.3 43.29,85.31 43.29,80.09 42.86,79.66 41.55,79.66 38.5,76.62 38.5,76.6 v1(36.48,74.58) 36.09,74.19 36.09,71.27 v2(35.08,70.26) ; v2(3.59,131.73) 4.48,131.73 5.34,132.6 5.34,134.61 6.03,135.29 6.03,144.21 5.14,145.1 5.14,151.04 4.83,151.35 4.83,153.47 2.83,155.48 2.83,167.04 BIOS_WP.2
PCH_GPIO72: length 72.9
  TOP w0.102: v2(25.51,76.23) 25.15,76.23 R237.1 R238.1 24.05,76.31 21.76,76.31 18.98,73.53 18.46,73.53 18.14,73.84 18.14,75.22 19.46,76.54 19.59,76.67 19.59,81.13 16.31,84.41 15.1,84.41 13.24,86.27 13.24,89.67 14.08,90.51 14.08,94.14 13.66,94.56 13.66,95.58 14.43,96.35 14.43,96.52 18.12,100.21 18.12,105.34 16.67,106.79 16.67,107.35 RJ3.1 ; PCH1.AJ40 41.9,86.34 41.9,85.68 41.26,85.04 41.26,85.02 38.51,82.28 v3(38.51,81.92)
  BOTTOM w0.102: v3(38.51,81.92) 37.75,81.92 v1(37.6,81.77) 37.6,81.64 35.54,79.57 32.35,79.57 31.07,78.29 27.59,78.29 25.53,76.23 v2(25.51,76.23)
PCH_GPIO73: length 228.6
  TOP w0.102: v2(5.75,169.2) 5.75,170.34 6.76,171.36 8.8,171.36 9.58,172.14 12,172.14 12.25,172.4 D8.2 D8.1 ; v2(41.74,55.15) 41.74,54.5 41.37,54.13 40.67,54.13 34.94,48.4 26.16,48.4 v2(25.74,48.83) ; v2(3.13,139.17) 2.72,138.77 2.72,59.93 3.13,59.52 6.93,59.52 7.16,59.75 8.19,59.75 10.37,61.93 12.63,61.93 13.34,62.64 15.88,62.64 16.83,63.6 21.94,63.6 v2(22.45,63.09) ; v2(47.4,60.71) 47.4,61.25 46.9,61.75 46.9,65.09 R963.1 R213.1 49.44,67.63 49.44,70.07 47.17,72.33 v2(47.17,75.1) ; PCH1.W34 47.01,90.09 v3(46.65,89.74)
  BOTTOM w0.102: v2(22.45,63.09) 26.65,58.88 26.65,56.73 25.33,55.4 25.33,49.77 25.74,49.36 v2(25.74,48.83) ; v2(41.74,55.15) 42.02,55.43 43.19,55.43 47.4,59.65 v2(47.4,60.71) ; v2(5.75,169.2) 5.32,169.63 4.2,169.63 1.84,167.27 1.84,153.56 4.66,150.74 4.66,144.93 4.71,144.88 5.57,144.02 5.57,141.76 5.23,141.42 5.19,141.42 5.18,141.41 3.99,141.41 3.36,140.78 3.36,139.4 v2(3.13,139.17) ; v2(47.17,75.1) 46.86,75.1 45.05,76.91 45.05,79.53 v1(45.4,79.88) 45.73,80.21 45.73,82.18 45.71,82.2 45.71,86.66 46.03,86.99 46.03,88.59 46.24,88.79 46.24,89.33 v3(46.65,89.74)
PCH_INTRUDER_L: length 16.1
  TOP w0.102: v2(33.66,73.36) 33.79,73.49 33.79,74.52 R229.2 33.81,75.82 33.81,81.19 34.2,81.57 34.2,82.58 35.59,83.98 36.96,83.98 38.81,85.83 PCH1.AR41
PCH_MEPWROK: length 150.8
  TOP w0.102: v2(3.46,132.62) 2.95,132.11 2.95,61.81 3.62,61.14 4.19,61.14 4.67,60.66 6.83,60.66 9.01,62.85 12.24,62.85 12.98,63.58 15.45,63.58 16.42,64.55 22.8,64.55 22.99,64.36 31.72,64.36 35.34,67.98 R186.1 ; v2(2.32,157.26) 8.29,157.26 9.86,158.83 C226.1 9.86,160.76 R184.1 10.62,161.53 QN25.C QN24.C
  BOTTOM w0.102: v2(3.46,132.62) 3.46,135.67 4.05,136.25 5.11,136.25 5.8,136.94 5.8,144.12 5.2,144.71 4.91,145 4.91,150.81 4.39,151.33 4.39,153.03 v1(3.59,153.83) 2.32,155.1 v2(2.32,157.26)
PCH_MEPWROK_R: length 31.4
  TOP w0.102: R186.2 R190.2 36.81,69.11 36.41,69.5 v2(35.08,69.5) ; PCH1.AA32 45.94,90.81 v3(45.57,91.17)
  BOTTOM w0.102: v2(35.08,69.5) 36.32,70.74 36.32,73.41 38.73,75.81 38.73,76.52 41.36,79.15 42.17,79.15 v1(42.76,78.57) 43.52,79.33 43.52,85.25 44.48,86.22 44.48,88.37 44.98,88.87 44.98,89.35 45.24,89.61 45.24,90.84 v3(45.57,91.17)
PCH_P19: length 1.6
  TOP w0.102: PCH1.P19 49.97,98.38 50.15,98.38 v3(50.15,98.38)
  BOTTOM w0.102: STP17.1 50.45,98.08 v3(50.15,98.38)
PCH_PCI_CLK2_FB: length 18.5
  TOP w0.102: PCH1.AU2 37.92,107.25 37.92,108.45 36.41,109.96 36.41,112.22 37.55,113.37 37.55,116.95 35.95,118.55 34.01,118.55 C195.1 R152.2 33.27,121.29 v2(33.31,121.32)
PCH_PECI: length 335.1
  TOP w0.089: 53.68,85.24 53.68,85.44 53.57,85.55 53.57,86.52 53.62,86.57
  TOP w0.102: 53.68,85.24 53.68,84.74 55.66,82.76 60.94,82.76 61.37,82.33 63.25,82.33 C224.1 64.26,82.33 67,82.33 69.91,85.24 69.91,89.42 v2(69.12,90.2) ; v2(213.39,113.44) 213.72,113.77 213.72,120.73 211.74,122.71 211.39,122.71 R24.2 ; PCH1.G40 53.62,86.57
  BOTTOM w0.102: v2(69.12,90.2) 69.37,89.95 75,89.95 77.29,92.23 80.78,92.23 81.87,91.14 v1(82.35,91.14) 82.35,90.69 87.71,85.33 87.71,75.52 85.55,73.36 85.55,59.33 87.94,56.94 87.94,54.54 87.51,54.11 87.51,51.27 96.2,42.58 96.2,39.4 96.68,38.92 96.68,38.89 98.81,36.76 101,36.76 101.78,35.97 105.74,35.97 107.26,37.5 127.79,37.5 130.65,34.65 158.85,34.65 160.61,36.41 173.1,36.41 174.19,35.31 178.32,35.31 179.42,36.41 201.63,36.41 202.72,35.31 216.72,35.31 217.02,35.62 218.34,35.62 218.67,35.95 222.18,35.95 222.82,36.59 222.82,37.85 224.16,39.2 224.16,49.3 225.7,50.83 227.36,50.83 227.81,50.39 229.2,50.39 229.97,51.16 229.97,52.61 229.01,53.57 229.01,54.13 229.52,54.64 229.52,61.63 230.54,62.64 230.54,65.54 226.9,69.18 226.9,80.96 220.89,86.98 220.89,97.64 216.19,102.34 216.19,110.65 v2(213.39,113.44)
PCH_PLTRST_L: length 492.7
  TOP w0.102: v2(77.53,89.31) 77.78,89.06 80.8,89.06 82.2,90.46 82.2,107.67 78.07,111.8 78.07,114.26 77.25,115.08 77.25,124.24 75.86,125.62 74.09,125.62 67.29,132.42 60.66,132.42 60.38,132.7 60.38,133.26 v2(60.61,133.48) 60.61,133.31 61.12,132.8 74,132.8 76.64,135.44 76.64,149.73 77.26,150.35 77.26,167.05 75.78,168.54 75.78,169.7 76.56,170.49 76.56,173.82 70.9,179.48 67.98,179.48 65.03,182.43 64.17,182.43 63.16,183.45 59.68,183.45 58.57,184.55 57.45,184.55 56.8,185.2 54.07,185.2 52.79,186.48 52.79,189.59 52.31,190.06 50.67,190.06 47.78,192.95 46.57,192.95 v2(46.24,193.28) ; v2(58.96,134.27) 59.21,134.27 60.1,135.16 60.1,135.95 R275.1 ; v2(48.72,208.52) 49.05,208.52 49.73,207.84 49.73,207.08 48.14,205.49 44.25,205.49 43.19,206.56 40.64,206.56 37.72,203.64 v2(37.72,202.96) ; v2(34.93,193.07) 34.81,192.95 29.75,192.95 v2(29.09,193.61) ; v2(197.14,28.18) 197.19,28.23 R358.1 ; v2(89.69,46.13) 89.69,47.15 88.96,47.89 80.96,47.89 80.02,48.83 80.02,58.35 v2(77.63,60.74) 75.37,60.74 74.1,62.01 69.81,62.01 67.77,64.04 60.8,64.04 59.28,62.52 51.96,62.52 48.51,59.06 44.39,59.06 43.34,60.12 43.34,65 42.99,65.35 42.99,66.67 43.34,67.02 43.34,67.72 43.57,67.95 43.57,69.58 44.89,70.91 44.89,73.31 44.61,73.59 44.61,75.27 44.81,75.47 44.81,76.14 45.27,76.6 45.27,76.97 46.18,77.88 46.18,84.47 46.11,84.55 46.11,85.4 46.17,85.47 46.17,86.24 46.27,86.34 46.27,87.71 PCH1.AA37 ; v2(63.98,221.84) 63.98,221.36 R457.1 65.37,219.96 v2(65.37,219.81)
  BOTTOM w0.102: SR59.1 63.91,221.9 v2(63.98,221.84) ; v2(29.09,193.61) 29.09,198.61 32.27,201.78 35.34,201.78 36.51,202.96 v2(37.72,202.96) ; v2(46.24,193.28) 45.7,193.81 44.36,193.81 43.03,195.13 41.76,195.13 40.37,193.73 39.05,193.73 37.8,192.49 35.52,192.49 v2(34.93,193.07) ; v2(89.69,46.13) 94.32,41.51 94.32,39.39 98.27,35.44 100.45,35.44 101.28,34.6 106.28,34.6 107.86,36.18 125.49,36.18 129.15,32.51 129.15,31.47 131.56,29.06 141.01,29.06 142.87,27.21 150.09,27.21 153.32,23.98 177.33,23.98 178.02,24.67 194.72,24.67 196.63,26.58 196.63,27.67 v2(197.14,28.18) ; v2(65.37,219.81) 65.37,218.28 v1(64.68,217.58) 63.29,216.2 54.66,216.2 53.4,214.94 53.4,209.73 52.18,208.52 v2(48.72,208.52) ; v2(77.53,89.31) 78.11,88.73 78.11,87.94 77.6,87.43 77.6,84.84 74.76,82 74.76,76.49 78.62,72.63 78.62,66.63 77.63,65.64 v2(77.63,60.74) ; v2(58.96,134.27) 59.75,133.48 v2(60.61,133.48)
PCH_PLTRST_L_R: length 6.6
  TOP w0.102: v1(61.88,138.01) 61.58,137.7 60.9,137.7 R275.2 59.72,137.54 59.72,138.72 60.07,139.07 C334.2 60.44,139.28 U11.117
PCH_PW_AB1: length 16.7
  TOP w0.178: C256.1 45.63,115 45.63,109.76 45.5,109.63 45.5,107.66 PCH1.AB1
  TOP w0.508: R760.2 46.45,119.6 C255.1 45.02,120.3 44.67,119.96 44.67,117.85 45.14,117.38 v1(45.3,117.38) 45.49,117.19 45.49,116.03 46.01,115.51 C256.1
PCH_PW_AB1_FB: length 4
  TOP w0.102: v1(49.64,120.86) 47.67,120.86 R760.1
  TOP w0.508: R760.1 47.53,122.78 PFB2.2
PCH_PWROK: length 643.3
  TOP w0.102: R200.1 32.82,73.75 v2(32.82,73.49) ; R190.1 35.47,68.99 v2(35.08,68.61) 34.92,68.45 34.92,67.95 31.56,64.59 23.09,64.59 22.9,64.78 16.32,64.78 15.48,63.94 12.63,63.94 v2(12.42,63.72) ; v2(225.46,90.71) 224.8,90.05 224.8,78.27 224.01,77.49 224.01,72.24 224.75,70.03 224.75,65.04 228.83,60.96 229.14,60.65 229.57,60.22 229.57,54.21 v2(229.9,53.88) ; v2(87.03,16.23) 87.03,19.34 90.56,22.87 90.56,32.41 89.19,33.79 89.19,38.13 89.85,38.79 90.63,38.79 92.44,40.6 92.44,44.15 v2(91.98,44.61) 92.36,44.99 92.36,49.79 93.45,50.88 93.45,53.93 v2(92.74,54.64) ; QN1.D 204.12,146.34 206.54,146.34 213.94,138.94 216.2,138.94 218.52,136.61 220.57,136.61 221.1,137.14 223.63,137.14 224.67,138.18 228.15,138.18 v2(230.16,136.18) ; U21.32 206.98,33.88 206.79,34.07 C395.1 R741.1 207.93,33.94 v2(207.8,33.81)
  BOTTOM w0.102: v2(32.82,73.49) 32.82,73.06 34.53,71.36 34.53,69.17 v2(35.08,68.61) ; v2(229.9,53.88) 230.54,53.25 230.54,51.04 229.62,50.12 229.62,49.03 227.96,47.37 227.96,44.27 226.22,42.53 226.22,36.56 225.33,35.67 224.81,35.67 222.09,32.95 208.67,32.95 v2(207.8,33.81) 207.4,34.22 205.85,34.22 203.64,32.01 199.65,32.01 199.02,32.65 197.87,32.65 197.29,32.06 197.29,29.19 196.4,28.3 196.4,26.92 194.37,24.9 177.92,24.9 177.23,24.21 153.41,24.21 150.19,27.44 142.96,27.44 141.11,29.29 131.66,29.29 129.38,31.57 129.38,32.61 125.58,36.41 107.76,36.41 106.19,34.83 101.38,34.83 100.54,35.67 98.36,35.67 94.55,39.48 94.55,42.04 v2(91.98,44.61) ; v2(92.74,54.64) 92.36,55.02 92.36,74.2 91.85,74.71 90.96,74.71 90.41,75.27 90.41,84.94 104.76,99.3 104.76,104.84 107.47,107.56 107.47,108.87 117.63,119.03 118.4,119.03 120.94,121.57 126.4,121.57 130.65,125.82 138.02,125.82 138.47,125.37 141.27,125.37 141.94,124.7 143.62,124.7 144.1,125.18 146.95,125.18 SR18.2 ; v2(225.46,90.71) 224.31,91.85 224.31,100.11 223.3,101.12 223.3,106.99 233.26,116.95 v1(233.26,117.63) 234.09,118.47 234.09,120.05 233.71,120.43 233.71,122.26 234.47,123.03 234.47,128.93 233.79,129.62 233.79,134.29 234.32,134.82 234.32,135.95 233.46,136.81 230.79,136.81 v2(230.16,136.18) ; v2(87.03,16.23) 84.04,16.23 82.6,14.79 76.97,14.79 72.05,9.87 72.05,9.84 70.57,8.35 70.57,5.23 69.45,4.11 63.88,4.11 60.01,7.98 53.63,7.98 50.86,5.21 11.69,5.21 8.69,8.2 8.69,16.05 9.25,16.61 9.25,36.43 10.19,37.37 10.19,45.68 10.95,46.44 10.95,49.29 10.01,50.23 10.01,55.52 10.01,55.52 10.01,56.44 11.75,58.17 12.01,58.44 12.01,58.44 12.15,58.58 12.15,63.46 v2(12.42,63.72)
PCH_RI_L: length 464.3
  TOP w0.102: v2(93.63,147.61) 93.63,131.4 92.95,130.72 92.95,116.24 91.98,115.27 86.52,115.27 85.71,114.46 83.85,114.46 82.71,115.6 80.04,115.6 v2(79.15,116.49) ; v2(1.56,144.51) 2.17,145.12 11.39,145.12 16.92,150.65 17.75,150.65 18.88,151.77 22.44,151.77 23.44,152.77 25.47,152.77 26.23,153.53 33.66,153.53 35.24,151.95 38.04,151.95 39.43,150.55 39.88,150.55 40.8,149.64 40.8,142.87 43.14,140.53 43.14,139.35 44.56,137.92 45.44,137.92 46.16,137.19 46.16,136.13 50.13,132.16 58.26,132.16 59.02,131.4 65.35,131.4 76.77,119.98 v2(76.77,115.63) ; v2(113.82,185.07) 114.21,184.69 116.62,184.69 117.15,185.22 121.22,185.22 122.65,183.8 126.14,183.8 127.92,185.58 127.92,190.66 136.56,199.3 143.16,199.3 143.92,200.06 146.84,200.06 147.1,199.8 v2(147.1,199.37) ; QN45.C 206.25,203.39 C435.1 207.9,203.39 208.44,202.85 v2(208.44,202.09) ; PCH1.AE36 43.63,88.67 v3(43.31,89) ; v2(4.1,61.88) 4.86,61.12 5.43,61.12 8.77,64.46 15.29,64.46 16.06,65.23 21.42,65.23 22.04,65.86 25.01,65.86 25.53,65.34 31.3,65.34 34.11,68.14 34.11,70.97 v2(35.08,71.95) 35.43,72.3 R224.1 ; v2(99.6,147.86) 99.85,148.11 v2(99.85,178.98)
  BOTTOM w0.102: v2(4.1,61.88) 3.92,61.88 1.02,64.79 1.02,143.97 v2(1.56,144.51) ; v2(99.6,147.86) 99.47,147.73 93.76,147.73 v2(93.63,147.61) ; v3(43.31,89) 43.31,88.65 43.09,88.43 43.09,88.26 42.43,87.6 42.43,86.42 42.55,86.29 42.55,81.7 36.73,75.87 35.74,75.87 34.83,74.96 34.83,72.21 v2(35.08,71.95) ; v2(79.15,116.49) 77.63,116.49 v2(76.77,115.63) ; v2(99.85,178.98) 101.37,178.98 104.65,182.25 111.77,182.25 113.82,184.31 v2(113.82,185.07) ; v2(147.1,199.37) 147.94,198.53 201.96,198.53 205.26,201.84 v1(205.9,201.84) 208.19,201.84 v2(208.44,202.09)
PCH_RTCX1: length 17.5
  TOP w0.102: v3(35.41,82.56) 36.28,82.56 39.39,85.67 PCH1.AN40 ; v2(29.31,80.49) 29.13,80.49 28.67,80.03 R249.1 28.67,79.56 27.78,78.66 C239.1 27.78,78.34 27.97,78.14 Y1.1
  BOTTOM w0.102: v3(35.41,82.56) 34.81,82.56 33.47,81.22 30.04,81.22 v2(29.31,80.49)
PCH_RTCX2: length 17.5
  TOP w0.102: Y1.2 30.51,77.68 30.84,78 C242.1 30.84,78.79 30.07,79.56 R249.2 30.07,80.19 v2(30.37,80.49) ; PCH1.AN39 39.69,87.08 39.69,85.62 35.87,81.8 v3(35.43,81.8)
  BOTTOM w0.102: v3(35.43,81.8) 34.73,81.8 33.67,80.74 30.62,80.74 v2(30.37,80.49)
PCH_SIO_33M: length 12
  TOP w0.102: PCH1.AV7 37.15,104.57 36.69,104.57 36.47,104.79 33.54,104.79 30.86,107.47 30.86,107.47 C194.1 29.72,108.62 R151.2 v2(27.69,107.89)
PCH_SIO_48M: length 11.9
  TOP w0.102: PCH1.AU8 37.32,103.91 36.96,104.27 36.71,104.27 36.54,104.1 35.81,104.1 35.62,103.92 35.16,103.92 34.5,104.58 33.31,104.58 31.17,106.71 C197.1 29.9,106.26 28.02,106.26 R155.2
PCH_SPI_CLK: length 11.3
  TOP w0.102: PCH1.U39 48.2,87.03 48.2,86.84 48.19,86.83 48.19,85.95 48.24,85.9 48.24,82.9 47.92,82.58 47.92,78.82 49.56,77.19 R221.2
PCH_SPKR: length 395.4
  TOP w0.102: R387.1 R243.1 230.54,100.39 228,97.85 v2(228,97.44) ; v2(70.14,62.87) 68.46,64.55 60.59,64.55 59.07,63.02 51.78,63.02 50.13,61.37 48.55,61.37 47.15,62.77 47.15,64.55 49.69,67.09 49.69,70.14 47.66,72.17 v2(47.66,72.83) ; v3(48.7,91.02) 48.92,90.81 PCH1.R32 ; v2(87.66,11.08) 87.66,12.21 87.1,12.77 85.38,14.5 85.38,19.6 89.26,23.49 89.26,31.88 87.89,33.25 87.89,42.9 86.76,44.03 81.58,44.03 77.73,47.88 77.73,56.54 76.12,58.15 72.01,58.15 71.2,58.96 68.94,58.96 v2(68.23,58.25)
  BOTTOM w0.102: v2(87.66,11.08) 87.66,9.7 88.12,9.24 88.12,7.23 92.7,2.65 103.14,2.65 105.94,5.44 109.06,5.44 112.98,1.52 223.91,1.52 226.54,4.16 229.64,4.16 231.49,6.01 231.49,9.08 240.76,18.35 240.76,23.65 242.09,24.99 v1(242.09,25.81) 242.09,26.83 242.53,27.26 242.53,48.29 242.31,48.51 242.31,48.52 242.12,48.71 242.12,49.71 242.53,50.12 242.53,67.91 238.8,71.64 236.02,71.64 231.35,76.31 231.35,86.35 228.63,89.07 228.63,91.98 228.12,92.49 228.12,97.31 v2(228,97.44) ; v3(48.7,91.02) 48.7,90.99 48.12,90.42 48.12,88.47 48.51,88.08 48.51,84.2 47.96,83.66 47.96,82.35 48.57,81.74 48.57,78.46 49.21,77.82 49.21,76.08 49.82,75.47 49.82,73.69 48.95,72.83 v2(47.66,72.83) ; v2(70.14,62.87) 70.14,60.15 v2(68.23,58.25)
PCH_SYSPWROK: length 443.3
  TOP w0.102: PCH1.W31 46.99,91.52 v3(46.64,91.17) ; v2(236.76,135.03) 235.87,134.14 R989.1 ; v2(70.01,58.12) 70.01,58.45 70.29,58.73 71,58.73 71.81,57.92 76.02,57.92 77.5,56.44 77.5,47.78 81.57,43.72 86.75,43.72 87.66,42.8 87.66,33.15 89.03,31.78 89.03,23.58 85.15,19.7 85.15,14.41 87.03,12.53 v2(87.03,11.72) ; v2(65.69,58.33) 65.18,58.83 52.98,58.83 49.94,55.79 42.96,55.79 42.45,56.3 42.36,56.4 40.41,56.4 R255.1 36.83,59.98 R253.1 R256.2 36.83,62.98 C241.1 37.19,63.42 37.19,66.63 37.32,66.76 v2(37.32,66.89)
  BOTTOM w0.102: v2(87.03,11.72) 87.03,10.01 87.03,10.01 87.89,9.14 87.89,7.14 92.61,2.42 103.24,2.42 106.03,5.21 108.97,5.21 112.88,1.3 224,1.3 226.64,3.93 229.74,3.93 231.72,5.91 231.72,8.98 241.02,18.28 241.02,23.47 242.75,25.2 242.75,48.39 242.35,48.8 242.35,49.62 242.75,50.03 242.75,68 238.89,71.86 236.12,71.86 231.58,76.4 231.58,86.45 228.89,89.14 228.89,92.09 228.63,92.34 228.63,97.7 227.49,98.84 227.49,106.14 237.4,116.04 237.4,123.16 237.14,123.42 237.14,124.75 237.27,124.87 237.27,127.03 237.07,127.24 237.07,134.73 v2(236.76,135.03) ; v2(65.69,58.33) 66.28,57.74 69.63,57.74 v2(70.01,58.12) ; v3(46.64,91.17) 46.13,90.66 46.13,89.51 46.04,89.41 46.04,88.93 45.83,88.72 45.83,87.08 45.5,86.75 45.5,80.96 44.81,80.27 44.81,75.9 44.51,75.6 44,75.6 43.36,76.23 41.59,76.23 39.66,74.3 39.61,74.3 38.21,72.9 v1(38.21,68.51) 38.21,67.77 v2(37.32,66.89)
PCH_TACH6: length 15.4
  TOP w0.102: v2(31.88,86.9) 31.25,86.27 R156.2 30.35,86.18 29.39,85.22 R160.2 ; v3(40.93,92.33) 41.14,92.54 PCH1.AK28
  BOTTOM w0.102: v3(40.93,92.33) 40.26,91.67 37.14,91.67 35.78,90.3 35.06,90.3 v1(34.7,89.95) 34.7,89.72 v2(31.88,86.9)
PCH_TACH7: length 12.2
  TOP w0.089: 35.96,89.67 36.08,89.67 36.1,89.69 36.55,89.69 36.66,89.59 36.88,89.59
  TOP w0.102: PCH1.AT34 38.06,89.59 36.88,89.59 ; R158.2 30.35,84.11 R161.2 30.68,84.44 31.3,84.44 32.34,85.48 32.34,86.93 35.08,89.67 35.96,89.67
PCH_TCM_33M: length 13.2
  TOP w0.102: R148.2 27.43,110.52 28.23,110.52 28.73,111.03 29.34,111.03 C193.1 30.26,110.4 v2(30.77,109.89) 31.38,109.28 31.38,107.96 34.11,105.23 36.8,105.23 PCH1.AV5
PCH_THERMTRIP_L: length 466.7
  TOP w0.102: v2(229.01,136.07) 228.28,136.07 226.07,133.87 214.94,133.87 207.27,141.54 204.22,141.54 203.77,141.98 R40.2 203.42,141.79 202.54,141.79 R42.1 ; v2(89.57,10.57) 89.57,11.64 86.32,14.89 86.32,19.21 90.2,23.1 90.2,32.27 88.83,33.64 88.83,38.41 89.57,39.15 90.49,39.15 91.97,40.63 91.97,43.22 91.37,43.82 91.37,44.89 92.01,45.52 92.01,49.94 93.1,51.03 93.1,53.09 91.54,54.64 87.54,54.64 v2(87.28,54.9) ; v2(68.18,89.85) 67.34,89.01 67.34,87.15 66.58,86.39 66.58,85.07 66.1,84.59 59.47,84.59 58.68,83.8 56.21,83.8 55.37,84.64 55.37,86.36 PCH1.C40
  BOTTOM w0.102: v2(68.18,89.85) 68.49,89.54 75.17,89.54 77.46,91.83 80.58,91.83 87.31,85.1 87.31,75.74 85.15,73.58 85.15,59.04 87.28,56.9 v2(87.28,54.9) ; v2(229.01,136.07) 230.11,137.17 233.61,137.17 234.68,136.1 234.68,134.68 234.35,134.35 234.35,132.14 235.36,131.12 235.36,129.45 234.83,128.91 234.83,122.88 234.47,122.52 v1(234.47,120.94) 234.47,117.66 223.68,106.87 223.68,101.25 224.67,100.26 224.67,92.39 226.09,90.96 226.09,87.39 229.93,83.56 229.93,75.75 235.46,70.21 237.12,70.21 241.31,66.02 241.31,50.55 240.95,50.19 240.95,47.91 241.36,47.51 241.36,29.14 239.34,27.12 239.34,18.94 229.84,9.44 229.84,7.27 229.16,6.59 228.25,6.59 227.22,5.56 225.91,5.56 225.6,5.25 223.3,5.25 220.97,2.92 116.15,2.92 113.78,5.29 113.27,5.29 111.81,6.75 105.69,6.75 102.87,3.93 92.95,3.93 89.31,7.57 89.31,10.32 v2(89.57,10.57)
PCH_TPM_33M: length 15
  TOP w0.102: PCH1.AU5 37.21,105.37 37.15,105.37 37.03,105.49 36.55,105.49 36.49,105.43 34.41,105.43 32.04,107.81 32.04,109.98 C196.1 29.67,112.35 v2(28.1,112.35) 27.99,112.35 R154.2
PCH_VGA_HSYNC: length 14.9
  TOP w0.102: PCH1.AH3 42.26,106.55 42.56,106.85 42.56,108.53 41.71,109.38 41.71,110.27 40.5,111.49 39.19,111.49 38.55,112.12 38.55,117.83 R142.2
PCH_VGA_VSYNC: length 14
  TOP w0.102: R143.2 38.3,118.14 38.3,112.09 39.1,111.28 40.41,111.28 41.51,110.19 41.51,109.29 42.36,108.44 42.36,107.12 PCH1.AH2
PCI_+VCC_+VCC3_FB: length 108.9
  TOP w0.203: v2(43.95,158.17) 44.2,157.92 46.65,157.92 R967.2 R968.2
  TOP w0.254: v2(48.04,140.37) 48.04,140.11 49.05,139.1 49.05,137.32 49.4,136.97 R977.2 ; R287.2 52.72,136.45 52.5,136.45 52.23,136.18 52.23,135.89 51.72,135.39 51.72,134.3
  TOP w0.305: 57.54,165.34 57.67,165.21 57.67,160.88 R976.2 ; R974.2 55.79,162.02 PFB11.2
  TOP w0.381: v2(53.73,164.62) 56.27,164.62 56.62,164.27 56.62,162.54 56.23,162.15 PFB11.2 ; R966.2 46.13,153.45 45.88,153.19 43.97,153.19 v2(43.85,153.07) ; v2(49.18,162.59) 49.44,162.59 49.69,162.34 49.69,161.83 ; R969.2 46.65,154.59 45.76,155.48 44.1,155.48 v2(43.85,155.23) ; R965.2 R288.2 45.75,151.16 45.24,150.65 v2(44.74,150.65) 43.38,149.3 43.38,144.26 44.73,142.91 45.2,142.91 45.9,142.21 45.9,140.73 v2(47.15,139.48) 47.95,138.67 47.95,136.87 48.68,136.14 49.41,135.41 50.53,134.3 57.13,134.3 v1(57.84,135.01) 58.12,135.29 59.34,135.29 59.6,135.54 59.6,136.59 R970.2 R975.2 ; 49.69,161.83 R971.2 R972.2 R973.2 51.98,160.94 50.71,162.21 PFB10.1 ; 49.69,161.83 46.21,161.83 v2(46.01,161.63) ; 57.54,165.34 56.73,166.15 v2(53.73,166.15) 49.82,166.15 v2(49.69,166.28)
  BOTTOM w0.254: v2(47.15,139.48) v2(48.04,140.37)
  BOTTOM w0.381: v2(49.18,162.59) 49.82,163.23 49.82,166.15 v2(49.69,166.28) ; v2(53.73,164.62) 53.73,166.12 53.75,166.15 v2(53.73,166.15) ; v2(46.01,161.63) 45.32,160.94 44.48,160.94 43.8,160.26 43.8,158.33 v2(43.95,158.17) 43.8,158.02 43.8,155.28 v2(43.85,155.23) v2(43.85,153.07) 43.85,151.54 v2(44.74,150.65)
PCI_CLK2_FB: length 243.7
  TOP w0.102: R152.1 31.55,120.43 30.04,118.93 arc(29.76,118.93) 29.76,119.21 33.01,122.47 arc(33.01,122.76) 32.72,122.76 25.58,115.61 arc(25.29,115.61) 25.29,115.9 32.32,122.93 arc(32.32,123.22) 32.03,123.22 25.55,116.74 arc(25.26,116.74) 25.26,117.02 31.21,122.97 arc(31.21,123.26) 30.93,123.26 25.61,117.95 arc(25.32,117.95) 25.32,118.23 30.09,123 arc(30.09,123.29) 29.8,123.29 26.21,119.69 arc(25.92,119.69) 25.92,119.98 28.84,122.9 arc(28.84,123.19) 28.56,123.19 26.8,121.43 arc(26.51,121.43) 26.51,121.72 27.75,122.96 arc(27.75,123.24) 27.46,123.24 26.08,121.86 26.08,120.92 25.53,120.38 25.53,118.98 24.92,118.36 24.92,114.94 23.64,113.67 arc(23.64,113.38) 23.93,113.38 28.1,117.55 arc(28.39,117.55) 28.39,117.26 23.53,112.4 arc(23.53,112.12) 23.82,112.12 28.09,116.39 arc(28.38,116.39) 28.38,116.1 24.49,112.21 arc(24.49,111.92) 24.78,111.92 27.74,114.89 arc(28.03,114.89) 28.03,114.6 24.85,111.42 24.85,107.09 arc(24.65,106.89) 24.44,107.09 24.44,111.28 arc(24.24,111.49) 24.04,111.28 24.04,103.87 arc(23.83,103.66) 23.63,103.87 23.63,111.36 arc(23.43,111.56) 23.22,111.36 23.22,103.03 arc(23.02,102.83) 22.82,103.03 22.82,111.08 arc(22.61,111.28) 22.41,111.08 22.41,102.19 arc(22.21,101.99) 22,102.19 22,105.65 arc(21.8,105.85) 21.6,105.65 21.6,101.25 arc(21.39,101.05) 21.19,101.25 21.19,104.86 arc(20.99,105.06) 20.78,104.86 20.78,100.59 arc(20.58,100.39) 20.38,100.59 20.38,102.7 arc(20.17,102.9) 19.97,102.7 19.97,99.55 17.85,97.42 17.85,95.38 arc(17.65,95.18) 17.44,95.38 17.44,96.45 arc(17.24,96.65) 17.04,96.45 17.04,94.69 v2(17,94.65) ; v3(40.09,96.81) 40.43,96.47 PCH1.AM22
  BOTTOM w0.102: v3(40.09,96.81) 39.94,96.81 39.48,96.35 37.32,96.35 v1(37.17,96.5) 37.17,96.01 35.26,94.1 33.04,94.1 31.25,92.31 SC17.1 30.1,92.85 29.91,93.04 27.85,93.04 27.25,92.44 23.98,92.44 22.59,93.83 22.59,94.42 22.08,94.93 19.84,94.93 v1(19.46,94.55) 19.08,94.93 17.28,94.93 v2(17,94.65)
PCICLK0: length 62.1
  TOP w0.102: R289.1 34.99,179.1 v2(35.08,179.1) ; v2(44.23,147.86) 43.93,147.56 43.93,146.42 44.65,145.7 44.91,145.7 45.91,144.71 45.91,143.55 45.9,143.54 45.9,142.91 46.39,142.42 46.39,141.15 48.43,139.11 48.45,139.09 48.45,137.08 49.03,136.49 49.15,136.38 50.2,136.38 50.4,136.58 50.4,137.65 50.67,137.92 C345.1 52.52,139.48 54.61,139.48 55.24,140.11 U11.104
  BOTTOM w0.102: v2(44.23,147.86) 44.02,147.86 42.55,149.33 41.76,149.33 40.93,150.17 40.93,162.39 39.83,163.48 38.64,163.48 37.62,164.5 37.27,164.5 v1(34.98,166.78) 34.45,167.32 34.45,178.59 34.96,179.1 v2(35.08,179.1)
PCICLK0_R: length 4.6
  TOP w0.102: PCI.B16 37.23,183.66 35.12,181.55 C347.2 33.88,181.55 R289.2
PCICLK_SEL: length 6.3
  TOP w0.102: RJ2.2 v1(66.07,139.22) 66.07,141.02 65.08,142.02 64.17,142.02 64.04,141.89 U11.126
PCIE_WAKE_L: length 249.7
  TOP w0.102: PCIE16X_2.B11 20.24,189.27 22.32,189.27 22.75,188.84 26.66,188.84 28.56,190.74 34.32,190.74 36.46,192.87 37.93,192.87 38.92,193.86 40.52,193.86 41.72,192.66 42.92,192.66 44.21,193.94 45.43,193.94 46.01,194.52 47.25,194.52 50.92,190.85 52.57,190.85 53.49,189.93 53.49,186.92 54.42,185.99 56.77,185.99 57.71,186.93 58.55,186.93 PCIE1X.B11 61.02,189.39 62.9,189.39 63.91,188.37 63.91,187.99 64.42,187.48 67.09,187.48 70.39,190.79 71.64,190.79 74.96,187.46 79.4,187.46 PCIE16X_1.B11 ; v3(40.95,90.35) 40.95,90.35 PCH1.AK34 ; v2(8.16,171.86) 8.67,172.37 11.64,172.37 13.28,174.01 v2(16.1,174.01) ; R225.1 25.15,77.38 25.46,77.38 v2(25.61,77.22) 25.99,76.84 25.99,75.84 25.44,75.29 21.13,75.29 19.13,73.3 18.31,73.3 17.91,73.69 17.91,75.32 19.36,76.77 19.36,81.03 16.34,84.06 15.02,84.06 12.76,86.32 v2(12.76,87.89)
  BOTTOM w0.102: v3(40.95,90.35) 40.39,89.8 40.39,87.15 40.01,86.77 40.01,85.33 36.96,82.28 36.96,81.33 35.44,79.8 32.26,79.8 30.98,78.52 26.91,78.52 v2(25.61,77.22) ; v2(12.76,87.89) 12.76,90.78 15.81,93.83 15.81,94.55 15.5,94.85 13.88,94.85 13.49,95.23 13.49,97.02 11.63,98.89 11.63,104.94 12.83,106.15 12.83,108.26 10.37,110.73 10.37,123.55 10.93,124.11 10.93,127.89 11.59,128.56 11.59,136.49 12.5,137.41 12.5,143.16 11.87,143.8 11.87,145.37 9.94,147.3 9.94,148.85 9.86,148.93 9.86,148.93 9.15,149.64 9.15,151.44 8.69,151.9 8.69,154.22 9.94,155.46 9.94,159.54 9.37,160.12 9.37,170.66 v2(8.16,171.86) ; PCIE16X_2.B11 17.74,188.55 16.42,187.23 16.42,174.36 16.1,174.04 v2(16.1,174.01)
PCIRST1_L: length 349
  TOP w0.102: R270.2 26.8,187.23 30.07,190.51 34.42,190.51 36.55,192.64 38.02,192.64 39.02,193.63 40.42,193.63 41.6,192.45 43.04,192.45 44.3,193.71 45.52,193.71 46.1,194.29 47.15,194.29 50.92,190.52 52.5,190.52 53.25,189.78 53.25,186.77 54.31,185.71 57.14,185.71 57.9,186.47 59.6,186.47 60.65,185.42 62.1,185.42 62.95,186.27 65.13,186.27 65.56,185.83 65.56,185.45 67.06,183.96 R271.2 67.83,183.47 73.8,183.47 76.05,181.21 76.05,177.98 77.12,176.92 77.12,169.7 v2(76.74,169.32) ; v2(88.17,53.75) 88.42,53.51 91.85,53.51 92.51,52.85 92.51,51.27 91.42,50.18 91.42,46.59 90.74,45.9 90.74,45.27 v2(90.2,44.74) ; v2(78.09,150.53) 77.1,149.54 77.1,130.79 75.19,128.89 75.19,126.45 75.55,126.09 76.16,126.09 77.76,124.49 77.76,115.22 78.53,114.45 78.53,112.31 83.09,107.75 83.09,92.01 v2(83.75,91.35) ; v2(206.15,31.02) 206.48,31.35 U21.33
  BOTTOM w0.102: v2(78.09,150.53) 77.53,151.09 77.53,156.22 77.1,156.65 77.1,167.95 76.74,168.31 v2(76.74,169.32) ; v2(206.15,31.02) 206.15,31.78 v1(205.9,32.04) 205.14,32.04 204.25,31.15 201.33,31.15 199.09,28.91 199.09,27.17 196.36,24.44 178.11,24.44 177.42,23.76 153.22,23.76 150,26.98 142.77,26.98 140.92,28.84 131.44,28.84 128.92,31.35 128.92,32.41 125.39,35.95 107.95,35.95 106.38,34.37 101.19,34.37 100.35,35.21 98.17,35.21 94.09,39.29 94.09,41.42 90.77,44.74 v2(90.2,44.74) ; v2(88.17,53.75) 88.35,53.93 88.35,57.11 85.96,59.49 85.96,73.13 88.12,75.29 88.12,86.95 83.75,91.32 v2(83.75,91.35)
PCIRST2_L: length 48.3
  TOP w0.102: v2(233.84,29.48) 234.03,29.67 237.15,29.67 238.09,28.73 R412.2 R408.1 ; U21.34 205.98,31.56 205.67,31.25 205.67,30.61 207.64,28.64 209.17,28.64 210.73,27.08 v2(210.73,23.78)
  BOTTOM w0.102: v2(233.84,29.48) v1(233.84,27.97) 233.84,27.34 233.36,26.85 233.36,25.08 232.32,24.04 229.78,24.04 229.08,23.34 219.5,23.34 217.25,25.58 212.19,25.58 211,24.39 211,24.05 v2(210.73,23.78)
PCIRST2_L_IC: length 3.2
  TOP w0.102: U23.16 236.65,25.92 235.94,26.64 C423.1 R408.2
PCIRST3_L: length 385.6
  TOP w0.102: v2(205.14,198.28) 204.88,198.28 203.74,199.42 202.72,199.42 201.53,198.23 137.71,198.23 129.34,189.87 129.34,184.6 117.81,173.06 108.81,173.06 v2(108.36,173.51) ; v2(92.11,183.55) D23.1 90.38,184.26 88.13,184.26 R96.2 ; v2(237.78,54.64) 236.35,56.06 236.35,64.65 237.22,65.51 237.22,66.4 237.42,66.61 237.42,70.18 231.2,76.41 231.2,82.1 234.5,85.4 239.54,85.4 241.51,87.37 241.51,199.42 238.71,202.22 v2(232.95,202.22) ; v2(221.19,29.24) 220.31,29.24 217.58,26.52 217.58,22.43 213.04,17.89 213.04,17.28 213.48,16.83 U21.84
  BOTTOM w0.102: v2(237.78,54.64) 237.78,54.26 234.47,50.95 234.47,45.88 233.17,44.58 233.17,39.4 232.09,38.32 232.09,33.45 229.34,30.7 225.14,30.7 223.17,28.73 221.7,28.73 v2(221.19,29.24) ; v2(108.36,173.51) 103.66,178.21 97.6,178.21 92.27,183.55 v2(92.11,183.55) ; v2(232.95,202.22) 231.81,201.07 210.73,201.07 v1(209,199.35) 207.93,198.28 v2(205.14,198.28)
PCIRST_L: length 68.5
  TOP w0.127: v2(68.1,176.94) 65.31,176.94 v2(63.53,178.72) ; v2(58.71,145.7) 59.64,144.77 U11.115 59.64,140.11 59.39,139.86 59.09,139.86 58.72,139.49 58.72,138.45 R975.1 ; R290.2 48.77,179.64 50.32,178.09 v2(51.09,178.09)
  BOTTOM w0.127: v2(58.71,145.7) 58.26,146.15 58.26,153.14 59.46,154.34 59.46,155.37 58.66,156.17 58.66,156.69 58,157.35 58,166.89 58.47,167.36 68.05,176.94 v2(68.1,176.94) ; v2(63.53,178.72) 62.67,179.58 60.07,179.58 58.58,178.09 v1(52.84,178.09) v2(51.09,178.09)
PCIRST_L_R: length 5.7
  TOP w0.102: PCI.A15 45.38,184.93 47.05,183.26 C346.2 47.05,181.52 R290.1
PEG_RCOMP: length 5.8
  TOP w0.305: R4.2 138.55,135.32 139.98,133.89 141.97,133.89 CPU1.P3
PEG_RX_N0: length 90.8
  TOP w0.102: CPU1.F15 v4(152.94,141.21)
  TOP w0.114: PCIE16X_1.A17 83.2,180.75 84.03,180.75 84.27,180.51 91.08,180.51 v2(91.47,180.12)
  BOTTOM w0.102: 150.8,146.34 150.8,146.31 150.81,146.3 150.81,145.5 151.11,145.19 151.59,145.19 152.23,144.56 152.23,143.59 152.48,143.34 152.48,141.93 152.94,141.47 v4(152.94,141.21)
  BOTTOM w0.114: 150.8,146.34 150.8,146.77 146.95,150.63 132.45,150.63 130.31,152.76 128.12,152.76 127.08,153.8 127.08,155.99 122.99,160.09 113.15,160.09 101.38,171.86 94.17,179.07 94.01,179.23 93.33,179.23 92.19,180.36 91.7,180.36 v2(91.47,180.12)
PEG_RX_N1: length 87.6
  TOP w0.102: v4(152.02,141.21) CPU1.E14
  TOP w0.114: v2(91.47,176.06) 91.06,176.47 84.5,176.47 84.18,176.16 84.18,175.8 84.43,175.55 PCIE16X_1.A22
  BOTTOM w0.102: v4(152.02,141.21) 152.02,141.39 151.82,141.59 151.54,141.59 151.29,141.84 151.29,143.32 151.67,143.7 151.67,144.25 151.36,144.56 150.73,144.56 150.07,145.22 150.07,146.3 150.06,146.31 150.06,146.34
  BOTTOM w0.114: 150.06,146.34 150.06,146.49 146.64,149.92 132.15,149.92 130.15,151.92 126.99,151.92 120.35,158.57 112.64,158.57 101.38,169.82 94.73,176.47 91.89,176.47 v2(91.47,176.06)
PEG_RX_N2: length 86.4
  TOP w0.102: v4(151.11,140.29) CPU1.F13
  TOP w0.114: PCIE16X_1.A26 84.42,171.55 84.17,171.8 84.17,172.21 84.4,172.44 91.03,172.44 v2(91.47,172)
  BOTTOM w0.102: v4(151.11,140.29) 151.11,140.55 150.65,141 150.65,143.35 149.39,144.62 149.39,145.26 148.79,145.86 148.79,146.3 148.78,146.31 148.78,146.34
  BOTTOM w0.114: 148.78,146.34 148.78,146.45 146.05,149.18 131.88,149.18 129.88,151.19 122.49,151.19 121.29,152.38 121.29,155.15 119.3,157.14 113.2,157.14 111.99,157.14 101.38,167.76 96.88,172.26 91.73,172.26 v2(91.47,172)
PEG_RX_N3: length 81.4
  TOP w0.102: v4(150.2,141.21) CPU1.E12
  TOP w0.114: v2(91.47,167.98) 91.47,168.05 91.04,168.49 84.44,168.49 84.23,168.28 84.23,167.93 84.61,167.55 PCIE16X_1.A30
  BOTTOM w0.102: v4(150.2,141.21) 150.2,141.41 150.05,141.56 149.77,141.56 149.43,141.89 149.43,143.59 148.71,144.3 148.24,144.3 147.78,144.76 147.78,145.73 147.35,146.17 147.34,146.17 147.33,146.18
  BOTTOM w0.114: 147.33,146.18 145.04,148.47 131.58,148.47 129.65,150.4 122,150.4 116.68,155.72 111.38,155.72 98.67,168.43 91.9,168.43 91.47,168 v2(91.47,167.98)
PEG_RX_N4: length 80.1
  TOP w0.114: v2(91.54,161.89) 91.09,162.34 84.39,162.34 84.21,162.16 84.21,161.81 84.46,161.55 PCIE16X_1.A36 ; v4(149.28,140.29) CPU1.F11
  BOTTOM w0.102: 145.38,146.34 145.38,146.31 145.39,146.3 145.39,145.76 147.48,143.67 148.5,143.67 148.8,143.36 148.8,141.85 148.52,141.57 148.52,140.95 148.83,140.65 149.14,140.65 149.28,140.51 v4(149.28,140.29)
  BOTTOM w0.114: v2(91.54,161.89) 91.99,162.34 102.75,162.34 110.79,154.3 115.23,154.3 117.41,152.13 117.41,150.3 118.19,149.51 129.5,149.51 131.29,147.72 144.39,147.72 145.38,146.73 145.38,146.34
PEG_RX_N5: length 76.8
  TOP w0.114: v4(148.37,139.38) CPU1.G10 ; PCIE16X_1.A40 84.42,157.55 84.08,157.89 84.08,158.08 84.49,158.49 91.04,158.49 v2(91.47,158.06)
  BOTTOM w0.102: v4(148.37,139.38) 147.93,140.18 147.93,140.18 147.91,140.22 147.91,141.53 147.69,141.75 147.69,142.62 144.53,145.77 144.53,146.3 144.53,146.31 144.53,146.34
  BOTTOM w0.114: v2(91.47,158.06) 91.85,158.43 103.84,158.43 109.67,152.6 113.2,152.6 115.34,150.46 115.34,149.78 116.43,148.69 129.31,148.69 130.98,147.01 144.01,147.01 144.53,146.5 144.53,146.34
PEG_RX_N6: length 72.8
  TOP w0.102: v4(147.45,140.29) CPU1.F9
  TOP w0.114: v2(91.47,154.06) 91.09,154.45 84.42,154.45 84.17,154.2 84.17,153.84 84.46,153.55 PCIE16X_1.A44
  BOTTOM w0.102: 143.09,145.51 143.11,145.49 143.12,145.49 143.42,145.19 144.18,145.19 144.37,145.01 144.89,144.49 144.89,143.65 145.83,142.71 146.63,142.71 146.98,142.36 146.98,141.17 147.01,141.1 147.06,141.01 v4(147.45,140.29)
  BOTTOM w0.114: 143.09,145.51 142.73,145.87 142.34,146.26 130.72,146.26 129.02,147.96 113.9,147.96 111.22,150.64 109.47,150.64 105.78,154.32 91.74,154.32 v2(91.47,154.06)
PEG_RX_N7: length 70.2
  TOP w0.102: CPU1.G8 v4(146.54,140.29)
  TOP w0.114: v2(91.47,149.9) 91.06,150.31 84.36,150.31 84.18,150.13 84.18,149.87 84.49,149.55 PCIE16X_1.A48
  BOTTOM w0.102: v4(146.54,140.29) 146.15,141.01 146.1,141.11 146.09,141.12 146.09,141.54 144.3,143.33 144.3,144.23 144,144.53 142.9,144.53 142.53,144.9 142.52,144.9 142.51,144.92
  BOTTOM w0.114: v2(91.47,149.9) 91.8,150.22 96.62,150.22 96.92,150.53 100.3,150.53 v1(100.68,150.15) 101.06,150.53 106.37,150.53 109.72,147.17 128.8,147.17 130.43,145.55 141.87,145.55 142.51,144.92
PEG_RX_N8: length 64.4
  TOP w0.102: CPU1.D4 143.78,143.02 v4(143.81,143.02)
  TOP w0.114: PCIE16X_1.A53 83.19,144.75 84.04,144.75 84.39,144.41 91.06,144.41 v2(91.47,143.99)
  BOTTOM w0.102: 141.24,143.65 141.25,143.63 141.26,143.63 142.33,142.56 143.08,142.56 143.54,143.02 v4(143.81,143.02)
  BOTTOM w0.114: 141.24,143.65 140.1,144.79 131.57,144.79 131.12,144.34 127.07,144.34 125.71,145.7 101.1,145.7 99.72,144.32 91.8,144.32 v2(91.47,143.99)
PEG_RX_N9: length 66.4
  TOP w0.102: v4(143.81,142.11) 143.81,142.11 144.25,141.66 CPU1.E5
  TOP w0.114: PCIE16X_1.A57 83.19,140.75 84.11,140.75 84.44,140.42 91.09,140.42 v2(91.47,140.03)
  BOTTOM w0.102: v4(143.81,142.11) 143.54,142.11 143.08,141.65 141.97,141.65 141.55,142.07 140.28,142.07 139.99,142.36 139.98,142.36 139.97,142.38
  BOTTOM w0.114: v2(91.47,140.03) 91.8,140.35 98.7,140.35 102.62,144.28 123.32,144.28 125.44,142.16 130.34,142.16 132.25,144.08 138.27,144.08 139.97,142.38
PEG_RX_N10: length 68.9
  TOP w0.102: CPU1.F6 v4(144.71,141.21)
  TOP w0.114: PCIE16X_1.A61 83.26,136.81 83.98,136.81 84.37,136.42 91.11,136.42 v2(91.52,136.01)
  BOTTOM w0.102: 139.41,141.82 139.43,141.81 139.44,141.81 139.79,141.45 140.94,141.45 141.26,141.13 141.84,140.55 143.3,140.55 143.5,140.75 144.25,140.75 v4(144.71,141.21)
  BOTTOM w0.114: v2(91.52,136.01) 91.85,136.33 96.71,136.33 103.24,142.86 120.42,142.86 122.39,140.89 130.21,140.89 132.68,143.36 137.87,143.36 139.41,141.82
PEG_RX_N11: length 69.6
  TOP w0.102: CPU1.G5 v4(144.71,140.29)
  TOP w0.114: v2(91.47,131.99) 91.06,132.4 84.45,132.4 84.11,132.75 83.19,132.75 PCIE16X_1.A65
  BOTTOM w0.102: v4(144.71,140.29) 144.41,140.29 143.95,139.83 141.55,139.83 141.31,140.07 139.7,140.07 139.22,140.55 139.22,141 138.93,141.3 138.92,141.3 138.9,141.32
  BOTTOM w0.114: v2(91.47,131.99) 91.8,132.32 94.71,132.32 103.14,140.75 112.36,140.75 v1(112.75,140.37) 113.13,140.75 115.74,140.75 116.31,140.18 130.53,140.18 133,142.65 137.56,142.65 138.9,141.32
PEG_RX_N12: length 70.1
  TOP w0.102: CPU1.H6 v4(144.71,139.38)
  TOP w0.114: v2(91.52,128.05) 91.13,128.44 84.35,128.44 83.88,128.91 83.36,128.91 PCIE16X_1.A69
  BOTTOM w0.102: 138.27,140.68 138.29,140.66 138.29,140.66 139.57,139.39 140.71,139.39 141.02,139.08 142.13,139.08 142.58,138.63 143.16,138.63 143.45,138.92 143.98,138.92 144.44,139.38 v4(144.71,139.38)
  BOTTOM w0.114: 138.27,140.68 137.56,141.39 135.55,141.39 132.91,138.75 105.48,138.75 100.09,133.36 98.86,133.36 97.76,132.25 v1(97.76,131.73) 97.24,131.73 95.75,130.25 94.29,130.25 92.35,128.3 91.77,128.3 v2(91.52,128.05)
PEG_RX_N13: length 69.5
  TOP w0.102: CPU1.J5 v4(144.71,138.46)
  TOP w0.114: PCIE16X_1.A73 83.19,124.75 84.11,124.75 84.45,124.4 91.07,124.4 v2(91.48,123.99)
  BOTTOM w0.102: v4(144.71,138.46) 144.44,138.46 144.01,138.03 142.63,138.03 142.35,137.75 140,137.75 139.1,138.66 138.23,138.66 138.23,138.65 138.21,138.65
  BOTTOM w0.114: 138.21,138.65 137.03,138.65 135.71,137.33 106.07,137.33 93.06,124.31 91.8,124.31 v2(91.48,123.99)
PEG_RX_N14: length 72.2
  TOP w0.102: CPU1.K6 v4(144.71,137.55)
  TOP w0.114: PCIE16X_1.A77 83.3,120.86 83.88,120.86 84.3,120.44 91.14,120.44 v2(91.55,120.03)
  BOTTOM w0.102: 138.21,135.91 138.23,135.91 138.23,135.92 138.59,135.92 139.85,137.18 142.26,137.18 142.73,136.71 143.97,136.71 144.35,137.09 144.35,137.38 144.52,137.55 v4(144.71,137.55)
  BOTTOM w0.114: 138.21,135.91 106.69,135.91 97.9,127.12 97.9,126.13 95.63,123.85 95.63,122.22 93.76,120.35 91.87,120.35 v2(91.55,120.03)
PEG_RX_N15: length 74
  TOP w0.102: v4(144.71,135.72) CPU1.L5
  TOP w0.114: v2(91.6,116.31) 91.16,116.76 90.9,116.76 90.55,116.4 84.3,116.4 83.78,116.92 83.37,116.92 PCIE16X_1.A81
  BOTTOM w0.102: v4(144.71,135.72) 144.53,135.72 144.36,135.55 144.36,135.26 143.95,134.86 143.06,134.86 142.3,134.09 139.28,134.09 138.88,134.49 138.24,134.49 138.23,134.49 138.21,134.49
  BOTTOM w0.114: 138.21,134.49 107.3,134.49 100.13,127.32 100.13,126.23 97.4,123.5 97.4,120.48 93.53,116.61 91.89,116.61 v2(91.6,116.31)
PEG_RX_P0: length 90.8
  TOP w0.102: CPU1.E15 153.4,141.66 152.94,142.12 v4(152.94,142.12)
  TOP w0.114: PCIE16X_1.A16 84.5,181.55 84.18,181.24 84.18,180.91 84.36,180.73 91.03,180.73 v2(91.47,181.17)
  BOTTOM w0.102: v4(152.94,142.12) 152.76,142.12 152.68,142.2 152.68,143.43 152.43,143.68 152.43,144.64 151.68,145.4 151.2,145.4 151.01,145.58 151.01,146.3 151.02,146.31 151.02,146.34
  BOTTOM w0.114: v2(91.47,181.17) 91.35,181.05 91.35,180.85 91.62,180.58 92.28,180.58 93.42,179.45 94.1,179.45 94.26,179.29 101.38,172.17 113.24,160.31 123.08,160.31 127.3,156.08 127.3,153.89 128.21,152.98 130.4,152.98 132.54,150.85 147.04,150.85 151.02,146.86 151.02,146.34
PEG_RX_P1: length 87.7
  TOP w0.102: v4(152.02,142.12) CPU1.D14
  TOP w0.114: v2(91.47,177.1) 91.06,176.69 84.41,176.69 84.03,176.31 83.25,176.31 PCIE16X_1.A21
  BOTTOM w0.102: v4(152.02,142.12) 152.02,141.91 151.9,141.79 151.63,141.79 151.49,141.93 151.49,143.24 151.87,143.62 151.87,144.33 151.44,144.76 150.82,144.76 150.27,145.3 150.27,146.3 150.28,146.31 150.28,146.34
  BOTTOM w0.114: 150.28,146.34 150.28,146.58 146.73,150.13 132.24,150.13 130.24,152.14 127.08,152.14 120.44,158.78 112.72,158.78 101.53,169.98 94.82,176.69 91.89,176.69 v2(91.47,177.1)
