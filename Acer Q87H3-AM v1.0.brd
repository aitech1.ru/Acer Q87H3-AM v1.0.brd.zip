# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PHASE2_RC1: length 1.6
  TOP w1.016: C753.1 174.44,176.28 R842.2
PHASE3: length 20.8
  TOP w0.127: P5.2 214.86,171.42 L10.1
  TOP w0.203: U39.28 227.51,153.56 227.16,153.91 227.16,154.41 226.47,155.1 226.22,155.1
  TOP w0.635: 226.22,155.1 224.95,156.37 224.95,160.62 C750.1 225.01,162.4 v2(224.82,162.59)
  BOTTOM w0.635: v2(218.6,165.39) 222.03,165.39 v2(224.82,162.59)
  vias: v2(212,174.28) v2(213.27,174.28) v2(214.54,174.28) v2(214.92,173.01) v2(216.69,169.58) v2(216.95,173.01) v2(217.96,171.1) v2(218.6,167.93) v2(218.6,166.66) v2(218.73,174.91) v2(218.73,173.77) v2(220.76,172.12) v2(222.41,172.12) v2(222.41,170.59)
PHASE3_RC1: length 1.7
  TOP w1.016: C765.1 225.58,171.23 R869.2
PHASE4: length 9.5
  TOP w0.127: L11.1 144.24,177.45 P7.2
  TOP w0.254: 145.57,184.31 146.14,184.88 U40.8
  TOP w0.635: 145.57,184.31 145.57,183.96 R885.2 144.91,182.88 143.99,181.96 C768.1 143.99,179.67 v2(143.67,179.36)
  vias: v2(137.07,183.67) v2(137.95,174.4) v2(138.08,183.67) v2(138.21,177.2) v2(139.1,183.67) v2(139.61,177.2) v2(140.11,183.67) v2(141,177.2) v2(141.51,182.02) v2(141.51,180.75) v2(141.51,171.74) v2(141.51,170.47) v2(141.51,169.2) v2(142.27,177.83) v2(142.91,175.93) v2(145.7,178.72) v2(148.11,179.48) v2(148.11,177.07)
PHASE4_RC1: length 1.4
  TOP w1.016: C772.1 135.52,175.83 R888.2
PIRQA_L: length 12.6
  TOP w0.102: RN12.5 26.98,90.71 27.23,90.46 28.39,90.46 28.85,90 31.07,90 33.69,92.62 36.59,92.62 36.7,92.73 37.01,92.73 37.31,92.42 PCH1.AU29
PIRQB_L: length 8
  TOP w0.102: RN11.5 31.6,92.05 33.13,93.59 36.6,93.59 36.66,93.53 36.86,93.53 37.59,93.79 PCH1.AU27
PIRQC_L: length 6.8
  TOP w0.102: RN11.1 31.41,90.98 33.54,93.1 PCH1.AW28
PIRQD_L: length 6.9
  TOP w0.102: RN11.7 31.77,92.63 32.99,93.84 PCH1.AV27
PM66EN: length 35.1
  TOP w0.102: U11.122 62.44,139.28 RJ1.2 62.52,138.84 62.52,137.8 62.11,137.4 61.14,137.4 60.71,136.96 60.71,135.77 60.36,135.42 60.36,134.99 59.15,133.78 50.53,133.78 48.08,136.22 47.59,136.72 47.59,137.78 46.36,139 46.36,139.42 46.08,139.71 44.76,139.71 44.08,140.39 44.08,141.22 43.85,141.45 43.85,142.4 v2(44.1,142.65)
  BOTTOM w0.102: PCI.B49 43.2,141.75 v2(44.1,142.65)
PM_SYNC: length 403.1
  TOP w0.102: PCH1.F40 54.27,86.44 53.96,86.13 53.96,85.85 54.08,85.72 54.08,84.91 55.8,83.19 59.19,83.19 59.52,83.52 66.54,83.52 68.18,85.16 68.18,86.16 69.22,87.21 v2(69.22,88.48) ; v2(179.48,132.11) 175.2,132.11 CPU1.P36
  BOTTOM w0.102: v2(69.22,88.48) 69.58,88.83 75.49,88.83 77.78,91.12 80.28,91.12 86.6,84.8 86.6,76.18 84.44,74.02 84.44,58.88 83.73,58.17 83.73,56.8 86.67,53.86 86.67,48.16 85.4,46.89 85.4,42.68 89.24,38.84 91.13,38.84 92.49,37.49 93.12,36.86 93.12,33.05 94.7,31.48 122.64,31.48 127.05,27.07 128.04,27.07 128.86,26.25 139.81,26.25 141.64,24.42 148.85,24.42 152.05,21.22 160.01,21.22 161,20.23 164.95,20.23 165.29,20.57 165.31,20.57 165.42,20.68 165.92,20.68 166.13,20.48 177.84,20.48 179.24,21.88 191,21.88 191.81,21.06 193.53,21.06 194.2,20.4 197.26,20.4 198.33,21.47 199.09,21.47 199.96,22.33 201.28,22.33 201.51,22.56 205.66,22.56 211.05,27.95 223.39,27.95 225.43,29.99 229.66,29.99 232.82,33.15 232.82,38.03 233.94,39.15 233.94,43.06 235.21,44.33 235.21,50.69 238.77,54.24 238.77,63.92 237.59,65.1 237.59,66.65 236.19,68.05 234.61,68.05 231.25,71.41 231.25,71.87 228.07,75.05 228.07,75.78 227.72,76.13 227.72,81.22 221.65,87.29 221.65,97.96 216.95,102.66 216.95,111.41 213.65,114.71 213.65,116.62 210.47,119.79 208.64,119.79 203.87,124.57 203.87,133.13 203.36,133.64 198.76,133.64 197.92,134.47 186.85,134.47 v1(186.49,134.12) 185.91,133.54 180.91,133.54 v2(179.48,132.11)
PME_B_L: length 6.5
  TOP w0.102: R277.1 67.85,139 67.85,140.42 68.08,140.65 v1(68.08,141.1) 68.08,142.22 67.85,142.45 67.85,142.53 67.49,142.89 U11.2
PME_L: length 223.3
  TOP w0.127: v3(45.6,91.91) 46,91.52 PCH1.AA31 ; v2(34.96,157.64) 34.14,156.82 23.53,156.82 22.52,155.81 18.84,155.81 17.83,154.8 17.14,154.8 13.79,151.45 13.79,149.75 11.06,147.02 6.64,147.02 6.18,147.48 3.46,147.48 v2(3.33,147.35) ; R127.2 36.1,74.55 36.1,73.7 v2(35.37,72.98) 33.88,71.48 33.88,68.22 31.21,65.55 25.62,65.55 25.1,66.07 21.88,66.07 21.25,65.45 15.92,65.45 15.16,64.69 8.31,64.69 8.02,64.69 5.24,61.91 v2(5.24,61.58)
  BOTTOM w0.102: 43.09,87.08 43.29,87.28 43.29,88.32 43.73,88.76 43.73,89.35 43.9,89.52 43.9,90.22 44.42,90.74 44.69,90.74 44.94,90.99 44.94,91.24 v3(45.6,91.91)
  BOTTOM w0.127: v2(5.24,61.58) 5.24,61.88 4.64,62.48 4.64,63.87 1.92,66.59 1.92,142.34 3.33,143.76 v2(3.33,147.35) ; 43.09,87.08 42.78,86.77 42.78,81.6 36.84,75.66 36.31,75.66 35.37,74.72 35.37,72.98 v2(35.37,72.98) ; v2(34.96,157.64) 34.07,158.53 34.07,178.73 34.46,179.13 34.46,179.41 34.92,179.86 38.01,179.86 39.06,178.81 40.64,178.81 41.68,179.85 PCI.A19
POP: length 130.1
  TOP w0.254: R513.1 R511.1 5.84,234.98 3.72,234.98 v2(2.57,233.84) 2.32,234.09 2.32,240.19 3.97,241.84 7.65,241.84 9.08,240.41 R486.1 R483.1 11.41,240.41 11.72,240.72 12.68,240.72 R520.1 R515.1 R507.1 R503.1 16.42,240.41 16.75,240.75 17.67,240.75 18,240.41 R493.1 R487.1 R501.1 R496.1 ; v2(2.19,210.6) 2.7,211.11 2.7,212.76 2.32,213.14 2.32,215.17 2.95,215.81 8.41,215.81 v2(10.68,218.07) ; R518.2 2.19,183.39 v2(2.19,194.09) ; QP6.C v2(32.04,215.68)
  BOTTOM w0.254: v2(2.57,233.84) 1.14,232.41 1.14,213.3 2.67,211.77 2.67,211.08 v2(2.19,210.6) v2(2.19,194.09) ; v2(10.68,218.07) 10.68,220.1 12.73,222.16 18.45,222.16 v1(21.85,218.75) 23.27,217.33 30.64,217.33 32.04,215.93 v2(32.04,215.68)
POP_R: length 3.8
  TOP w0.254: QN46.B 3.97,178.09 3.72,178.34 v2(3.72,178.47) R518.1
PREQ64_1_L: length 11.8
  TOP w0.102: R293.2 46.8,131.06 45.37,132.49 44.08,132.49 43.44,131.86 41.82,131.86 40.57,130.61 v2(40.47,130.61)
  BOTTOM w0.102: v2(40.47,130.61) 40.8,130.28 40.8,128.68 41.7,127.78 PCI.A60
PROCHOT_L: length 23.3
  TOP w0.102: R38.2 197.14,140.62 195.87,139.35 v2(192.06,139.35) 183.17,139.35 179.64,135.82 177.81,135.82 177.79,135.8 177.01,135.8 CPU1.K38
PWM4: length 140.5
  TOP w0.203: 225.46,153.07 225.46,152.76 225.89,152.33 U39.31
  TOP w0.254: v2(236.96,180.82) 236.77,181.01 234.22,181.01 233.52,180.31 233.52,169.64 227.49,163.61 222.41,163.61 221.77,162.97 221.77,161.59 222.79,160.58 222.79,155.73 225.46,153.07 ; v2(148.88,182.15) 148.62,182.4 147.54,182.4 147.35,182.6 U40.3
  BOTTOM w0.254: v2(148.88,182.15) 149.28,182.15 154.68,187.55 155.35,187.55 159.63,191.83 214.26,191.83 v1(215.55,190.53) 216.76,189.33 228.82,189.33 236.96,181.19 v2(236.96,180.82)
PWR_DEBUG: length 43.1
  TOP w0.102: v2(206.15,134.27) 208.44,134.27 209.46,133.26 v2(209.46,133) ; v2(202.72,136.43) 202.55,136.25 200.78,136.25 R15.2 R17.2 198.25,136.18 183.67,136.18 180.93,133.43 CPU1.N40
  BOTTOM w0.102: v2(202.72,136.43) 203.84,136.43 v1(203.97,136.3) 205.37,134.91 205.52,134.91 v2(206.15,134.27) ; v2(209.46,133) 209.96,133.51 214.54,133.51 216.57,131.48 SR30.1
PWROK_RC: length 15.5
  TOP w0.102: PCH1.AT40 38.37,86.55 38.45,86.48 38.45,85.77 36.86,84.18 34.68,84.18 v2(34.63,84.23) 34.63,83.4 33.94,82.71 33.94,81.69 33.31,81.06 C230.1 32.72,79.81 32.72,76.85 R204.2 R200.2
R_MDI0N: length 40.9
  TOP w0.102: v2(72.04,232.46) 71.77,232.19 71.28,232.19 70.42,231.32 70.42,230.56 69.79,229.93 69.48,229.93 v1(69.12,230.28) 68.76,229.93 66.61,229.93 64.52,227.85 60.92,227.85 59.8,226.73 57.05,226.73 56.83,226.95 56.49,226.95 56.42,227.02 RLAN.4
  BOTTOM w0.102: SR7.2 82.89,217.48 81.72,217.48 80.04,219.16 80.04,226.09 73.94,232.19 72.31,232.19 v2(72.04,232.46)
R_MDI0P: length 40.9
  TOP w0.102: v2(72.04,231.57) 71.77,231.83 71.43,231.83 70.77,231.17 70.77,230.41 69.93,229.57 67.9,229.57 v1(67.47,229.14) 67.04,229.57 66.75,229.57 64.67,227.49 61.07,227.49 59.95,226.37 56.9,226.37 56.69,226.59 56.49,226.59 56.42,226.52 RLAN.3
  BOTTOM w0.102: v2(72.04,231.57) 72.31,231.83 73.79,231.83 79.69,225.94 79.69,219.01 81.57,217.13 82.94,217.13 SR8.2
R_MDI1N: length 39.2
  TOP w0.102: v2(69.5,232.2) 69.23,231.93 68.74,231.93 68.11,231.3 65.56,231.3 65.18,230.92 v1(64.68,230.92) 64.68,230.41 63.13,228.86 60.46,228.86 60.02,228.42 56.57,228.42 56.48,228.52 RLAN.7
  BOTTOM w0.102: SR9.2 80.95,215.6 80.65,215.6 80.55,215.7 80.55,217.2 78.9,218.85 78.9,225.84 73.97,230.77 71.43,230.77 70.26,231.93 69.77,231.93 v2(69.5,232.2)
R_MDI1P: length 39.2
  TOP w0.102: v2(69.5,231.31) 69.23,231.58 68.89,231.58 68.26,230.94 65.71,230.94 64.17,229.4 v1(64.17,228.89) 63.65,228.89 63.27,228.51 60.61,228.51 60.17,228.06 56.47,228.06 56.42,228.02 RLAN.6
  BOTTOM w0.102: v2(69.5,231.31) 69.77,231.58 70.11,231.58 71.28,230.41 73.82,230.41 78.54,225.69 78.54,218.71 80.19,217.06 80.19,215.55 80.5,215.25 80.98,215.25 81.28,214.95 SR10.2
R_MDI2N: length 37.2
  TOP w0.102: v2(67.47,232.84) 67.25,232.62 66.38,232.62 66.05,232.29 63.89,232.29 63.41,231.81 v1(62.9,231.81) 62.9,231.29 61.7,230.09 56.8,230.09 56.66,229.95 56.55,229.95 56.48,230.02 RLAN.10
  BOTTOM w0.102: v2(67.47,232.84) 67.69,232.62 68.3,232.62 68.87,232.06 68.87,231.04 70.16,229.75 73.51,229.75 77.86,225.41 77.86,218.24 79.15,216.94 79.15,216.1 SR11.2
R_MDI2P: length 37.2
  TOP w0.102: RLAN.9 56.47,229.52 56.55,229.6 56.81,229.6 56.95,229.74 61.84,229.74 62.14,230.03 v1(62.64,230.03) 62.64,230.54 64.04,231.93 66.2,231.93 66.53,232.26 67.32,232.26 67.47,232.11 v2(67.47,231.95)
  BOTTOM w0.102: v2(67.47,231.95) 67.47,232.06 67.67,232.26 68.16,232.26 68.51,231.91 68.51,230.89 70.01,229.39 73.37,229.39 77.5,225.26 77.5,218.09 78.8,216.8 78.8,216 78.7,215.9 SR12.2
R_MDI3N: length 48.3
  TOP w0.102: RLAN.13 56.64,231.52 56.93,231.81 60.97,231.81 61.91,232.75 61.91,233.23 62.87,234.2 63.93,234.2 64.29,233.84 64.29,233.41 v2(64.55,233.15)
  BOTTOM w0.102: SR13.2 84.9,210.6 83.85,210.6 82.05,212.4 78.75,212.4 77.63,213.52 77.63,216.95 76.74,217.84 76.74,224.94 72.95,228.73 68.84,228.73 v1(68.49,229.09) 68.13,228.73 67.62,228.73 64.29,232.06 64.29,232.9 v2(64.55,233.15)
R_MDI3P: length 48.3
  TOP w0.102: RLAN.12 56.52,231.02 56.66,231.16 56.79,231.16 57.08,231.45 61.11,231.45 62.26,232.6 62.26,233.08 63.02,233.84 63.79,233.84 63.91,233.71 63.91,233.41 v2(63.66,233.15)
  BOTTOM w0.102: SR14.2 85,210.24 83.71,210.24 81.9,212.05 78.6,212.05 77.27,213.37 77.27,216.8 76.38,217.69 76.38,224.8 72.8,228.38 70.49,228.38 v1(70.14,228.02) 69.78,228.38 67.47,228.38 63.93,231.92 63.93,232.89 v2(63.66,233.15)
RBIAS: length 3.6
  TOP w0.203: ILAN.12 74.11,211.7 74.45,211.36
  TOP w0.254: 74.45,211.36 74.58,211.23 v1(74.58,210.47) 75.36,209.69 75.45,209.69 R446.2
REFCLK14IN: length 11.1
  TOP w0.102: PCH1.AR7 38.53,104.49 38.36,104.66 38.13,104.76 37.89,104.76 37.85,104.75 37.77,104.75 37.39,104.75 37.34,104.77 36.77,104.77 36.55,104.99 33.84,104.99 31.02,107.82 31.02,108.59 30.35,109.25 R159.2
REQ0_L: length 65.5
  TOP w0.127: v2(58.71,144.2) 58.35,144.2 56.44,142.3 U11.107 56.44,140.14 56.29,139.99 55.91,139.99 54.3,138.37 53.7,138.37 R287.1 ; PCI.B18 40.33,181.12 41.27,180.18 43.08,180.18 44.38,178.89 46.82,178.89 51.47,174.23 51.47,172.5 52.43,171.53 v2(59.72,171.53)
  BOTTOM w0.127: v2(59.72,171.53) 57.54,169.35 57.54,157.15 57.8,156.88 57.8,145.52 58.24,145.09 58.24,144.74 58.71,144.27 v2(58.71,144.2)
REQ1_L: length 6.9
  TOP w0.102: U11.102 54.44,140.04 54.24,139.83 52.37,139.83 51.97,139.43 50.51,139.43 v1(50.22,139.15) 49.82,138.74 R977.1
RJ45_P19: length 10.1
  TOP w0.508: C495.1 100.71,220.79 C496.2 101.54,220.79 101.94,221.19 v2(101.94,221.39)
  BOTTOM w0.508: v2(101.94,221.39) 104.93,221.39 108.21,224.67 USB3_LAN.19
RLAN_CLKN: length 219.7
  TOP w0.102: v3(47.64,102.47) 47.48,102.47 PCH1.W11 ; v2(88.08,195.61) 87.78,195.31 87.62,195.31 87.51,195.42 87.51,198.94 85.88,200.57 56.55,200.57 55.66,201.45 55.66,203.13 48.65,210.14 39.86,210.14 37.68,212.32 37.68,217.4 40.42,220.15 40.42,235.26 41.92,236.76 42.81,236.76 43.97,237.93 43.97,238.54 44.3,238.87 49.63,238.87 50.58,237.93 50.58,235.34 50.47,235.23 50.47,234.37 50.34,234.25 RLAN.27
  BOTTOM w0.102: v3(47.64,102.47) 47.33,102.47 47.15,102.65 47.15,103.03 46.64,103.54 46.64,107.22 45.98,107.88 45.98,108.09 45.96,108.12 45.96,109.34 48.24,111.63 48.24,112.02 48.29,112.07 48.29,115.37 50.53,117.61 50.53,122.41 51.62,123.5 51.62,129.51 57.92,135.81 57.92,136.43 62.14,140.64 62.14,152.05 62.97,152.89 62.97,156.67 62.14,157.51 62.14,165.64 68.11,171.61 70.64,171.61 72.04,173.01 72.04,181.64 74.81,184.41 74.81,186.6 75.57,187.36 v1(76.08,187.36) 76.08,187.87 77.6,189.39 77.6,190.18 77.83,190.41 79.03,190.41 80.04,191.42 83.47,191.42 84.49,192.44 85.88,192.44 87.69,194.24 87.69,195.27 88.03,195.61 v2(88.08,195.61)
RLAN_CLKP: length 219.7
  TOP w0.102: PCH1.W10 47.11,102.68 46.87,102.44 v3(46.64,102.44) ; RLAN.26 50.84,234.25 50.72,234.37 50.72,235.13 50.83,235.24 50.83,238.03 49.74,239.12 44.2,239.12 43.72,238.64 43.72,238.03 42.7,237.01 41.82,237.01 40.16,235.36 40.16,220.25 37.42,217.51 37.42,212.22 39.75,209.89 48.55,209.89 55.4,203.03 55.4,201.35 56.44,200.31 85.78,200.31 87.26,198.83 87.26,195.87 v2(87,195.61)
  BOTTOM w0.102: v2(87,195.61) 87.28,195.61 87.43,195.46 87.43,194.35 85.78,192.69 84.38,192.69 83.37,191.68 79.94,191.68 78.92,190.66 77.73,190.66 77.35,190.28 77.35,189.49 76.94,189.08 v1(76.44,189.08) 76.44,188.58 74.56,186.7 74.56,184.52 71.79,181.75 71.79,173.11 70.54,171.86 68,171.86 61.88,165.74 61.88,157.4 62.72,156.56 62.72,153 61.88,152.16 61.88,140.75 57.67,136.53 57.67,135.91 51.37,129.61 51.37,123.61 50.27,122.52 50.27,117.71 48.04,115.48 48.04,111.71 45.75,109.43 45.75,108.03 45.78,108.01 45.78,107.8 46.44,107.14 46.44,103.45 46.95,102.95 46.95,102.57 46.82,102.44 v3(46.64,102.44)
RLAN_R_RST: length 7.7
  TOP w0.102: v1(55.48,238.89) 56.17,238.21 56.17,237.3 R452.1 C461.2 55.66,236.2 54.97,235.52 54.54,235.52 53.84,234.82 RLAN.20
RLAN_RST: length 27.7
  TOP w0.102: v2(56.17,239.43) 56.67,238.92 R452.2
  BOTTOM w0.102: v2(56.17,239.43) 56.7,239.96 63.82,239.96 64.29,239.49 64.29,234.73 62.95,233.38 62.95,231.88 64.42,230.41 v1(64.42,229.34) 64.42,225.14 63.91,224.63 SR59.2
RLAN_RXN: length 34.8
  TOP w0.102: v2(46.11,238.06) 46.44,237.73 46.44,237.4 46.3,237.26 C481.2
  BOTTOM w0.102: v2(46.11,238.06) 46.43,238.38 46.43,239 46.81,239.38 49.04,239.38 51.45,236.96 59.43,236.96 61.48,234.91 61.48,229.7 v1(61.83,229.34) 61.48,228.99 61.48,220.81 61.19,220.53 60.99,220.53 SR3.2
RLAN_RXN_C: length 5.1
  TOP w0.102: RLAN.30 48.84,234.22 48.99,234.37 48.99,234.91 48.67,235.24 46.66,235.24 46.4,235.49 46.4,235.89 C481.1
RLAN_RXP: length 34.8
  TOP w0.102: v2(47.06,238.06) 46.93,238.06 46.64,237.77 46.64,237.37 46.75,237.26 C482.2
  BOTTOM w0.102: SR2.2 60.46,221.15 60.46,220.89 60.61,220.73 61.11,220.73 61.27,220.9 61.27,230.72 v1(60.92,231.07) 61.27,231.43 61.27,234.83 59.34,236.76 51.37,236.76 48.95,239.17 46.9,239.17 46.64,238.91 46.64,238.32 46.9,238.06 v2(47.06,238.06)
RLAN_RXP_C: length 5.1
  TOP w0.102: C482.1 46.61,235.92 46.61,235.58 46.74,235.44 48.75,235.44 49.2,234.99 49.2,234.37 49.34,234.22 RLAN.29
RLAN_TXN: length 38.1
  TOP w0.102: C480.1 51.77,237.54 52,237.77 52,237.93 v2(51.62,238.31)
  BOTTOM w0.102: v2(51.62,238.31) 51.94,238.63 51.94,239.39 52.43,239.88 54.64,239.88 55.86,238.67 56.47,238.67 57.28,239.48 61.58,239.48 63.66,237.4 63.66,234.98 62.16,233.48 62.16,231.55 63.25,230.46 63.25,226.02 v1(63.61,225.66) 63.25,225.31 63.25,224.95 62.16,223.86 62.16,218.96 61.47,218.27 60.94,218.27 SR6.2
RLAN_TXN_C: length 3.1
  TOP w0.102: C480.2 51.99,236.19 51.99,234.37 51.84,234.22 RLAN.24
RLAN_TXP: length 38.1
  TOP w0.102: C479.1 52.43,237.54 52.2,237.77 52.2,237.93 v2(52.59,238.31)
  BOTTOM w0.102: SR5.2 60.66,219.11 60.48,218.93 60.48,218.62 60.64,218.47 61.39,218.47 61.96,219.04 61.96,223.94 63.05,225.03 63.05,227.03 v1(62.69,227.39) 63.05,227.74 63.05,230.38 61.96,231.47 61.96,233.57 63.46,235.07 63.46,237.31 61.49,239.28 57.37,239.28 56.56,238.46 55.78,238.46 54.56,239.68 52.52,239.68 52.14,239.31 52.14,238.5 52.33,238.31 v2(52.59,238.31)
RLAN_TXP_C: length 3.2
  TOP w0.102: C479.2 52.2,236.17 52.2,234.37 52.34,234.22 RLAN.23
RLAN_WAKE_L: length 9
  TOP w0.102: RLAN.19 54.34,234.94 54.69,235.29 55.13,235.29 56.17,236.33 57.23,236.33 R694.2 R461.1 58.2,237.3 v1(58.2,239.22)
ROM_CS_L0: length 27.4
  TOP w0.102: v2(20.33,9.35) 20.07,9.61 17.74,9.61 17.63,9.5 17.63,9.08 15.86,7.3 15.86,4.99 15.48,4.6 SPI_DEBUG.1 ; SPIROM1.1 26.17,3.91 25.6,4.48 22.97,4.48 arc(22.79,4.66) 22.97,4.83 25.36,4.83 25.51,4.99 25.51,7.86 R325.2 24,9.21 v2(23.43,9.79)
  BOTTOM w0.102: v2(20.33,9.35) 20.73,9.76 23.4,9.76 v2(23.43,9.79)
ROM_CS_L1: length 36.8
  TOP w0.102: SPIROM2.1 41.11,3.91 40.47,4.55 40.47,6.19 v2(38.28,8.38) ; v2(25.25,12.3) 24.91,12.64 R326.2 23.5,12.1 21.08,12.1 20.43,11.45 19.39,11.45 18.07,12.76 16.16,12.76 15.91,12.51 15.91,11.59 15.27,10.95 SPI_DEBUG.11
  BOTTOM w0.102: v2(25.25,12.3) 24.92,11.98 24.92,11.13 25.48,10.57 30.84,10.57 31.68,11.41 32.34,11.41 35.14,8.62 36.81,8.62 37.24,9.05 37.61,9.05 v2(38.28,8.38)
RREF_8893: length 3.7
  TOP w0.102: U11.16 68.4,148.49 v1(68.74,148.83) 69.08,149.16 R279.2
RSET: length 2.3
  TOP w0.102: RLAN.64 55.34,224.55 56.5,223.39 R451.1
RSMRST_L: length 349
  TOP w0.102: v2(185.33,9.94) 185.45,9.94 187.08,8.31 187.08,6.56 186.75,6.23 186.63,6.23 186.24,5.84 186.24,4.5 186.72,4.02 190.63,4.02 191.24,4.63 191.24,6.71 191.62,7.08 193.25,7.08 193.73,7.56 195.95,7.56 197.01,8.62 201.18,8.62 201.66,9.1 208.36,9.1 208.69,9.43 208.69,10.45 208.5,10.64 208.5,11.91 208.69,12.1 208.69,12.89 R356.1 C678.1 210.54,14 211.36,14.83 213.77,14.83 213.98,15.04 U21.85 ; v2(11.65,65.88) 12.39,66.62 14.99,66.62 16.97,68.6 19.36,68.6 C691.1 20.13,68.36 20.95,68.36 21.11,68.52 21.11,68.99 21.65,69.53 24.41,69.53 R761.1 25.43,70.01 26.35,69.1 26.35,68.41 26.46,68.3 26.46,66.99 27.43,66.02 31.05,66.02 33.42,68.39 33.42,71.65 34.69,72.92 34.69,73.45 35.52,74.28 35.52,75.4 36.02,75.9 36.02,76.28 36.96,77.22 36.96,78.01 36.76,78.21 36.33,78.21 36.32,78.23 36.29,78.23 36.02,78.49 36.02,79.64 36.15,79.77 36.15,79.96 R198.2 36.58,81.81 40.43,85.65 40.43,86.62 PCH1.AM40
  BOTTOM w0.102: v2(11.65,65.88) 11.46,65.69 11.46,58.86 9.28,56.68 9.28,37.77 7.65,36.14 7.43,36.14 7.17,35.88 7.17,35.19 7.73,34.63 7.73,30.49 6.12,28.88 6.12,9.36 11.19,4.29 51.24,4.29 54.01,7.07 59.64,7.07 63.5,3.2 71.81,3.2 72.88,4.27 72.88,9.37 72.97,9.46 72.97,9.49 77.33,13.85 84.56,13.85 84.59,13.88 84.59,13.88 85.37,14.65 89.3,14.65 v1(90.33,13.62) 91.68,12.28 102.01,12.28 102.49,12.76 110.5,12.76 112.02,14.28 140.71,14.28 144.47,10.52 161.07,10.52 161.4,10.19 185.07,10.19 v2(185.33,9.94)
RST_SEL: length 3.2
  TOP w0.102: R286.1 49.12,144.79 49.66,144.79 49.97,144.49 U11.91
RSTIN_L: length 5.2
  TOP w0.102: R354.1 223.16,36.01 222.36,35.21 222.36,34.22 v1(222.28,34.14) 221.48,33.34 U21.3
RTCRST_L: length 47.4
  TOP w0.102: v3(38.32,87.35) 38.66,87.68 PCH1.AR38 ; v2(25.58,73.08) 25.58,72.37 24.88,71.67 24.29,71.67 23.63,72.32 21.57,72.32 21.5,72.4 20.39,72.4 18.1,70.11 15.09,70.11 15.08,70.1 15.07,70.1 14.7,69.73 8.82,69.73 8.45,70.1 R251.1 7.24,70.1 C238.2
  BOTTOM w0.102: v2(25.58,73.08) 25.28,73.08 24.44,73.92 24.44,78.34 25.61,79.51 26.8,79.51 v1(28.35,81.06) 29,81.71 31.38,81.71 32.16,82.48 32.16,82.7 33.15,83.7 36.96,83.7 38.41,85.15 38.41,87.26 v3(38.32,87.35)
SATA3_RX_N0: length 104.5
  TOP w0.102: PCH1.B28 56.92,93.27 56.98,93.3 58.08,93.3 58.38,93 59.09,93 61.53,90.56 62.64,90.56 v3(62.92,90.84) ; v2(33.23,20.47) 33.59,20.82 33.76,20.82 C205.1
  BOTTOM w0.102: v3(62.92,90.84) 62.92,91.14 63.23,91.45 64.32,91.45 65.01,90.76 65.01,87.43 71.04,81.4 71.04,69.77 58.99,57.72 56.87,57.72 44.86,45.71 44.86,44.86 v1(45.31,44.42) 44.86,43.97 44.86,32.29 40.8,28.23 38.89,28.23 37.37,26.7 37.37,24.29 36.96,23.88 36.96,22.49 34.96,20.48 33.24,20.48 v2(33.23,20.47)
SATA3_RX_N0_C: length 5.7
  TOP w0.102: C205.2 35.65,20.82 39.66,20.82 SATA1.5
SATA3_RX_N1: length 98
  TOP w0.102: v2(35.41,24.14) 35.06,24.49 34.78,24.49 34.54,24.26 C213.1 ; v3(62.82,89.83) 62.21,89.83 61.99,90.05 61.27,90.05 58.83,92.49 58.08,92.49 57.93,92.64 56.86,92.64 56.59,92.71 56.3,92.71 56.24,92.67 56.08,92.57 55.5,92.57 55.16,92.23 PCH1.D30
  BOTTOM w0.102: v2(35.41,24.14) 35.67,24.39 35.82,24.39 36.23,24.8 36.23,28.26 36.45,28.48 v1(36.99,28.48) 36.99,29.02 37.16,29.19 40.53,29.19 43.97,32.64 43.97,45.98 56.62,58.63 58.73,58.63 70.15,70.05 70.15,81.02 64.29,86.88 64.29,89.44 63.84,89.89 63.22,89.89 63.15,89.83 v3(62.82,89.83)
SATA3_RX_N1_C: length 6.5
  TOP w0.102: C213.2 33.12,24.51 32.63,24.51 32.24,24.11 32.24,21.15 31.91,20.83 31.61,20.83 SATA2.5
SATA3_RX_N2: length 78.4
  TOP w0.102: PCH1.A31 56.9,91.66 56.9,91.56 56.99,91.48 57.57,91.48 57.69,91.6 58.99,91.6 60.46,90.13 60.46,89.79 60.83,89.42 v3(61.09,89.42) ; v2(32.89,40.53) 33.23,40.88 33.59,40.88 C221.1
  BOTTOM w0.102: v2(32.89,40.53) 33.17,40.81 33.86,40.81 34.67,41.63 v1(35.34,41.63) 35.34,42.29 36.23,43.18 36.23,45.5 39.02,48.29 41.64,48.29 55.28,61.93 57.14,61.93 66.61,71.4 66.61,79.8 64.26,82.15 63.08,82.15 59.16,86.07 59.16,88.04 59.48,88.36 60.29,88.36 60.74,88.81 60.74,89.06 v3(61.09,89.42)
SATA3_RX_N2_C: length 5.9
  TOP w0.102: SATA3.5 39.66,40.89 35.53,40.89 C221.2
SATA3_RX_N3: length 82.8
  TOP w0.102: v2(23.53,40.49) 23.91,40.88 24.39,40.88 24.58,40.69 C204.1 ; v3(59.01,90.48) 58.91,90.48 58.4,90.99 58.4,91 56.72,91 56.64,90.91 56.42,90.91 56.37,90.96 PCH1.B32
  BOTTOM w0.102: v2(23.53,40.49) 23.81,40.77 24.71,40.77 26.32,42.39 v1(26.96,42.39) 26.96,43.02 28.1,44.17 28.1,45.73 29.7,47.33 31.35,47.33 32.7,45.98 34.41,45.98 38.55,50.12 41.11,50.12 54.57,63.58 56.25,63.58 64.73,72.06 64.73,75.17 62.52,77.38 62.52,80.33 58.15,84.7 58.15,89.1 58.86,89.81 58.86,90.33 v3(59.01,90.48)
SATA3_RX_N3_C: length 5.8
  TOP w0.102: C204.2 26,40.89 30.16,40.89 SATA4.5
SATA3_RX_N4: length 103.5
  TOP w0.102: PCH1.A26 56.87,94.29 56.78,94.2 56.78,94.04 56.9,93.92 58.35,93.92 58.69,93.58 61.04,93.58 61.75,92.87 61.75,92.2 61.42,91.87 v3(61.42,91.44) ; v2(25.99,20.47) 25.63,20.82 25.31,20.82 25.15,20.66 C841.1
  BOTTOM w0.102: v2(25.99,20.47) 26.3,20.78 26.69,20.78 26.91,21 26.91,27.6 31.22,31.92 31.22,34.75 32.21,35.74 32.21,42.64 32.66,43.09 v1(33.24,43.09) 33.24,43.66 38.76,49.18 41.37,49.18 54.96,62.77 56.71,62.77 65.56,71.63 65.56,75.55 63.33,77.78 63.33,81.13 58.66,85.81 58.66,88.88 59.72,89.95 59.72,90.2 60.96,91.44 v3(61.42,91.44)
SATA3_RX_N4_C: length 3.3
  TOP w0.102: SATA5.5 22.09,20.82 23.72,20.82 C841.2
SATA3_RX_P0: length 104.5
  TOP w0.102: PCH1.A28 57.12,93.09 58,93.09 58.3,92.79 59,92.79 61.44,90.35 63.3,90.35 63.61,90.66 v3(63.61,90.84) ; C207.1 34.23,21.22 34.03,21.03 33.52,21.03 33.23,21.32 v2(33.23,21.38)
  BOTTOM w0.102: v2(33.23,21.38) 33.08,21.23 33.08,20.99 33.14,20.92 33.43,20.92 33.67,20.68 34.87,20.68 35.66,21.47 v1(35.66,22.07) 36.26,22.07 36.76,22.57 36.76,23.97 37.17,24.37 37.17,26.79 38.81,28.43 40.72,28.43 44.66,32.37 44.66,45.8 56.78,57.92 58.9,57.92 70.84,69.85 70.84,81.32 64.8,87.35 64.8,90.68 64.24,91.24 63.31,91.24 63.25,91.18 63.25,91.08 63.49,90.84 v3(63.61,90.84)
SATA3_RX_P0_C: length 5.7
  TOP w0.102: C207.2 35.65,21.03 39.65,21.03 SATA1.6
SATA3_RX_P1: length 98
  TOP w0.102: C215.1 34.54,24.83 34.68,24.7 35.06,24.7 v2(35.41,25.05) ; v3(63.43,89.14) 63.15,89.42 62.65,89.42 62.45,89.62 62.13,89.62 61.91,89.85 61.19,89.85 58.75,92.29 58,92.29 57.84,92.44 56.83,92.44 56.56,92.5 56.36,92.5 56.28,92.45 56.13,92.37 55.75,92.37 PCH1.C30
  BOTTOM w0.102: v3(63.43,89.14) 63.18,89.39 63.18,89.56 63.3,89.69 63.76,89.69 64.09,89.36 64.09,88.41 v1(63.66,87.98) 64.09,87.55 64.09,86.79 69.95,80.94 69.95,70.13 58.65,58.83 56.54,58.83 43.77,46.07 43.77,32.72 40.44,29.39 37.08,29.39 36.02,28.34 36.02,24.88 35.74,24.59 35.54,24.59 35.41,24.72 v2(35.41,25.05)
SATA3_RX_P1_C: length 6.5
  TOP w0.102: SATA2.6 31.61,21.03 31.83,21.03 32.04,21.24 32.04,24.2 32.55,24.71 33.12,24.71 C215.2
SATA3_RX_P2: length 78.3
  TOP w0.102: PCH1.B31 56.48,91.7 56.91,91.27 57.65,91.27 57.77,91.4 58.91,91.4 60.26,90.05 v3(60.26,89.42) ; v2(32.89,41.45) 33.26,41.08 33.62,41.08 C223.1
  BOTTOM w0.102: v3(60.26,89.42) 60.54,89.14 60.54,88.89 60.21,88.56 59.4,88.56 58.96,88.13 58.96,85.99 63,81.95 64.17,81.95 66.4,79.72 66.4,71.48 57.06,62.14 55.19,62.14 41.55,48.5 38.94,48.5 36.02,45.58 36.02,45.04 v1(35.59,44.61) 36.02,44.18 36.02,43.26 33.78,41.02 33.07,41.02 32.89,41.19 v2(32.89,41.45)
SATA3_RX_P2_C: length 5.9
  TOP w0.102: SATA3.6 39.61,41.1 35.47,41.1 C223.2
SATA3_RX_P3: length 82.7
  TOP w0.102: PCH1.C32 55.94,91.07 56.29,90.71 56.73,90.71 56.81,90.79 58.02,90.79 v3(58.33,90.49) ; v2(23.53,41.41) 23.86,41.08 24.37,41.08 24.58,41.28 C206.1
  BOTTOM w0.102: v2(23.53,41.41) 23.53,41.21 23.76,40.98 24.62,40.98 25.12,41.47 v1(25.12,42.07) 25.72,42.07 27.9,44.25 27.9,45.81 29.62,47.53 31.44,47.53 32.78,46.18 34.33,46.18 38.47,50.32 41.03,50.32 54.49,63.79 56.17,63.79 64.52,72.14 64.52,75.09 62.31,77.3 62.31,80.25 57.94,84.61 57.94,89.19 58.66,89.9 58.66,90.16 v3(58.33,90.49)
SATA3_RX_P3_C: length 5.9
  TOP w0.102: SATA4.6 30.11,41.1 25.99,41.1 C206.2
SATA3_RX_P4: length 103.6
  TOP w0.102: v3(60.85,92.01) 61.28,92.01 61.55,92.29 61.55,92.79 60.96,93.38 58.6,93.38 58.26,93.72 56.81,93.72 56.31,94.23 PCH1.B26 ; v2(25.99,21.38) 25.63,21.03 25.31,21.03 25.15,21.18 C842.1
  BOTTOM w0.102: v2(25.99,21.38) 25.99,21.09 26.09,20.99 26.6,20.99 26.7,21.09 26.7,27.69 31.02,32.01 31.02,34.83 32.01,35.82 32.01,42.72 33.5,44.21 v1(33.5,44.86) 34.16,44.86 38.68,49.38 41.28,49.38 54.87,62.97 56.62,62.97 65.36,71.71 65.36,75.46 63.13,77.7 63.13,81.05 58.45,85.72 58.45,88.97 59.52,90.03 59.52,90.29 60.85,91.62 v3(60.85,92.01)
SATA3_RX_P4_C: length 3.3
  TOP w0.102: SATA5.6 22.1,21.03 23.72,21.03 C842.2
SATA3_TX_N0: length 119
  TOP w0.102: PCH1.F31 54.31,92.07 v3(54.31,92.36) ; v2(33.27,15.79) 33.62,15.44 33.76,15.44 C203.1
  BOTTOM w0.102: v3(54.31,92.36) 54.19,92.36 54.03,92.21 54.03,91.96 54.12,91.88 54.92,91.88 56.27,93.23 61.58,93.23 62.85,91.96 64.68,91.96 65.82,90.82 65.82,88.11 66.39,87.54 v1(67.09,87.54) 67.09,86.84 72.3,81.63 72.3,69.87 59.22,56.8 57.11,56.8 53.25,52.93 53.25,47.02 52.13,45.9 48.73,45.9 45.75,42.92 45.75,31.78 41.31,27.34 39.28,27.34 38.26,26.32 38.26,23.87 37.78,23.39 37.78,22.03 37.24,21.5 37.24,17.14 36.18,16.09 34.59,16.09 34.09,16.59 32.78,16.59 32.54,16.36 32.54,15.71 32.82,15.44 33.13,15.44 33.27,15.58 v2(33.27,15.79)
SATA3_TX_N0_C: length 6.5
  TOP w0.102: C203.2 35.64,15.45 36.5,15.45 38.28,17.23 39.65,17.23 SATA1.3
SATA3_TX_N1: length 105.4
  TOP w0.102: PCH1.B34 56.66,89.65 56.78,89.77 57.42,89.77 58.81,88.37 59.24,88.37 59.7,87.92 61.59,87.92 62.2,87.31 62.83,87.31 v3(63.28,86.86) ; v2(35.59,18.19) 35.24,17.84 35.03,17.84 C211.1
  BOTTOM w0.102: v3(63.28,86.86) 62.87,86.45 62.87,85.97 63.74,85.1 64.8,85.1 69.31,80.59 69.31,70.38 58.38,59.44 56.28,59.44 43.09,46.25 43.09,32.93 40.16,30 34.7,30 33.31,28.61 v1(33.31,27.91) 32.61,27.91 32.21,27.52 32.21,18.68 33.16,17.74 35.39,17.74 35.59,17.94 v2(35.59,18.19)
SATA3_TX_N1_C: length 3.5
  TOP w0.102: SATA2.3 31.64,17.2 31.93,17.2 32.58,17.85 33.12,17.85 C211.2
SATA3_TX_N2: length 82.5
  TOP w0.102: v2(33.08,34.06) 33.44,33.7 33.6,33.7 C219.1 ; v3(60.51,86.7) 60.27,86.7 60.06,86.91 59.87,87.1 59.71,87.1 59.02,87.79 57.85,87.79 56.59,89.05 56.13,89.05 PCH1.B35
  BOTTOM w0.102: v2(33.08,34.06) 32.73,33.7 32.62,33.7 32.29,34.03 32.29,34.58 34.96,37.24 v1(35.59,37.24) 35.59,37.88 37.24,39.53 37.24,45.36 39.28,47.4 41.92,47.4 55.63,61.12 57.69,61.12 67.49,70.92 67.49,80.07 64.6,82.96 63.19,82.96 60.05,86.1 60.05,86.47 60.28,86.7 v3(60.51,86.7)
SATA3_TX_N2_C: length 8.5
  TOP w0.102: SATA3.3 39.68,37.37 37.62,37.37 36.23,35.97 36.23,34.07 35.86,33.7 35.5,33.7 C219.2
SATA3_TX_N3: length 87.8
  TOP w0.102: v2(23.63,37.62) 23.63,37.62 23.98,37.27 24.29,37.27 24.58,37.55 C202.1 ; PCH1.G33 53.58,90.57 53.58,90.12 v3(53.67,90.03)
  BOTTOM w0.102: v3(53.67,90.03) 53.98,89.72 53.98,89.56 54.46,89.08 55.52,89.08 56.73,87.88 56.73,84.37 57.31,83.79 v1(57.31,83.15) 57.94,83.15 61.42,79.67 61.42,77.04 63.14,75.32 63.14,71.94 60.58,69.37 57.94,69.37 56.04,67.47 55.04,67.47 54.44,66.87 54.44,64.98 40.62,51.16 38.15,51.16 33.99,47 33.24,47 31.89,48.34 29.17,48.34 22.56,41.74 22.56,39.1 23.1,38.56 24.33,38.56 24.67,38.23 24.67,37.35 24.52,37.19 23.78,37.19 23.63,37.35 v2(23.63,37.62)
SATA3_TX_N3_C: length 5.9
  TOP w0.102: SATA4.3 30.1,37.29 25.99,37.29 C202.2
SATA3_TX_N4: length 117.8
  TOP w0.102: v2(26.19,17.56) 25.84,17.2 25.63,17.2 C840.1 ; PCH1.L28 51.72,92.71 51.72,92.56 v3(51.52,92.36)
  BOTTOM w0.102: v3(51.52,92.36) 51.72,92.16 51.72,91.31 52.51,90.52 54.74,90.52 56.73,92.51 61.19,92.51 62.06,91.64 62.06,88.51 61.32,87.77 61.32,85.76 63.1,83.98 64.46,83.98 68.23,80.21 68.23,70.78 57.91,60.46 55.85,60.46 41.87,46.47 41.87,33.26 39.7,31.1 32.46,31.1 29.59,28.23 v1(28.99,28.23) 28.99,27.63 27.52,26.15 27.52,17.61 27.01,17.1 26.37,17.1 26.19,17.28 v2(26.19,17.56)
SATA3_TX_N4_C: length 3.3
  TOP w0.102: SATA5.3 22.11,17.22 23.72,17.22 C840.2
SATA3_TX_P0: length 119
  TOP w0.102: v2(33.27,14.88) 33.62,15.23 33.76,15.23 C201.1 ; PCH1.H31 53.55,92.07 v3(53.55,92.36)
  BOTTOM w0.102: v2(33.27,14.88) 32.91,15.23 32.74,15.23 32.34,15.63 32.34,16.44 32.7,16.8 34.17,16.8 34.68,16.29 36.1,16.29 37.04,17.23 37.04,21.58 37.57,22.11 37.57,23.48 38.06,23.96 38.06,26.41 39.19,27.54 41.22,27.54 45.55,31.87 45.55,43.01 48.65,46.11 52.04,46.11 53.04,47.11 53.04,53.02 57.03,57 59.14,57 72.09,69.96 72.09,77.32 v1(71.72,77.69) 72.09,78.06 72.09,81.55 65.62,88.02 65.62,90.74 64.6,91.75 62.77,91.75 61.5,93.02 56.35,93.02 55.01,91.68 54.03,91.68 53.83,91.88 53.83,92.08 v3(53.55,92.36)
SATA3_TX_P0_C: length 6.5
  TOP w0.102: SATA1.2 39.65,17.03 38.36,17.03 36.58,15.24 35.66,15.24 C201.2
SATA3_TX_P1: length 105.5
  TOP w0.102: PCH1.C34 55.91,89.7 55.92,89.7 56.29,89.32 56.62,89.32 56.86,89.57 57.33,89.57 58.73,88.17 59.16,88.17 59.61,87.71 61.51,87.71 v3(62.36,86.86) ; C209.1 35,17.63 35.24,17.63 v2(35.59,17.28)
  BOTTOM w0.102: v2(35.59,17.28) 35.34,17.53 33.08,17.53 32.01,18.6 32.01,27.6 33.56,29.15 v1(33.56,29.75) 34.16,29.75 34.62,30.21 40.08,30.21 42.88,33.01 42.88,46.34 56.19,59.65 58.29,59.65 69.11,70.46 69.11,80.5 64.72,84.89 63.66,84.89 62.67,85.88 62.67,86.55 v3(62.36,86.86)
SATA3_TX_P1_C: length 3.5
  TOP w0.102: SATA2.2 31.6,17 32.02,17 32.67,17.65 33.12,17.65 C209.2
SATA3_TX_P2: length 82.5
  TOP w0.102: v3(59.7,86.7) 59.7,86.82 58.94,87.59 57.76,87.59 56.51,88.84 55.9,88.84 55.81,88.93 PCH1.D35 ; v2(33.08,33.14) 33.44,33.5 33.6,33.5 C217.1
  BOTTOM w0.102: v3(59.7,86.7) 59.85,86.54 59.85,86.01 63.1,82.76 64.51,82.76 67.29,79.98 67.29,71.01 57.61,61.32 55.55,61.32 41.83,47.61 39.2,47.61 37.04,45.45 37.04,39.61 34.42,36.99 v1(33.81,36.99) 33.81,36.39 32.09,34.66 32.09,33.95 32.54,33.5 32.73,33.5 v2(33.08,33.14)
SATA3_TX_P2_C: length 8.5
  TOP w0.102: C217.2 35.5,33.5 35.94,33.5 36.43,33.98 36.43,35.89 37.71,37.17 39.58,37.17 SATA3.2
SATA3_TX_P3: length 87.8
  TOP w0.102: v2(23.63,36.71) 23.98,37.07 24.31,37.07 24.58,36.81 C200.1 ; PCH1.F33 54.28,90.19 v3(54.43,90.04)
  BOTTOM w0.102: v2(23.63,36.71) 23.91,36.99 24.6,36.99 24.87,37.26 24.87,38.31 24.42,38.77 23.18,38.77 22.77,39.18 22.77,41.65 29.25,48.14 31.81,48.14 33.15,46.79 34.07,46.79 38.24,50.96 40.71,50.96 54.64,64.9 54.64,66.78 55.13,67.27 56.12,67.27 58.03,69.17 60.66,69.17 63.34,71.85 63.34,73.44 v1(63.72,73.82) 63.34,74.2 63.34,75.41 61.63,77.12 61.63,79.76 56.93,84.46 56.93,87.97 55.61,89.29 54.54,89.29 54.19,89.64 54.19,89.79 v3(54.43,90.04)
SATA3_TX_P3_C: length 5.8
  TOP w0.102: C200.2 26,37.08 30.16,37.08 SATA4.2
SATA3_TX_P4: length 117.9
  TOP w0.102: C839.1 25.6,17 25.84,17 v2(26.19,16.64) ; v3(52.17,92.35) 51.92,92.6 51.92,92.78 PCH1.K28
  BOTTOM w0.102: v3(52.17,92.35) 51.92,92.11 51.92,91.4 52.6,90.72 54.66,90.72 56.65,92.72 61.27,92.72 62.26,91.73 62.26,88.42 61.53,87.69 61.53,85.84 63.19,84.18 64.55,84.18 68.43,80.3 68.43,70.7 58,60.26 55.94,60.26 42.07,46.39 42.07,33.18 39.78,30.89 32.54,30.89 30.77,29.12 v1(30.77,28.42) 30.07,28.42 27.72,26.07 27.72,17.52 27.09,16.9 26.45,16.9 v2(26.19,16.64)
SATA3_TX_P4_C: length 3.3
  TOP w0.102: SATA5.2 22.09,17.01 23.72,17.01 C839.2
SATA_RCOMP: length 9
  TOP w0.102: R166.1 62.52,88.25 59.82,88.25 59.39,88.68 58.94,88.68 57.54,90.08 56.65,90.08 56.59,90.01 55.34,90.01 PCH1.D33
SATALED_L: length 103.2
  TOP w0.089: 52.54,85.7 52.5,85.74 52.5,86.21 52.53,86.23 52.53,86.24
  TOP w0.102: 52.53,86.24 52.53,87.08 PCH1.J39 ; 52.54,85.7 52.66,85.58 52.66,85.2 52.86,85 52.86,84.4 55.13,82.14 55.13,81.8 55.51,81.41 56.12,81.41 56.78,82.07 60.19,82.07 62.56,79.71 64.12,79.71 64.22,79.61 64.22,78.62 64.52,78.32 65.39,78.32 R165.1 66.61,78.26 67.01,78.26 67.27,78.01 67.27,77.02 64.2,73.95 62.19,73.95 v2(62.03,74.1) ; QN43.E 11.49,50.12 12.3,49.31 13.34,49.31 R397.1 16.16,46.48 16.16,41.82 v2(17.18,40.8)
  BOTTOM w0.102: v2(62.03,74.1) 62.47,73.67 62.47,72.12 60.33,69.98 57.69,69.98 57.41,69.7 54.77,69.7 53.42,68.35 v1(53.42,67.8) 52.87,67.8 50.38,65.31 48.56,65.31 33.91,50.66 28.28,50.66 18.42,40.8 v2(17.18,40.8)
SATALED_L_B: length 3
  TOP w0.102: QN43.B v2(9.89,48.65)
  TOP w0.254: QN43.B 11.49,48.64 R389.1
SCLOCK: length 23.1
  TOP w0.102: PCH1.L38 51.96,87.36 51.96,86.67 51.92,86.63 51.92,86.32 52.1,86.13 52.1,85.56 52.25,85.41 52.25,84.84 52.46,84.64 52.46,84.23 54.69,82 54.69,80.25 55.84,79.1 55.84,74.23 v2(56.22,73.84) 56.04,73.67 56.04,72.23 56.81,71.46 58.09,71.46 59.27,70.28 59.67,69.88 RN46.3
SDAT1: length 23.3
  TOP w0.102: RN46.5 59.34,69.38 v1(59.14,69.58) 59.14,70.04 57.97,71.2 56.74,71.2 55.61,72.33 55.61,78.95 54.46,80.09 54.46,81.94 52.25,84.15 52.25,84.46 51.95,84.77 51.67,84.77 51.35,85.08 51.35,85.32 51.42,85.38 51.42,86.13 51.65,86.37 PCH1.L40
SDI: length 12.8
  TOP w0.102: CODEC.8 19.2,215.67 v1(18.96,215.42) 18.9,215.37 18.9,214.92 arc(18.85,214.79) 18.73,214.74 18.63,214.74 arc(18.45,214.56) 18.63,214.38 18.73,214.38 arc(18.9,214.21) 18.73,214.03 18.63,214.03 arc(18.45,213.85) 18.63,213.67 18.73,213.67 arc(18.85,213.62) 18.9,213.49 18.9,212.48 18.04,211.62 18.04,210.37 18.32,210.09 19.46,210.09 19.59,209.96 19.59,209.52 19.27,209.2 17.65,209.2 R509.1
SENSE-A: length 8.2
  TOP w0.254: CODEC.13 23.94,218.31 v2(24.16,218.09) 24.92,217.33 R499.1 24.96,217.2 25.47,216.69 26.48,216.69 R502.1 27.4,217.04 27.4,216.92 27.62,216.69 28.64,216.69 R500.1
SENSE-B: length 8.1
  TOP w0.254: R482.2 R481.2 12.22,228.79 13.53,227.49 15.78,227.49 v1(16.16,227.11) 16.7,226.57 CODEC.34
SERIRQ: length 333.5
  TOP w0.102: RN15.5 41.08,64.45 40.95,64.32 40.25,64.32 40.11,64.19 40.11,60.59 42,58.71 43.34,58.71 43.94,58.11 48.85,58.11 52.24,61.5 59.7,61.5 60.71,62.52 66.33,62.52 v2(66.45,62.64) 67.77,61.32 73.36,61.32 v2(74.33,60.36) ; v2(228.51,21.75) 228.51,23.15 229.5,24.14 U23.27 ; PCH1.G39 53.64,87.05 53.35,86.76 53.35,86.16 53.37,86.13 53.37,85.35 53.47,85.25 53.47,84.66 55.57,82.56 60.51,82.56 62.9,80.17 64.46,80.17 65.26,80.97 65.26,81.64 65.54,81.92 67.17,81.92 70.09,84.84 v2(70.44,84.84) ; v2(211.11,21.24) 210.22,22.13 210.22,27.21 209.07,28.35 207.5,28.35 207.15,28.71 204.58,28.71 202.8,30.49 U21.39
  BOTTOM w0.102: v2(74.33,60.36) 77.76,56.93 77.76,45.41 79.26,43.91 79.26,40.32 80.88,38.69 82.39,38.69 88.42,32.65 88.42,31.23 92.91,26.75 110.57,26.75 114.33,22.99 121.04,22.99 122.61,21.42 141.81,21.42 144.91,18.32 154.92,18.32 156.06,17.18 167.29,17.18 168.05,17.94 178.93,17.94 180.33,19.34 189.84,19.34 192.23,16.95 199.72,16.95 202.59,19.82 205.37,19.82 205.68,19.51 207.2,19.51 207.86,20.17 209,20.17 209.2,19.97 210.34,19.97 210.6,20.23 210.6,20.73 v2(211.11,21.24) 211.11,22.07 212.17,23.14 212.17,23.82 212.69,24.34 216.88,24.34 219.05,22.17 228.09,22.17 v2(228.51,21.75) 228.63,21.62 229.62,21.62 229.9,21.9 231.32,21.9 232.82,20.4 232.82,17.5 228.39,13.07 228.39,12.41 224.3,8.33 222.89,8.33 220.62,6.05 216.03,6.05 TPM.16 ; v2(66.45,62.64) 66.45,63.15 72.98,69.68 72.98,82.3 v2(70.44,84.84)
SERR_L: length 46.4
  TOP w0.127: U11.56 55.64,157.5 55.91,157.77 55.91,159.32 R974.1 56.42,160.08 56.42,160.94 57.06,161.58 57.06,164.42 56.12,165.36 47.74,165.36 45.83,163.46 44.28,163.46 43.28,164.45 41.87,164.45 40.88,163.46 39.2,163.46 38.1,164.55 36.66,164.55 v2(35.85,163.74)
  BOTTOM w0.127: v2(35.85,163.74) 35.85,152.1 PCI.B42
SIO_33M: length 342.5
  TOP w0.102: R151.1 26.02,107.9 26.02,106.62 25.58,106.19 25.58,103.64 18.92,96.97 18.92,91.71 18.19,90.99 18.19,90.61 v2(17.61,90.02) ; U21.47 200.93,26.41 200.31,27.03 200.01,27.03 199.73,27.31 199.73,29.22 C399.1 199.09,29.4 198.66,29.83 197.85,29.83 196.53,28.51 196.53,26.18 195.87,25.52 195.87,23.9 194.75,22.79 194.75,20.32 192.46,18.03 192.46,13.73 191.95,13.22 188.47,13.22 187.61,14.07 187.61,15.42 186.6,16.44 v2(186.6,16.57)
  BOTTOM w0.102: v2(186.6,16.57) 186.19,16.16 182.48,16.16 181.99,15.68 169.12,15.68 168.33,14.9 156.77,14.9 155.57,13.7 143.09,13.7 141.24,15.55 128.66,15.55 v1(128.18,16.03) 127.67,16.54 109.33,16.54 108.49,15.7 107,15.7 102.86,19.85 92.51,19.85 92.13,19.46 90.78,19.46 88.24,16.92 84.23,16.92 82.48,15.17 76.85,15.17 71.7,10.02 71.7,9.98 70.21,8.5 70.21,5.75 68.94,4.47 64.03,4.47 60.16,8.34 53.49,8.34 50.71,5.56 11.83,5.56 9.05,8.35 9.05,15.91 9.61,16.47 9.61,36.28 10.55,37.22 10.55,45.47 11.31,46.24 11.31,49.52 10.45,50.38 10.45,56.37 12.5,58.43 12.5,62.6 13.86,63.96 13.86,66.19 12.52,67.54 12.52,72.13 8.31,76.33 8.31,80.91 11.84,84.44 12.13,84.44 15.86,84.44 16.92,85.5 16.92,89.06 17.61,89.75 v2(17.61,90.02)
SIO_48M: length 344.6
  TOP w0.102: v2(18.57,89.97) 18.57,90.87 19.27,91.57 19.27,96.83 25.94,103.49 25.94,106.05 R155.1 ; U21.37 204.48,33.45 204.25,33.69 203.82,33.69 203.11,32.98 202.32,32.98 201.61,33.69 199.96,33.69 C398.1 197.99,32.89 197.42,32.32 197.42,29.93 196.17,28.68 196.17,26.33 195.4,25.55 195.4,23.94 194.39,22.93 194.39,20.46 192.11,18.18 192.11,13.88 191.8,13.57 188.61,13.57 187.99,14.19 187.99,16.03 v2(187.48,16.54)
  BOTTOM w0.102: v2(187.48,16.54) 186.98,17.05 186.85,17.18 186.34,17.18 185.68,16.52 182.33,16.52 181.85,16.03 168.97,16.03 168.7,15.76 168.19,15.25 156.62,15.25 155.42,14.05 143.24,14.05 141.39,15.91 129.8,15.91 128.81,16.9 108.08,16.9 v1(107.6,16.42) 107.12,16.9 106.31,16.9 102.98,20.23 92.39,20.23 91.98,19.82 90.63,19.82 88.12,17.3 84.11,17.3 82.33,15.53 76.7,15.53 71.34,10.17 71.34,10.13 69.86,8.65 69.86,5.98 68.71,4.83 64.18,4.83 60.31,8.69 53.34,8.69 50.57,5.93 11.97,5.93 9.41,8.49 9.41,15.76 9.96,16.32 9.96,36.13 10.9,37.07 10.9,45.24 11.67,46.01 11.67,49.67 10.8,50.53 10.8,56.22 12.86,58.28 12.86,62.45 14.22,63.81 14.22,66.34 12.87,67.68 12.87,72.28 8.67,76.48 8.67,80.77 11.98,84.08 16.31,84.08 17.38,85.16 17.38,88.63 18.57,89.82 v2(18.57,89.97)
SIO_BEEP: length 102.4
  TOP w0.102: v2(232.65,90) 232.06,90 231.45,89.39 231.45,88.5 227.11,84.16 227.11,76.26 226.8,75.95 226.8,71.55 226.93,71.21 228.48,69.65 231.02,69.65 232.8,67.88 232.8,62.68 233.81,61.67 233.81,53.19 237.36,49.65 238.55,49.65 240.7,47.51 240.7,47 240.24,46.54 234.88,46.54 234.45,46.97 234.45,49.38 233.86,49.97 232.42,49.97 229.67,47.23 229.55,47.23 229.09,46.77 228.58,46.77 227.92,47.43 227.49,47.43 227.39,47.53 v2(226.59,47.53) ; v2(231.31,96.79) 231.31,97.56 232.47,98.71 233.08,98.71 233.43,99.06 R385.2 233.71,99.51 C411.1 ; U21.2 221.98,33.39 222.13,33.54 222.47,33.54 R341.1 223.88,34.91 v2(225.13,36.15)
  BOTTOM w0.102: v2(232.65,90) 232.65,94.75 231.31,96.08 v2(231.31,96.79) ; v2(225.13,36.15) 225.99,37.01 225.99,42.93 227.11,44.05 v1(227.11,46.64) 227.11,47.02 v2(226.59,47.53)
SIO_GND: length 40.9
  TOP w0.254: U21.86 214.48,15 214.01,14.52 211.88,14.52 211.65,14.29 C383.2
  TOP w0.508: 225.84,12.7 C376.2 ; 225.84,12.7 v2(225.84,13.69) ; 225.84,12.7 C377.2 ; C383.2 C385.1 211.49,12.45 211.49,10.75 R366.2 210.66,9.72 211.21,9.18 v2(211.42,9.18) 212,9.18 212.25,9.43 RT1.1 ; v2(216.63,11.15) C380.1 ; C374.2 v2(218.92,11.72) ; C375.2 221.23,11.43 v2(220.76,11.91) 220.22,11.37 R335.2 ; R337.2 v2(223.68,11.78) C378.2 ; C379.2 v2(222.54,11.34) R338.2 222.25,10.19 R336.2
  BOTTOM w0.508: v2(211.42,9.18) 211.42,9.24 214.73,12.54 216,12.54 216.63,11.91 v2(216.63,11.15) 216.82,10.95 218.41,10.95 218.79,11.34 218.79,11.59 v2(218.92,11.72) 220.57,11.72 v2(220.76,11.91) 221.33,11.34 v2(222.54,11.34) 222.98,11.78 v2(223.68,11.78) 223.68,12.48 v1(224.44,13.24) 224.89,13.69 v2(225.84,13.69)
SIO_GP46: length 26.9
  TOP w0.102: A1.1 189.64,7.14 190.66,8.16 190.66,8.73 191.72,9.79 192.72,9.79 193.71,8.8 194.54,8.8 195.61,9.87 195.61,11.13 195.92,11.44 196.3,11.44 197.64,12.78 197.64,15.02 198.33,15.7 199.34,15.7 R258.1 200.18,15.27 200.63,15.72 200.63,16.02 201.81,17.2 202.76,17.2 203.23,16.73 203.23,15.2 203.61,14.82 204.25,14.82 204.48,15.05 U21.66
SIO_GP47: length 21.9
  TOP w0.102: U21.65 203.91,16.92 203.65,17.18 203.11,17.18 202.86,17.43 201.71,17.43 200.69,16.42 R424.1 199.29,15.93 198.24,15.93 197.42,15.11 197.42,12.88 196.2,11.67 195.83,11.67 195.38,11.22 195.38,9.96 194.45,9.02 193.8,9.02 192.81,10.01 191.62,10.01 190.53,8.92 A2.1
SIO_GP70: length 7.8
  TOP w0.102: U21.62 201.03,18.91 200.87,18.75 200.87,17.33 200.46,16.92 197.89,16.92 v1(197.58,16.61) 197.17,16.21 197.17,16 RJ17.2
SIO_GP71: length 10.4
  TOP w0.102: RJ7.2 194.93,15.86 194.93,16.8 195.36,17.23 199.98,17.23 v1(200.26,17.51) 200.62,17.87 200.62,19.01 201.02,19.41 U21.61
SIO_GP73: length 6.1
  TOP w0.102: RJ9.2 197.9,18.45 199.93,18.45 200.16,18.68 200.16,19.2 200.67,19.7 200.67,20.07 201.01,20.41 U21.59
SIO_GP74: length 5.6
  TOP w0.102: U21.58 200.93,20.91 200.44,20.42 200.44,19.8 199.93,19.29 199.93,18.9 199.71,18.68 198.69,18.68 RJ10.2
SIO_GP75: length 4.3
  TOP w0.102: U21.57 201.04,21.41 200.46,20.84 198.64,20.84 RJ11.2
SIO_GP76: length 113.1
  TOP w0.102: v2(241.59,23.27) 241.78,23.46 241.78,34.59 240.27,36.1 THER_HD.5 ; U21.56 200.93,21.91 200.83,21.81 200.83,21.53 200.37,21.06 198.67,21.06 RJ8.2 197.67,22.06 196.13,22.06 195.87,21.81 195.87,21.3 196.25,20.92 196.25,19.22 195.85,18.82 194.72,18.82 193.34,17.43 193.34,13.23 191.29,11.18 191.29,10.53 190.68,9.91 189.01,9.91 188.78,9.68 188.78,5.77 v2(188.37,5.37) ; v2(228.84,17.1) 228.84,16.78 230.41,15.21 231.49,15.21 233.13,13.57 237.14,13.57 238.39,14.82 241.18,14.82 242.09,15.73 v2(242.09,16.54)
  BOTTOM w0.102: v2(228.84,17.1) 228.18,16.44 225.04,16.44 224.23,15.63 223.58,15.63 221.9,13.94 213.2,13.94 209.78,10.52 207.12,10.52 205.7,9.1 201,9.1 200.06,8.16 195.92,8.16 194.55,6.79 191.68,6.79 191.35,6.46 190.71,6.46 190.38,6.79 188.93,6.79 188.7,6.55 188.7,5.69 v2(188.37,5.37) ; v2(242.09,16.54) 242.67,17.11 242.67,22.19 v2(241.59,23.27)
SIO_GP77: length 11
  TOP w0.102: U21.54 201.1,22.91 200.91,23.1 200.91,24.19 200.46,24.65 197.11,24.65 195.43,22.97 v1(195.43,22.18) 195.36,22.11 R360.2
SIO_LED0: length 298.1
  TOP w0.102: v2(11.88,55.02) 11.88,55.66 R396.2 11.75,56.45 13.49,58.2 14.76,58.2 15.17,57.79 15.17,56.22 R388.2 ; v2(64.09,12.96) 64.98,12.96 67.85,15.83 78.57,15.83 v2(78.87,16.14) ; U21.14 215.98,31.58 215.73,31.33 214.14,31.33 213.96,31.15 213.96,30.07 215.93,28.1 215.93,22.82 211.94,18.83 211.21,18.83 v2(210.57,19.46)
  BOTTOM w0.102: v2(78.87,16.14) 79.1,15.91 82.21,15.91 84.01,17.71 88.02,17.71 90.49,20.17 91.83,20.17 92.29,20.63 103.08,20.63 106.41,17.3 142.06,17.3 144.27,15.09 154.81,15.09 155.95,16.24 167.65,16.24 168.43,17.03 179.31,17.03 180.7,18.42 187.18,18.42 188.5,17.1 190.2,17.1 191.27,16.03 200.16,16.03 202.93,18.8 204.45,18.8 v1(204.83,18.42) 205.15,18.74 205.3,18.6 208.07,18.6 208.2,18.73 209.4,18.73 209.63,18.96 210.07,18.96 v2(210.57,19.46) ; v2(64.09,12.96) 61.89,12.96 57.63,17.22 50.05,17.22 48.52,15.69 48.52,8.71 46.09,6.28 12.12,6.28 9.76,8.64 9.76,15.59 10.75,16.58 10.75,21.44 11.06,21.75 11.06,26.27 10.39,26.94 10.39,34.82 11.25,35.69 11.25,36.36 11.26,36.36 11.26,44.94 12.05,45.73 12.05,49.79 11.16,50.68 11.16,54.43 11.75,55.02 v2(11.88,55.02)
SIO_LED0_R: length 2.4
  TOP w0.254: R396.1 13.06,56.14 13.06,56.42 v2(13.39,56.75) 13.59,56.94 13.86,56.94 14.1,57.18 QN41.B
SIO_LED1: length 289.7
  TOP w0.102: R395.2 14.83,50.07 13.7,50.07 R398.1 13.11,50.08 12.35,50.83 12.35,51.59 v2(11.97,51.98) ; v2(64.7,13.49) 65.16,13.49 67.77,16.11 78.11,16.11 78.72,16.72 79.31,16.72 v2(79.61,16.42) ; U21.12 216.98,31.33 216.51,30.86 215.26,30.86 215.04,30.64 215.04,29.37 216.26,28.15 216.26,22.83 212.01,18.57 210.7,18.57 v2(209.81,19.46)
  BOTTOM w0.102: v2(64.7,13.49) 61.68,13.49 60.22,14.96 57.73,17.45 49.96,17.45 48.29,15.78 48.29,8.81 45.99,6.51 16.72,6.51 15.86,7.37 11.35,7.37 9.99,8.74 9.99,15.48 10.98,16.47 10.98,21.35 11.28,21.65 11.28,26.36 10.98,26.67 10.98,32.23 11.61,32.87 11.61,36.51 11.49,36.64 11.49,44.85 12.28,45.64 12.28,51.67 v2(11.97,51.98) ; v2(209.81,19.46) 209.3,18.96 208.1,18.96 207.98,18.83 205.39,18.83 205.16,19.06 202.86,19.06 200.07,16.26 191.36,16.26 190.3,17.33 188.68,17.33 187.36,18.65 180.61,18.65 179.21,17.25 168.34,17.25 167.55,16.47 155.86,16.47 154.71,15.32 144.89,15.32 v1(144.23,15.98) 142.6,17.61 106.48,17.61 103.23,20.86 92.2,20.86 91.74,20.4 90.39,20.4 87.93,17.94 83.92,17.94 82.12,16.14 79.89,16.14 v2(79.61,16.42)
SIO_LED1_R: length 2.4
  TOP w0.254: QN42.B 13.6,52.33 v2(13.42,52.15) 13.42,51.31 R398.2
SIO_PECI: length 140.6
  TOP w0.102: R27.2 214.15,121.1 214.15,112.55 225.46,101.25 v2(225.46,101.12) ; v2(198.56,24.01) 198.28,24.29 197.26,24.29 196.46,23.49 R357.2 ; v2(228.84,47.38) 232.39,50.93 232.39,59.26 231.35,60.3 231.35,66.45 229.26,68.55 227.96,68.55 226.6,69.9 226.32,70.61 225.53,72.85 225.53,76.38 226.32,77.17 226.32,84.97 v2(228.25,86.9)
  BOTTOM w0.102: v2(225.46,101.12) 225.46,92.74 226.85,91.35 226.85,88.04 228,86.9 v2(228.25,86.9) ; v2(228.84,47.38) 228.61,47.15 228.61,44.18 226.6,42.17 226.6,40.55 227.62,39.53 227.62,38.77 228.31,38.08 228.31,36.6 225.93,34.22 225.42,34.22 222.7,31.5 217.05,31.5 v1(216.63,31.08) 216.63,30.56 215.77,29.7 208.87,29.7 208.69,29.88 203.13,29.88 201.2,27.95 201.2,27.39 198.56,24.75 v2(198.56,24.01)
SIO_PECI_R: length 5.7
  TOP w0.102: R357.1 197.41,23.34 v2(197.75,23.68) 198.05,23.38 199.21,23.38 C400.1 199.7,22.89 200.49,22.89 200.97,22.41 U21.55
SIO_PWRON_L: length 387.2
  TOP w0.102: v2(235.87,132.01) 235.69,131.83 230.66,131.83 230.28,131.45 228.5,131.45 R984.1 ; v2(230.28,55.4) 230.05,55.63 230.05,66.22 228.85,67.42 226.6,67.42 225.2,68.82 225.2,70.12 224.47,72.5 224.47,76.82 225.25,77.61 225.25,88.22 v2(227.49,90.46) ; R350.1 205.87,13.72 206.49,14.34 206.84,14.34 207.48,14.98 U21.72 207.48,17.69 207.8,18.01 207.8,26.07 v2(207.55,26.32) ; PCH1.AK41 41.35,85.72 37.52,81.89 37.52,79.32 37.73,79.12 37.73,74.97 37.52,74.77 37.52,67.81 37.88,67.45 37.88,59.88 41.13,56.62 42.46,56.62 42.61,56.46 43.06,56.02 49.85,56.02 52.89,59.06 65.6,59.06 66.18,59.65 71.48,59.65 72.29,58.83 76.48,58.83 78.42,56.89 78.42,48.16 81.46,45.12 v2(86.01,45.12)
  BOTTOM w0.102: v2(235.87,132.01) 236.13,131.76 236.13,129.2 235.54,128.62 235.54,123.24 236.13,122.66 236.13,117.45 234.61,115.93 233.79,115.93 225.33,107.47 v1(225.33,105.11) 225.33,102.27 226.07,101.53 226.07,92.77 227.39,91.45 227.39,90.56 v2(227.49,90.46) ; v2(86.01,45.12) 86.01,44.48 88.17,42.32 88.17,41.3 89.91,39.55 91.42,39.55 93.94,37.05 93.94,33.27 95.02,32.19 100.83,32.19 101.84,33.2 109.2,33.2 109.68,32.72 110.55,32.72 111.47,33.64 112.16,33.64 112.42,33.38 122.16,33.38 123.03,34.26 124.78,34.26 127.32,31.72 127.32,30.67 130.78,27.21 140.22,27.21 142.05,25.38 149.23,25.38 152.45,22.16 160.4,22.16 161.39,21.17 164.56,21.17 165.02,21.62 166.31,21.62 166.52,21.42 177.36,21.42 178.76,22.82 191.5,22.82 192.31,22 195.13,22 195.56,22.44 198.73,22.44 199.57,23.27 200.83,23.27 201.06,23.5 205.24,23.5 207.55,25.81 v2(207.55,26.32) 210.12,28.89 216.17,28.89 217.98,30.69 223.1,30.69 225.82,33.41 226.26,33.41 229.12,36.26 229.12,39.82 230.2,40.9 230.2,49.87 231.5,51.17 231.5,54.19 v2(230.28,55.4)
SIO_VCC3: length 2.7
  TOP w0.254: U21.92 217.48,13.76 R340.1
SIO_VCORE: length 5.6
  TOP w0.102: v2(202.67,33.64) 202.67,33.98 C389.1
  TOP w0.254: 204.63,34.32 204.63,34.04 204.98,33.69 U21.36
  TOP w0.508: C389.1 203.81,35.12 204.45,35.12 C388.1 204.63,34.99 204.63,34.32
SIO_VREF: length 6.9
  TOP w0.254: U21.91 216.98,13.78 C380.2 217.33,12.73 217.33,10.5 216.96,10.13 R339.1
SKIP: length 5.9
  TOP w0.178: U41.25 49.28,33.56 R935.2 48.27,33.55 46.47,33.55 R934.1
SLOAD: length 21
  TOP w0.102: v2(56.52,75.62) 56.52,74.78 56.75,74.55 56.75,73.57 56.52,73.34 56.52,72.5 57.33,71.69 58.22,71.69 59.46,70.45 RN46.1 ; PCH1.H41 53.12,85.9 53.12,85.32 53.27,85.17 53.27,84.57 55.77,82.07 v2(55.79,82.07)
  BOTTOM w0.102: v2(55.79,82.07) 55.99,82.07 v1(56.7,81.36) 56.75,81.31 56.75,80.58 55.87,79.7 55.87,77.21 56.52,76.56 v2(56.52,75.62)
SLP_AMT_L: length 348
  TOP w0.102: v2(90.46,37.62) 91.42,36.66 91.42,22.94 v2(92.18,22.18) ; PCH1.AN37 39.72,88.3 v3(39.72,88.49) ; v2(81.3,16.91) 81.03,17.18 78.53,17.18 77.92,16.57 67.53,16.57 65.42,14.46 v2(64.73,14.46) ; v2(3.72,130.84) 3.44,130.56 3.44,65.13 4.25,64.32 5.96,64.32 7.46,65.82 8.16,65.82 9.67,67.33 14.73,67.33 15.46,68.06 v2(15.46,68.74) 16.01,69.29 18.44,69.29 20.07,70.91 22.64,70.91 22.8,70.75 24.03,70.75 24.2,70.91 24.81,70.91 26.32,72.43 26.32,73.69 25.94,74.07 v2(25.43,74.07) ; QN60.E 85,49.91 R622.2 85.34,49.56 v2(86.01,49.56) ; R645.2 8.48,152.97 R187.1 8.51,154.85 5.52,154.85 ME_TEST.5
  BOTTOM w0.102: v2(64.73,14.46) 61.36,14.46 60.68,15.15 57.91,17.91 49.39,17.91 47.84,16.36 47.84,9 45.8,6.97 18.56,6.97 17.69,7.84 11.53,7.84 10.45,8.93 10.45,15.29 11.59,16.43 11.59,19.34 12.33,20.07 12.33,20.73 12.1,20.96 12.1,36.99 11.97,37.12 11.97,44.68 12.76,45.47 12.76,57.14 13.76,58.14 13.76,60.69 13.98,60.9 13.98,62.62 14.8,63.44 14.8,67.19 15.46,67.85 v2(15.46,68.74) ; v2(92.18,22.18) 92.18,21.7 91.35,20.86 90.2,20.86 87.74,18.4 83.67,18.4 82.19,16.91 v2(81.3,16.91) ; v2(86.01,49.56) 85.5,49.05 v1(85.5,48.04) 85.5,47.91 85.05,47.45 85.05,42.47 89.9,37.62 v2(90.46,37.62) ; v2(25.43,74.07) 24.92,74.58 24.92,78.14 25.81,79.03 30.84,79.03 32.07,80.26 35.01,80.26 36.38,81.63 36.38,82.71 38.82,85.15 38.82,87.59 v3(39.72,88.49) ; v2(3.72,130.84) 3.97,130.84 5.57,132.44 5.57,134.51 6.26,135.2 6.26,144.3 5.39,145.17 5.39,151.11 5.06,151.44 5.06,154.9 4.43,155.53 ME_TEST.5
SLP_AMT_L_B: length 4.4
  TOP w0.254: C229.1 11.11,155.35 QN26.B 11.28,154.83 11.18,154.72 11.14,154.72 v2(10.29,153.88) 9.66,153.24 9.66,153.2 R187.2
