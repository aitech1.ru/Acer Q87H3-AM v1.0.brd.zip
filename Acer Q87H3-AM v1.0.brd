# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDID_LEVEL_SF: length 9.7
  TOP w0.508: QN22.D v2(181.64,209.71)
  BOTTOM w0.508: v2(181.64,209.71) 180.98,209.71 v1(180.52,210.17) 180.52,210.19 v2(178.09,212.63) v2(174.28,212.63)
DDID_N0_C: length 7.5
  TOP w0.102: RN7.6 177.55,216.75 177.22,216.42 177.22,216.03 177.58,215.68 177.58,215.3 177.71,215.17 RN10.5 177.71,214.41 177.49,214.2 176.85,214.2 176.49,213.83 176.49,212.83 177.43,211.89 177.43,211.61 C108.2
DDID_N1_C: length 9.4
  TOP w0.102: RN8.2 175.24,216.77 174.81,216.34 174.81,215.96 174.66,215.81 174.66,215.49 174.85,215.3 RN9.1 174.85,214.6 175.06,214.38 175.28,214.38 175.59,214.07 175.59,212.3 175.14,211.86 175.14,209.32 175.29,209.17 C109.2
DDID_N2_C: length 7.4
  TOP w0.102: C110.2 173.43,211.67 173.43,211.99 172.7,212.71 172.7,213.94 172.91,214.15 173.51,214.15 173.77,214.41 RN9.5 173.77,215.3 173.64,215.43 173.64,215.78 173.29,216.14 173.29,216.34 173.62,216.67 RN8.6
DDID_N3_C: length 10
  TOP w0.102: C115.2 179.29,209.17 179.17,209.3 179.17,209.8 179.86,210.5 179.86,212.38 v1(180.22,212.73) 179.86,213.09 179.86,213.8 179.28,214.38 179.01,214.38 178.79,214.61 RN10.1 178.79,215.17 178.59,215.36 178.59,215.61 178.85,215.86 178.85,216.36 179.22,216.74 CMK12.3
DDID_P0_C: length 7.5
  TOP w0.102: C112.2 176.99,211.33 177.22,211.56 177.22,211.81 176.28,212.75 176.28,213.92 176.77,214.41 176.94,214.41 177.13,214.6 RN10.7 177.13,215.17 177.38,215.41 177.38,215.59 177.02,215.95 177.02,216.44 176.7,216.76 CMK10.2
DDID_P1_C: length 9.4
  TOP w0.102: CMK11.2 174.44,216.66 174.61,216.49 174.61,216.04 174.45,215.89 174.45,215.48 174.27,215.3 RN9.3 174.27,214.41 174.51,214.18 175.19,214.18 175.39,213.99 175.39,212.39 174.94,211.94 174.94,209.58 C113.2
DDID_P2_C: length 7.3
  TOP w0.102: RN8.8 172.8,216.59 173.08,216.31 173.08,216.05 173.44,215.7 173.44,215.55 173.2,215.31 RN9.7 173.2,214.59 172.97,214.36 172.83,214.36 172.5,214.03 172.5,212.63 173.22,211.91 173.22,211.51 173.04,211.33 C111.2
DDID_P3_C: length 10
  TOP w0.102: CMK12.2 178.37,216.71 178.65,216.44 178.65,215.95 178.39,215.7 178.39,215.37 178.21,215.18 RN10.3 178.21,214.41 178.44,214.18 179.2,214.18 179.66,213.71 179.66,211.59 v1(179.31,211.23) 179.66,210.88 179.66,210.58 178.96,209.88 178.96,209.54 C114.2
DDID_TX_N0: length 124.8
  TOP w0.102: CPU1.C15 153.4,143.57 153.96,144.13 153.96,145.54 154.22,145.81 154.22,146.98 154.59,147.35 154.59,148.5 148.56,154.53 136.2,154.53 136.05,154.68 136.05,154.95 v2(136.33,155.23) ; v2(173.64,209.07) 173.29,209.43 173.29,209.89 C110.1
  BOTTOM w0.102: v2(136.33,155.23) 135.97,155.58 135.97,155.79 135.75,156.01 133.87,156.01 127.68,162.2 127.68,167.44 126.42,168.7 126.42,190.46 138.56,202.6 140.24,202.6 142.56,204.92 169.8,204.92 170.4,205.52 v1(170.92,205.52) 170.92,206.04 173.31,208.43 173.31,208.74 v2(173.64,209.07)
DDID_TX_N1: length 124.3
  TOP w0.102: v2(139.38,155.86) 139.15,155.63 139.15,155.32 139.26,155.21 149.18,155.21 155.3,149.09 155.3,147 154.85,146.54 154.85,144.99 154.62,144.76 154.41,144.76 154.31,144.66 CPU1.B16 ; v2(175.55,207.3) 175.2,207.64 175.2,207.97 175.45,208.22 C109.1
  BOTTOM w0.102: v2(139.38,155.86) 139.02,156.22 139.02,156.48 138.8,156.7 134.17,156.7 128.36,162.51 128.36,167.9 127.13,169.13 127.13,190.18 138.87,201.91 140.53,201.91 142.84,204.22 171.16,204.22 171.87,204.93 172.52,204.93 v1(172.88,204.58) 173.24,204.93 173.84,204.93 175.24,206.33 175.24,207.12 175.42,207.3 v2(175.55,207.3)
DDID_TX_N2: length 127.9
  TOP w0.102: C108.1 177.22,209.89 177.22,209.43 v2(177.58,209.07) ; v2(142.68,156.5) 142.45,156.27 142.45,156.04 142.59,155.9 149.59,155.9 156.18,149.31 156.18,145.94 155.8,145.56 155.8,144.11 155.56,143.87 155.38,143.87 155.22,143.72 CPU1.C17
  BOTTOM w0.102: v2(177.58,209.07) 177.25,208.74 177.25,207.57 176,206.32 176,205.43 174.11,203.54 143.12,203.54 140.81,201.23 139.21,201.23 127.82,189.84 127.82,169.41 129.05,168.18 129.05,162.86 134.53,157.39 142.15,157.39 142.37,157.17 142.37,156.8 v2(142.68,156.5)
DDID_TX_N3: length 126.8
  TOP w0.102: v2(145.24,157.26) 145.02,157.03 145.02,156.71 145.14,156.59 149.9,156.59 156.89,149.6 156.89,145.05 156.58,144.74 156.37,144.74 156.14,144.51 CPU1.B18 ; C115.1 179.57,208.22 179.28,207.93 179.28,207.45 179.43,207.3 v2(179.61,207.3)
  BOTTOM w0.102: v2(145.24,157.26) 144.89,157.61 144.89,157.93 144.67,158.15 134.74,158.15 129.74,163.15 129.74,168.47 128.51,169.7 128.51,187.56 130.84,189.9 130.84,191.82 139.51,200.49 141.05,200.49 143.41,202.85 175.95,202.85 177.1,203.99 v1(177.6,203.99) 177.6,204.5 179.29,206.19 179.29,207.12 179.47,207.3 v2(179.61,207.3)
DDID_TX_P0: length 124.8
  TOP w0.102: v2(135.41,155.23) 135.72,155.23 135.85,155.1 135.85,154.59 136.11,154.32 148.47,154.32 154.39,148.41 154.39,147.44 154.02,147.07 154.02,145.89 153.75,145.63 153.75,144.21 153.59,144.05 153.47,144.05 153.4,144.13 CPU1.B15 ; C111.1 173.08,209.92 173.08,209.43 v2(172.73,209.07)
  BOTTOM w0.102: v2(135.41,155.23) 135.77,155.58 135.77,155.71 135.67,155.81 133.78,155.81 127.48,162.12 127.48,167.36 126.22,168.61 126.22,190.54 138.48,202.8 140.16,202.8 142.48,205.12 169.71,205.12 171.46,206.86 v1(171.46,207.35) 171.94,207.35 173.1,208.51 173.1,208.77 172.8,209.07 v2(172.73,209.07)
DDID_TX_P1: length 124.3
  TOP w0.102: v2(174.63,207.3) 175,207.66 175,207.97 174.75,208.22 C113.1 ; v2(138.46,155.86) 138.77,155.86 138.95,155.68 138.95,155.24 139.17,155.01 149.09,155.01 155.1,149 155.1,147.08 154.64,146.62 154.64,145.07 154.53,144.96 154.38,144.96 154.31,145.04 CPU1.A16
  BOTTOM w0.102: v2(174.63,207.3) 175.04,206.89 175.04,206.42 174.65,206.03 v1(174.12,206.03) 174.12,205.5 173.76,205.14 171.79,205.14 171.08,204.43 142.75,204.43 140.44,202.11 138.78,202.11 126.93,190.26 126.93,169.04 128.16,167.81 128.16,162.42 134.09,156.5 138.72,156.5 138.82,156.39 138.82,156.22 v2(138.46,155.86)
DDID_TX_P2: length 127.9
  TOP w0.102: v2(176.66,209.07) 177.02,209.43 177.02,209.92 C112.1 ; v2(141.76,156.5) 141.99,156.5 142.25,156.24 142.25,155.95 142.51,155.7 149.5,155.7 155.98,149.22 155.98,146.03 155.59,145.64 155.59,144.2 155.47,144.08 155.35,144.08 155.22,144.2 CPU1.B17
  BOTTOM w0.102: v2(141.76,156.5) 142.17,156.9 142.17,157.08 142.07,157.18 134.44,157.18 128.85,162.78 128.85,168.1 127.62,169.33 127.62,189.92 139.12,201.43 140.73,201.43 143.04,203.74 174.02,203.74 175.8,205.52 175.8,206.41 177.05,207.65 177.05,208.69 v2(176.66,209.07)
DDID_TX_P3: length 126.9
  TOP w0.102: CPU1.A18 156.14,145.12 156.32,144.94 156.5,144.94 156.69,145.13 156.69,149.51 149.82,156.38 145.05,156.38 144.81,156.62 144.81,157 144.56,157.26 v2(144.33,157.26) ; v2(178.7,207.3) 178.9,207.3 179.08,207.47 179.08,207.86 178.72,208.22 C114.1
  BOTTOM w0.102: v2(144.33,157.26) 144.69,157.61 144.69,157.84 144.58,157.94 134.65,157.94 129.53,163.06 129.53,168.38 128.3,169.61 128.3,187.65 130.64,189.98 130.64,191.9 139.43,200.69 140.96,200.69 143.32,203.05 175.87,203.05 178.11,205.3 v1(178.11,205.82) 178.64,205.82 179.09,206.28 179.09,206.99 178.79,207.3 v2(178.7,207.3)
DDR3_DRAMRST_L: length 40
  TOP w0.102: R68.2 C9.2 172.53,73.76 173.93,72.35 DIMM4.168 173.13,70.19 173.13,64.02 DIMM2.168 173.93,57.22 172.65,55.93 172.65,53.23 173.93,51.94 DIMM3.168 173.04,50.13 173.04,41.59 DIMM1.168
DEPOP_N1: length 2.7
  TOP w0.102: v2(23.65,213.14) 23.65,212.12 22.99,211.46 R479.1
DEPOP_N2: length 22.4
  TOP w0.102: QP7.B 22.83,209.07 21.24,209.07 v1(20.99,208.82) 20.35,208.19 18.02,208.19 16.5,206.66 14.26,206.66 13.62,207.3 13.62,208.14 14.31,208.82 14.31,210.32 13.9,210.73 12.54,210.73 12.3,210.97 12.3,215.63 R480.1
DEPOP_N3: length 7
  TOP w0.508: 27.34,212.12 25.69,212.12 v2(25.69,209.58) 25.69,208.19 27.05,208.19 R471.1
DEPOP_N4: length 4.9
  TOP w0.102: v1(27.92,210.22) 27.92,210.19 28.2,210.47 C505.1
  TOP w0.508: R474.2 30.26,210.73 30,210.47 C505.1 29.37,212.12
DEPOP_N5: length 5.9
  TOP w0.102: 31.02,212.12 31.02,212.61 v2(29.65,213.98)
  TOP w0.508: 31.88,210.57 30.95,209.64 R476.2 ; 31.88,210.57 31.88,210.57 31.88,211.26 31.02,212.12 ; 31.88,210.57 R474.1
DEVSEL_L: length 12.6
  TOP w0.127: PCI.B37 42.84,156.99 43.75,156.09 45.97,156.09 46.61,155.46 47.85,155.46 R968.1 48.55,155.99 50.05,154.49 U11.66
DIFFCLK_BIASREF: length 1.6
  TOP w0.102: PCH1.R11 48.89,102.45 v2(48.7,102.45)
  BOTTOM w0.102: SR21.2 48.74,102.49 v2(48.7,102.45)
DIMM_DQ_AC: length 2.1
  TOP w0.102: R66.2 v2(206.28,120.02)
  TOP w0.254: C7.1 R66.2
DIMM_DQ_BC: length 4.2
  TOP w0.102: R67.2 207.78,119.48 207.78,117.66 v2(208.06,117.38)
  TOP w0.254: C8.1 R67.2
DIMM_DQ_CPU_VREF_A: length 109.3
  TOP w0.254: C7.2 v4(204.25,122.17)
  TOP w0.305: CPU1.AB39 178.09,125.76 v4(179.5,125.76) ; R125.1 226.96,57.85 227.49,58.38 227.49,59.34 222.99,63.84 222.99,69.69 222.66,70.51 222.26,71.51 222.26,78.21 222.99,78.95 222.99,87.94 220.63,90.3 220.63,95.92 214.54,102.01 214.54,109.79 204.25,120.07 v4(204.25,122.17)
  BOTTOM w0.254: v4(179.5,125.76) 183.18,129.45 194.66,129.45 201.93,122.17 203.05,122.17 ; 203.05,122.17 v1(203.05,122.18) ; 203.05,122.17 v4(204.25,122.17)
DIMM_DQ_CPU_VREF_A_R: length 3.5
  TOP w0.508: R119.2 R123.1 216.39,58.66 C183.1 218.65,58.66 R121.1
DIMM_DQ_CPU_VREF_B: length 110
  TOP w0.254: C8.2 208.31,122.46 207.88,122.89 200.86,122.89 194.31,129.45 183.93,129.45 179.69,125.2 179.33,125.2 179.2,125.33 178.58,125.33 CPU1.AB40
  TOP w0.305: C8.2 208.85,122.17 209.15,121.88 209.15,116.8 v2(209.63,116.31) 209.63,115.55 215.15,110.04 215.15,102.42 221.24,96.32 221.24,90.56 223.6,88.19 223.6,78.7 222.87,77.96 222.87,71.63 222.91,71.52 223.05,71.17 223.13,70.97 223.32,70.5 223.51,70.04 223.6,69.81 223.6,64.09 228.1,59.59 228.1,58.03 226.95,56.89 R126.1
DIMM_DQ_CPU_VREF_B_R: length 3.4
  TOP w0.508: R120.2 R124.1 C184.1 218.64,57.48 R122.1
DIMM_VREF_CA_A: length 218.8
  TOP w0.254: R46.1 211.87,118.17 v2(211.87,115.86)
  TOP w0.305: DIMM2.67 150.93,62.82 151.95,61.81 151.95,60.1 C179.1 149.73,59.18 C671.1 148.79,58.23 R115.2 147.99,57.84 148.34,57.49 148.34,57.46 148.36,57.45 148.36,56.43 148.97,55.82 148.97,54.35 147.86,53.25 147.86,52.48 146.97,51.59 146.97,50.71 145.83,49.56 145.83,48.29 142.91,45.37 142.91,44.1 141.89,43.09 141.89,42.07 140.9,41.08 140.9,40.13 139.97,39.2 v2(139.97,37.86) 140.51,37.86 141,37.37 R157.1
  GND w0.305: DIMM4.67 150.93,70.67 149.94,69.68 149.94,68.65 150.93,67.66 DIMM2.67
  BOTTOM w0.254: v2(139.97,37.86) 139.97,37.64 140.16,37.45 202.06,37.45 203.16,36.35 215.42,36.35 216.72,37.65 221.14,37.65 223.12,39.63 223.12,49.73 228.48,55.09 228.48,60.13 225.84,62.77 225.84,80.42 219.74,86.52 219.74,96.93 215.04,101.63 215.04,109.51 211.87,112.68 v2(211.87,115.86)
DIMM_VREF_CA_A_R: length 2.3
  TOP w0.381: R113.2 R117.1 R115.1
DIMM_VREF_CA_B: length 215.3
  TOP w0.254: v2(212.63,115.86) 212.63,119.83 R48.1
  TOP w0.305: DIMM3.67 150.93,50.57 149.94,49.57 149.94,48.38 150.93,47.38 DIMM1.67 150.93,40.22 150.47,39.75 142.37,39.75 141.93,39.32 141.93,38.09 142.22,37.8 C180.1 142.19,37.08 141.24,36.13 R157.2 140.01,36.13 C672.1 139.66,36.28 138.72,35.34 137.35,35.34 R116.2 v2(135.87,36.13)
  BOTTOM w0.254: v2(212.63,115.86) 212.63,113.06 215.6,110.09 215.6,101.96 220.3,97.26 220.3,86.75 226.4,80.65 226.4,63 229.04,60.36 229.04,54.86 223.68,49.5 223.68,39.4 221.37,37.09 216.95,37.09 215.66,35.8 202.92,35.8 201.83,36.89 179.22,36.89 178.12,35.8 174.39,35.8 173.3,36.89 136.63,36.89 v2(135.87,36.13)
DIMM_VREF_CA_B_R: length 2.9
  TOP w0.305: R114.2 R118.1 v2(135.7,37.08) R116.1
DIMM_VREF_CPU: length 43.7
  TOP w0.254: R46.2 210.67,120.32 210.67,121.56 210.93,121.81 211.13,121.81 R48.2 210.95,122.46 210.33,122.46 C4.1 208.56,123.45 201.73,123.45 v4(201.45,123.73)
  TOP w0.305: CPU1.AB38 v4(177.08,124.75)
  BOTTOM w0.254: v4(177.08,124.75) 178.63,126.29 179.24,126.29 182.95,130 194.89,130 195.93,128.96 v1(196.43,128.96) 196.43,128.47 201.17,123.73 v4(201.45,123.73)
DIMM_VREF_CPU_C: length 4
  TOP w0.102: C4.2 R49.1 210.47,119.38 210.47,117.96 v2(210.93,117.51)
DIMM_VREF_DQ_A: length 25.3
  TOP w0.508: DIMM4.1 222.28,69.55 222.28,67.22 220.93,65.87 DIMM2.1 220.93,64.5 223.7,61.73 C185.1 ; C185.1 C186.1 225.94,59.59 R125.2 ; C185.1 223.55,59.59 223.07,59.11 C673.1 222.31,59.98 222.05,60.23 218.93,60.23 218.68,59.98 R121.2
DIMM_VREF_DQ_B: length 29.4
  TOP w0.508: DIMM1.1 222.92,44.58 222.92,49.69 220.93,51.67 DIMM3.1 222.4,54.39 225.84,54.39 226.5,55.05 226.5,55.92 226.28,56.14 226.28,56.26 R126.2 225.97,56.52 224.85,56.52 C187.1 224.73,56.53 224.72,56.52 C188.1 223.58,56.52 223.04,57.06 C674.1 222.31,56.06 221.97,55.73 219.04,55.73 218.65,56.12 R122.2
DLA: length 18.3
  TOP w0.508: QN50.G 143.05,5.84 C828.1 R589.2 139.99,5.97 139.99,18.24 v1(140.04,18.3) 140.04,18.5 QN51.C
DMI_RX_N0: length 113
  TOP w0.102: PCH1.C20 55.96,97.29 56.32,96.93 56.64,96.93 56.9,97.19 58.03,97.19 58.32,97.49 59.41,97.49 59.49,97.41 59.49,97.28 v3(59.25,97.04) ; CPU1.T3 142.07,131.25 140.14,131.25 139.73,130.84 139,130.84 138.37,131.48 132.02,131.48 127.75,135.74 114.2,135.74 110.14,131.69 110.14,124.64 v2(109.86,124.37)
  BOTTOM w0.102: v3(59.25,97.04) 59.4,97.04 59.57,97.21 59.57,97.55 59.87,97.85 73.81,97.85 75.18,99.22 77.88,99.22 80.3,101.63 v1(80.3,102.27) 80.93,102.27 81.77,103.11 91.45,103.11 110.26,121.91 110.26,123.97 v2(109.86,124.37)
DMI_RX_N1: length 113.6
  TOP w0.102: v3(62.01,96.43) 61.88,96.55 61.75,96.55 61.37,96.17 59.04,96.17 58.83,96.38 57.33,96.38 57.26,96.31 56.68,96.31 56.56,96.43 56.21,96.43 55.9,96.43 55.59,96.74 PCH1.D21 ; CPU1.V1 140.59,130.04 140.51,130.13 138.53,130.13 138.01,130.65 131.64,130.65 127.39,134.91 115.35,134.91 111.94,131.5 111.94,125.79 112.23,125.5 v2(112.4,125.5)
  BOTTOM w0.102: v2(112.4,125.5) 112,125.91 112,126.14 112.18,126.33 112.97,126.33 113.44,125.86 113.44,125.13 112.17,123.86 112.17,122.62 108.79,119.23 108.44,119.23 108.24,119.03 90.97,101.76 88.68,101.76 v1(88.3,102.14) 87.92,101.76 82.45,101.76 79.31,98.61 75.59,98.61 74.17,97.19 63.24,97.19 62.89,96.83 62.16,96.83 62.01,96.68 v3(62.01,96.43)
DMI_RX_N2: length 115.7
  TOP w0.102: v2(114.77,123.76) 114.54,123.98 113.9,123.98 113.57,124.31 113.57,125.91 112.71,126.78 112.71,131.07 115.98,134.35 127.14,134.35 131.33,130.16 137.9,130.16 138.34,129.71 139.97,129.71 140.27,129.42 141.15,129.42 CPU1.V2 ; PCH1.B22 56.54,96.02 57.37,96.02 57.51,96.16 57.98,96.16 58.35,95.79 v3(58.43,95.79)
  BOTTOM w0.102: v2(114.77,123.76) 114.77,123.96 114.59,124.14 114.23,124.14 114.08,123.98 114.08,122.46 109.68,118.06 108.44,118.06 96.37,105.99 96.37,104.42 93.58,101.63 92.14,101.63 89.02,98.51 85.05,98.51 v1(84.61,98.08) 84.18,98.51 82.13,98.51 80.5,96.88 75.07,96.88 73.62,95.43 72.21,95.43 71.27,96.37 63.72,96.37 63.06,95.71 60.55,95.71 59.89,96.37 58.3,96.37 58.12,96.2 58.12,95.97 58.3,95.79 v3(58.43,95.79)
DMI_RX_N3: length 114.2
  TOP w0.102: v3(63.84,95.89) 64.02,95.89 64.14,95.77 64.14,95.41 64.07,95.33 62.31,95.33 61.95,94.98 60.79,94.98 59.9,95.87 59.24,95.87 58.55,95.18 57.75,95.18 57.62,95.31 57.1,95.31 PCH1.A24 ; CPU1.W3 142.05,128.49 138.69,128.49 137.66,129.52 130.85,129.52 126.66,133.71 117.17,133.71 115.3,131.84 115.3,128.15 v2(114.92,127.77)
  BOTTOM w0.102: v3(63.84,95.89) 63.72,95.78 63.72,95.47 63.85,95.35 64.41,95.35 64.73,95.03 73.82,95.03 75.27,96.48 80.73,96.48 81.57,97.31 86.14,97.31 v1(86.52,97.7) 86.9,97.31 89.06,97.31 92.36,100.62 93.19,100.62 97.75,105.17 97.75,106.76 108.31,117.33 110.31,117.33 115.88,122.9 115.88,126.39 115.2,127.08 115.2,127.49 v2(114.92,127.77)
DMI_RX_P0: length 113
  TOP w0.102: v3(60.15,97.04) 60.15,96.93 60.05,96.83 59.75,96.83 59.7,96.88 59.7,97.49 59.49,97.7 58.24,97.7 57.94,97.4 56.81,97.4 56.65,97.24 PCH1.B20 ; CPU1.U3 142.48,130.74 142.48,130.94 142.37,131.05 140.22,131.05 139.82,130.64 138.92,130.64 138.28,131.27 131.93,131.27 127.67,135.54 114.28,135.54 110.34,131.6 110.34,124.64 110.62,124.37 v2(110.73,124.37)
  BOTTOM w0.102: v3(60.15,97.04) 59.95,97.04 59.78,97.21 59.78,97.47 59.95,97.64 73.9,97.64 75.27,99.02 77.97,99.02 79.44,100.49 v1(80.04,100.49) 80.04,101.09 81.85,102.9 91.53,102.9 110.46,121.83 110.46,124.1 v2(110.73,124.37)
DMI_RX_P1: length 113.7
  TOP w0.102: v2(111.49,125.5) 111.74,125.75 111.74,131.59 115.26,135.11 127.47,135.11 131.73,130.86 138.09,130.86 138.61,130.33 140.24,130.33 CPU1.U1 ; v3(62.77,96.43) 62.36,96.83 61.75,96.83 61.29,96.37 59.12,96.37 58.92,96.58 57.25,96.58 57.18,96.51 56.76,96.51 56.64,96.64 56.13,96.64 PCH1.B21
  BOTTOM w0.102: v3(62.77,96.43) 63.33,96.98 74.25,96.98 75.67,98.41 79.39,98.41 82.54,101.56 86.34,101.56 v1(86.77,101.12) 87.2,101.56 91.05,101.56 91.24,101.75 108.53,119.03 108.87,119.03 112.38,122.54 112.38,123.77 113.65,125.04 113.65,125.94 113.05,126.53 112.1,126.53 111.79,126.23 111.79,125.8 v2(111.49,125.5)
DMI_RX_P2: length 115.7
  TOP w0.102: CPU1.W2 141.51,129.14 141.43,129.22 140.18,129.22 139.89,129.51 138.26,129.51 137.81,129.95 131.25,129.95 127.06,134.14 116.07,134.14 112.91,130.99 112.91,126.86 113.77,126 113.77,124.4 113.99,124.19 114.61,124.19 114.77,124.34 v2(114.77,124.67) ; v3(57.76,95.76) 57.7,95.82 56.3,95.82 55.99,96.13 PCH1.C22
  BOTTOM w0.102: v2(114.77,124.67) 114.77,124.62 114.49,124.34 114.15,124.34 113.88,124.07 113.88,122.54 109.6,118.27 108.36,118.27 96.17,106.08 96.17,104.51 93.5,101.84 92.06,101.84 88.93,98.71 83.47,98.71 v1(83.09,99.09) 82.71,98.71 82.04,98.71 80.42,97.09 74.99,97.09 73.54,95.64 72.3,95.64 71.35,96.58 63.63,96.58 62.97,95.92 60.64,95.92 59.98,96.58 58.22,96.58 57.92,96.28 57.92,95.91 v3(57.76,95.76)
DMI_RX_P3: length 114.2
  TOP w0.102: v2(115.78,127.77) 115.63,127.77 115.5,127.9 115.5,131.76 117.25,133.51 126.58,133.51 130.77,129.32 137.58,129.32 138.61,128.29 142.42,128.29 142.5,128.21 142.5,128.03 CPU1.Y3 ; v3(63.85,94.9) 63.62,95.13 62.39,95.13 62.03,94.77 60.7,94.77 59.82,95.66 59.32,95.66 58.64,94.98 57.67,94.98 57.54,95.1 56.87,95.1 56.51,95.46 PCH1.B24
  BOTTOM w0.102: v2(115.78,127.77) 115.58,127.77 115.4,127.59 115.4,127.16 116.09,126.47 116.09,122.82 110.4,117.13 108.4,117.13 97.95,106.68 97.95,105.09 93.28,100.41 92.45,100.41 89.14,97.11 88.6,97.11 v1(88.17,96.68) 87.74,97.11 81.65,97.11 80.81,96.27 75.35,96.27 73.9,94.82 64.64,94.82 64.32,95.14 64.09,95.14 v3(63.85,94.9)
DMI_TX_N0: length 120
  TOP w0.102: PCH1.L24 51.72,95.57 v3(51.72,95.79) ; CPU1.AA5 144.08,127.03 143.95,127.16 143.95,127.36 143.72,127.59 142.21,127.59 142.17,127.63 141.81,128 138.1,128 137.21,128.89 130.32,128.89 127.33,131.87 122.63,131.87 119.67,128.91 119.67,126.81 119.38,126.52 119.11,126.52 v2(118.78,126.85)
  BOTTOM w0.102: v3(51.72,95.79) 51.98,95.54 51.98,95.38 52.2,95.16 54.58,95.16 54.89,94.85 56.48,94.85 56.79,94.55 62.38,94.55 63.4,93.53 74.39,93.53 75.91,95.05 91.28,95.05 92.62,96.4 94.11,96.4 96.81,99.09 v1(97.44,99.09) 97.44,99.73 97.61,99.89 97.61,102.99 100.31,105.69 100.31,107.26 108.32,115.27 110.35,115.27 116.96,121.88 117.59,121.88 119.74,124.03 119.74,126.27 119.44,126.58 119.06,126.58 v2(118.78,126.85)
DMI_TX_N1: length 115.2
  TOP w0.102: PCH1.G24 53.57,95.53 v3(53.83,95.79) ; v2(117.83,125.01) 118.09,124.75 119.35,124.75 120.35,125.75 120.35,128.69 122.83,131.17 126.84,131.17 129.76,128.25 136.71,128.25 137.8,127.16 140.4,127.16 140.87,126.69 142.84,126.69 143.06,126.47 143.06,126.22 143.16,126.12 CPU1.AB4
  BOTTOM w0.102: v2(117.83,125.01) 118.14,124.7 118.43,124.7 118.73,124.4 118.73,123.93 117.3,122.51 116.7,122.51 110.43,116.24 108.4,116.24 98.58,106.42 98.58,104.86 96.17,102.45 96.17,101.98 93.12,98.93 v1(93.12,98.33) 92.52,98.33 89.86,95.66 75.63,95.66 74.11,94.14 63.58,94.14 62.59,95.13 60.36,95.13 59.82,95.66 59.32,95.66 58.72,95.06 57.33,95.06 56.2,96.2 53.81,96.2 53.76,96.2 53.65,96.09 53.65,95.97 v3(53.83,95.79)
DMI_TX_N2: length 111.9
  TOP w0.102: v3(54.03,94.75) 54.03,94.44 54.27,94.21 PCH1.F26 ; v4(142.89,125.69) 142.89,125.65 CPU1.AC4
  BOTTOM w0.102: v4(142.89,125.69) 143.1,125.89 143.21,125.89 143.34,125.76 143.34,125.43 143.16,125.25 142.21,125.25 141.42,126.04 141.14,126.04 140.26,126.92 139.34,126.92 138.64,127.62 130.66,127.62 125.84,122.79 120.43,122.79 118.2,120.56 117.38,120.56 110.22,113.39 108.59,113.39 106.22,111.03 104.93,111.03 100.74,106.84 100.74,105.55 98.99,103.8 98.99,102.8 v1(98.58,102.39) 98.99,101.99 98.99,99.53 95.15,95.69 92.77,95.69 91.73,94.65 76.11,94.65 74.58,93.12 63.29,93.12 62.17,94.24 53.84,94.24 53.71,94.38 53.71,94.6 53.83,94.72 54.01,94.72 v3(54.03,94.75)
DMI_TX_N3: length 111.2
  TOP w0.102: v3(52.41,94.75) 52.14,94.48 PCH1.K26 ; CPU1.AC2 141.33,125.2 141.15,125.38 141.15,125.72 140.92,125.95 140.49,125.95 140.16,125.62 139.11,125.62 138.97,125.76 138.97,125.9 v4(139.25,126.18)
  BOTTOM w0.102: v3(52.41,94.75) 52.15,94.5 52.15,94.09 52.51,93.73 61.88,93.73 63.1,92.51 75.11,92.51 76.64,94.04 92.39,94.04 93.35,95 95.5,95 100.54,100.04 100.54,103.11 v1(100.11,103.54) 100.54,103.97 100.54,104.48 101.38,105.32 101.38,106.59 105.19,110.4 106.45,110.4 108.84,112.78 110.5,112.78 117.49,119.78 118.28,119.78 120.68,122.18 126.12,122.18 130.85,126.91 138.59,126.91 139.25,126.24 v4(139.25,126.18)
DMI_TX_P0: length 120
  TOP w0.102: v3(52.41,95.82) 52.14,95.55 PCH1.K24 ; v2(118.78,125.89) 118.78,126.19 118.9,126.32 119.46,126.32 119.87,126.73 119.87,128.82 122.71,131.67 127.25,131.67 130.23,128.68 137.13,128.68 138.02,127.79 141.72,127.79 142.09,127.43 142.09,127.43 142.13,127.39 143.64,127.39 143.75,127.28 143.75,127.13 143.64,127.03 CPU1.AA4
  BOTTOM w0.102: v3(52.41,95.82) 52.27,95.82 52.18,95.73 52.18,95.47 52.29,95.36 54.67,95.36 54.97,95.05 56.57,95.05 56.87,94.75 62.47,94.75 63.48,93.73 74.3,93.73 75.83,95.26 91.19,95.26 92.54,96.6 94.03,96.6 95.54,98.11 v1(95.54,98.71) 96.14,98.71 97.4,99.98 97.4,103.07 100.11,105.78 100.11,107.35 108.24,115.48 110.27,115.48 116.87,122.08 117.51,122.08 119.54,124.11 119.54,126.19 119.35,126.37 118.58,126.37 118.47,126.27 118.47,125.94 118.52,125.89 v2(118.78,125.89)
DMI_TX_P1: length 115.2
  TOP w0.102: PCH1.H24 52.85,95.53 v3(53.12,95.79) ; CPU1.AB3 142.76,126.12 142.86,126.22 142.86,126.39 142.76,126.49 140.79,126.49 140.32,126.96 137.71,126.96 136.62,128.05 129.67,128.05 126.75,130.97 122.92,130.97 120.56,128.61 120.56,125.67 119.43,124.54 117.95,124.54 117.83,124.42 v2(117.83,124.15)
  BOTTOM w0.102: v3(53.12,95.79) 53.25,95.79 53.45,95.99 53.45,96.17 53.68,96.4 53.9,96.4 56.28,96.4 57.42,95.27 58.64,95.27 59.24,95.87 59.91,95.87 60.44,95.33 62.68,95.33 63.67,94.34 74.02,94.34 75.55,95.87 89.77,95.87 91.22,97.31 v1(91.22,97.95) 91.85,97.95 95.97,102.06 95.97,102.53 98.38,104.94 98.38,106.51 108.31,116.44 110.34,116.44 116.62,122.71 117.22,122.71 118.52,124.02 118.52,124.32 118.35,124.49 117.95,124.49 117.83,124.37 v2(117.83,124.15)
DMI_TX_P2: length 111.9
  TOP w0.102: v4(143.79,125.69) 143.79,125.66 CPU1.AC5 ; PCH1.G26 53.22,94.55 v3(53.22,94.72)
  BOTTOM w0.102: v4(143.79,125.69) 143.72,125.69 143.54,125.51 143.54,125.35 143.25,125.05 142.12,125.05 141.33,125.84 141.05,125.84 140.18,126.72 139.25,126.72 138.56,127.41 130.75,127.41 125.92,122.59 120.52,122.59 118.28,120.35 117.46,120.35 110.3,113.19 108.67,113.19 106.31,110.83 105.02,110.83 100.95,106.76 100.95,105.47 99.19,103.71 99.19,101.4 v1(99.6,101) 99.19,100.59 99.19,99.45 95.23,95.49 92.85,95.49 91.81,94.44 76.19,94.44 74.67,92.92 63.2,92.92 62.09,94.04 53.76,94.04 53.51,94.29 53.51,94.44 v3(53.22,94.72)
DMI_TX_P3: length 111.2
  TOP w0.102: CPU1.AC1 140.82,125.2 140.95,125.33 140.95,125.64 140.84,125.75 140.57,125.75 140.25,125.42 139.03,125.42 138.75,125.69 138.75,125.97 v4(138.54,126.18) ; PCH1.L26 51.43,94.43 v3(51.72,94.72)
  BOTTOM w0.102: v3(51.72,94.72) 51.95,94.5 51.95,94 52.42,93.53 61.8,93.53 63.02,92.31 75.2,92.31 76.72,93.83 92.47,93.83 93.44,94.8 95.59,94.8 100.74,99.95 100.74,101.63 v1(101.12,102.01) 100.74,102.4 100.74,104.4 101.58,105.24 101.58,106.5 105.27,110.19 106.53,110.19 108.92,112.58 110.58,112.58 117.58,119.58 118.37,119.58 120.77,121.98 126.21,121.98 130.93,126.7 138.51,126.7 138.77,126.44 138.77,126.25 138.7,126.18 v4(138.54,126.18)
DONGLE_DP: length 12.8
  TOP w0.102: v2(193.02,208.41) 193.02,208.21 192.11,207.3 QN75.G 190.79,208.31 189.01,208.31 QN73.G 187.99,205.49 R789.2 188.09,203.99 R793.1 188.85,203.96 190.28,205.39 QN74.D
DONGLE_DP2: length 9.6
  TOP w0.102: QN13.G 220,212.25 218.35,212.25 QN12.G 217.36,211.2 R85.1 ; v1(216.34,209.68) 216.49,209.84 R85.1 ; R85.1 217.36,208.81 R81.2 217.3,207.65 QN11.D
DONGLE_HDMI: length 13.4
  TOP w0.102: QN71.G 191.55,212.53 QN69.G 187.76,212.53 186.85,211.61 186.85,208.79 R790.2 185.53,207.47 v1(185.53,206.56) 185.53,204.43 QN72.D
DONGLE_HDMI2: length 15.2
  TOP w0.102: R82.2 224.35,207.42 QN10.D 221.9,207.3 221.9,207.8 v2(222.79,208.69) ; v2(219.36,215.09) QN7.G 220.76,216.31 QN9.G
  BOTTOM w0.102: v2(219.36,215.09) 219.36,212.12 v1(221.7,209.79) 222.41,209.07 v2(222.79,208.69)
DONGLE_HDMI2_CT: length 6.1
  TOP w0.102: QN10.G 220.61,205.14 v1(219.62,206.13) 218.31,207.43 R85.2
DONGLE_HDMI_CT: length 5.9
  TOP w0.102: R793.2 187.07,203.01 v1(187.05,203.03) 186.6,203.49 184.82,203.49 183.42,204.88 QN72.G
DOT96_N: length 21.6
  TOP w0.102: v2(31.91,116.87) 31.66,117.13 R140.1 ; v3(38.95,102.42) 38.95,102.17 39.22,101.89 PCH1.AP11
  BOTTOM w0.102: v3(38.95,102.42) 38.95,102.6 36.3,105.24 36.3,106.12 35.44,106.98 35.44,108.03 v1(34.98,108.49) 34.7,108.77 34.7,110.52 30.39,114.84 30.39,115.88 31.38,116.87 v2(31.91,116.87)
DOT96_P: length 20.3
  TOP w0.102: v3(39.61,102.42) 40.09,101.94 PCH1.AM11 ; R141.1 v2(31.78,115.98)
  BOTTOM w0.102: v2(31.78,115.98) 31.5,115.98 30.94,115.42 30.94,114.61 35.15,110.4 v1(35.36,110.4) 35.69,110.07 35.69,107.02 36.51,106.2 36.51,105.36 38.89,102.98 39.05,102.98 v3(39.61,102.42)
DP2_HPD: length 303.7
  TOP w0.102: QN6.S v2(225.97,220.76) ; PCH1.AH5 41.95,105.89 41.95,107.15 42.07,107.26 42.07,108.39 41.31,109.15 41.31,110.1 41.1,110.31 40.46,110.95 40.33,111.08 38.89,111.08 38.04,111.93 38.04,117.47 36.43,119.08 35.57,119.08 v2(34.25,120.4)
  BOTTOM w0.102: v2(34.25,120.4) 33.33,120.4 30.78,122.95 30.78,179.61 31.52,180.35 31.52,183.18 34.63,186.29 34.63,188.26 36.69,190.33 37.77,190.33 39.09,191.65 40.44,191.65 41.7,192.91 43.13,192.91 44.4,191.64 46.59,191.64 49.51,194.56 49.51,195.97 50.48,196.93 52.06,196.93 52.42,196.58 54.53,196.58 58.29,200.34 59.32,200.34 60.18,201.2 65.94,201.2 69.04,204.3 98.75,204.3 100.53,206.08 104.94,206.08 105.4,205.62 107.78,205.62 110.57,208.41 113.81,208.41 117.01,211.61 120.44,211.61 121.28,210.78 129.89,210.78 134.01,214.89 137.41,214.89 143.25,220.73 148.85,220.73 149.74,221.62 153.8,221.62 154.85,222.66 160.05,222.66 161.81,220.91 187.84,220.91 188.88,219.87 191.68,219.87 193.33,218.22 195.82,218.22 196.4,218.8 214.48,218.8 216.44,220.76 v1(221.04,220.76) v2(225.97,220.76)
DP2_HPD_QN: length 9
  TOP w0.102: v2(224.77,221.88) 225.53,221.88 225.97,222.31 QN6.D 225.97,223.46 R76.1 223.58,224.6 C825.1 224.11,225.19 224.11,227.34 R79.1
DP_HPD: length 272
  TOP w0.102: v2(193.96,218.85) 193.96,218.6 QN68.S ; PCH1.AJ2 41.63,107.2 41.87,107.43 41.87,108.3 41.1,109.07 41.1,109.99 40.22,110.88 38.81,110.88 37.96,111.73 37.95,111.73 37.82,111.86 37.82,117.37 37.59,117.6 36.36,118.83 35.01,118.83 v2(34.25,119.59)
  BOTTOM w0.102: v2(193.96,218.85) 193.68,218.85 v1(193,219.54) 192.41,220.12 189.14,220.12 187.99,221.27 161.83,221.27 160.2,222.89 154.57,222.89 153.52,221.85 149.58,221.85 148.69,220.96 143.16,220.96 137.31,215.12 133.91,215.12 129.8,211 121.42,211 120.58,211.84 116.92,211.84 113.72,208.64 110.48,208.64 107.68,205.85 105.49,205.85 105.04,206.31 100.44,206.31 98.66,204.53 68.94,204.53 65.87,201.45 60.12,201.45 59.23,200.57 58.2,200.57 54.44,196.81 52.51,196.81 52.13,197.19 50.38,197.19 49.28,196.1 49.28,195.08 47,192.79 46.03,192.79 45.27,193.56 44.2,193.56 42.88,194.88 41.87,194.88 40.49,193.5 39.25,193.5 38.01,192.26 36.33,192.26 34.4,190.33 34.4,186.39 31.29,183.28 31.29,180.44 30.55,179.7 30.55,122.86 33.82,119.59 v2(34.25,119.59)
DP_HPD_CNN: length 21.8
  TOP w0.102: U6.4 191.48,220.57 191.93,221.01 192.85,221.01 R787.2 197.26,225.43 197.26,231.3 198.79,232.82 198.79,234.09 198.15,234.73 195.97,234.73 DP2.18
DP_HPD_CNN2: length 17.4
  TOP w0.102: v2(223.12,221.37) 223.49,221.73 U3.4 223.49,223.62 222.92,224.19 222.92,228.51 223.14,228.73 R79.2 223.68,229.52 221.65,231.55 221.65,234.35 221.27,234.73 220.17,234.73 DP1.18
DP_HPD_QN: length 5.5
  TOP w0.102: QN68.D v2(195.13,219.87) 195.73,219.87 C826.1 196.43,220.83 195.96,221.3 R784.1 R787.1
DP_MOS_G: length 8.9
  TOP w0.508: v2(225.24,211.2) 224.98,210.95 R78.2 ; QN8.G v2(225.84,217.84)
  BOTTOM w0.508: 225.24,217.18 v2(225.24,211.2) ; 225.24,217.18 v1(225.28,217.23) ; 225.24,217.18 225.24,217.23 v2(225.84,217.84)
DP_PWR_FUSE:
  vias: v1(229.29,214.99)
DP_RCOMP: length 10.3
  TOP w0.305: R1.2 134.91,134.84 137,132.75 137.95,132.75 138.64,132.06 142.88,132.06 CPU1.R4
DPWROK: length 363.3
  TOP w0.102: U21.17 214.48,33.49 213.9,34.07 213.9,35.13 C689.1 212.74,36.29 R351.1 212.23,36.99 209.71,36.99 209.51,36.79 208.9,36.79 208.19,37.5 204.48,37.5 203.54,36.56 197.19,36.56 196.81,36.18 196.81,31.83 197.06,31.58 197.06,30.08 195.82,28.84 195.82,26.47 194.98,25.64 194.98,24.04 193.88,22.94 193.88,21.54 QN83.C 191.8,23.02 190.79,23.02 188.25,20.48 187.61,20.48 185.43,18.29 185.43,16.16 186.72,14.86 186.72,13.74 187.99,12.47 187.99,10.34 187.76,10.12 v2(187.76,9.74) ; PCH1.AV38 36.77,88.18 35.47,88.18 33.81,86.53 33.81,85 32.16,83.34 32.16,82.17 31.54,81.54 28.91,81.54 26.91,79.53 26.91,72.36 25,70.45 24.38,70.45 R761.2 C690.2 22.73,70.01 22.29,70.45 20.26,70.45 18.63,68.83 16.87,68.83 14.89,66.85 10.97,66.85 v2(10.32,66.2)
  BOTTOM w0.102: v2(10.32,66.2) 10.32,64.29 10.85,63.76 10.85,59.11 8.67,56.93 8.67,38.02 7.4,36.75 7.18,36.75 6.56,36.13 6.56,34.93 6.99,34.5 6.99,30.68 3.84,27.53 3.84,10.72 10.88,3.68 51.53,3.68 54.28,6.43 59.41,6.43 63.25,2.59 72.29,2.59 73.49,3.79 73.49,9.12 73.58,9.2 73.58,9.24 77.58,13.24 84.82,13.24 84.84,13.27 84.85,13.27 85.53,13.95 88.09,13.95 92.07,9.97 101.41,9.97 103.54,12.1 111.03,12.1 112.43,13.49 139.94,13.49 v1(140.9,12.53) 143.52,9.91 160.82,9.91 161.06,9.67 161.15,9.58 182.13,9.58 183.42,8.29 186.32,8.29 v2(187.76,9.74)
DRAM_PWROK: length 421.4
  TOP w0.102: v2(86.52,43.09) 86.27,43.34 81.44,43.34 77.15,47.64 77.15,56.22 75.8,57.56 71.3,57.56 v2(70.77,58.1) ; v2(41.33,77.07) 41.33,77.1 41.21,76.97 41.21,76.17 40.95,75.92 40.95,67.06 39.53,65.63 39.53,60.35 41.75,58.12 43.08,58.12 43.68,57.52 49.11,57.52 52.48,60.89 63.05,60.89 63.66,61.5 65.48,61.5 66.29,60.69 72.35,60.69 v2(72.8,60.23) ; v2(43.97,83.85) 44.4,84.28 44.4,86.15 44.34,86.21 44.24,86.32 44.24,86.66 44.37,86.78 44.37,87.1 44.05,87.41 PCH1.AE38
  BOTTOM w0.102: SR16.2 168.75,120.07 SR23.1 170.66,121.98 170.66,123.13 SR22.1 170.15,124.56 171.69,126.09 177.02,126.09 179.18,128.25 180.07,128.25 182.61,130.79 195.92,130.79 198.25,128.45 198.25,127.44 201.17,124.52 201.96,124.52 202.72,123.76 203.83,123.76 208.19,119.41 210.09,119.41 213.27,116.24 213.27,114.59 216.59,111.26 216.59,102.51 221.29,97.81 221.29,87.14 227.36,81.07 227.36,75.88 227.87,75.37 227.87,74.96 230.94,71.89 230.94,66.43 231.55,65.82 v1(233.1,65.82) 233.74,66.45 236.3,66.45 237.14,65.62 237.14,65.01 238.41,63.74 238.41,54.39 234.86,50.83 234.86,45.75 233.59,44.48 233.59,39.31 232.45,38.18 232.45,33.28 229.52,30.35 225.29,30.35 223.24,28.3 210.9,28.3 205.52,22.92 201.36,22.92 201.13,22.69 199.81,22.69 198.95,21.83 197.92,21.83 196.86,20.76 194.34,20.76 193.68,21.42 191.96,21.42 191.14,22.23 179.09,22.23 177.7,20.84 166.28,20.84 166.07,21.04 165.27,21.04 165.18,20.95 165.17,20.95 164.8,20.58 161.14,20.58 160.15,21.57 152.2,21.57 149,24.77 141.84,24.77 140.01,26.6 129.01,26.6 128.17,27.44 127.18,27.44 122.79,31.83 94.85,31.83 93.5,33.17 93.5,36.98 92.74,37.75 91.28,39.2 89.64,39.2 86.52,42.32 v2(86.52,43.09) ; v2(72.8,60.23) 70.77,58.2 v2(70.77,58.1) ; v2(43.97,83.85) 43.87,83.75 43.87,78.42 42.53,77.07 v2(41.33,77.07)
DRAM_PWROK_RC: length 6.6
  TOP w0.102: CPU1.AK21 v4(161.54,118.35)
  BOTTOM w0.102: v4(161.54,118.35) 161.09,118.79 161.09,119.53 SC11.1 161.91,120.35 162.92,120.35 163.2,120.07 SR16.1
DRAMRT: length 54.5
  TOP w0.102: CPU1.AK22 v4(162.45,118.35) ; v2(177.83,77.63) R68.1
  GND w0.102: v4(162.45,118.35) 162.99,118.88 163.53,118.88 163.83,118.58 163.83,117.8 166.15,115.48 166.15,112 166.65,111.49 167.28,111.49 167.49,111.28 167.49,110.89 168.1,110.28 168.1,109.38 169.76,107.73 170.01,107.73 170.36,107.37 170.36,107.17 171.86,105.67 171.86,102.9 178.47,96.3 178.47,78.26 v2(177.83,77.63)
DVI_CLK_DN_C: length 41.2
  TOP w0.102: CMK12.4 179.22,219.34 178.9,219.67 178.9,220.23 178.81,220.32 178.81,220.6 178.96,220.75 U10.5 U10.6 178.96,222.54 178.81,222.69 178.81,223.26 179.23,223.68 179.23,232.7 174.99,236.94 174.99,239.38 173.34,241.03 159.43,241.03 158.83,240.43 158.83,239.99 158.56,239.71 DVI-D.24
DVI_CLK_DP_C: length 41.2
  TOP w0.102: DVI-D.23 159.6,239.36 159.2,239.36 159.04,239.53 159.04,240.35 159.51,240.82 173.26,240.82 174.78,239.3 174.78,236.85 179.03,232.61 179.03,223.76 178.61,223.35 178.61,222.69 178.46,222.54 U10.7 U10.4 178.46,220.75 178.61,220.6 178.61,220.24 178.7,220.15 178.7,219.72 178.37,219.39 CMK12.1
DVI_HPD: length 229.7
  TOP w0.102: PCH1.AJ4 41.33,106.25 41.33,106.83 41.37,106.87 41.37,107.26 41.18,107.44 41.18,107.79 41.07,107.89 40.88,108.09 40.88,109.89 40.34,110.42 v3(40.01,110.42) ; v2(148.11,215.92) 147.86,215.92 146.08,214.14 146.08,210.08 146.96,209.2 149.74,209.2 150.53,208.41 150.53,206.79 150.4,206.66 R106.2 149.48,207.84 QN21.S
  BOTTOM w0.102: v3(40.01,110.42) 38.95,111.49 38.95,112.35 39.68,113.09 39.68,117.74 38.68,118.74 37.87,118.74 37.01,119.59 37.01,122.51 32.38,127.14 32.38,178.87 33.12,179.61 33.12,180.17 33.12,182.42 36.23,185.53 36.23,186.46 36.9,187.13 38.11,187.13 39.35,188.37 40.67,188.37 41.98,189.68 42.87,189.68 44.09,188.47 47.47,188.47 50.02,191.02 53.93,191.02 57.31,194.4 57.31,195.69 57.99,196.37 58.72,196.37 59.66,197.31 63.43,197.31 64.45,198.33 66.5,198.33 70.87,202.7 99.7,202.7 101.48,204.48 104.07,204.48 104.53,204.02 108.69,204.02 111.43,206.76 114.5,206.76 116.87,209.13 130.51,209.13 134.65,213.27 138.05,213.27 139.85,215.07 v1(143.03,215.07) 143.89,215.92 v2(148.11,215.92)
DVI_HPD_D: length 6.3
  TOP w0.102: v2(149.38,210.42) 149.31,210.34 QN21.D 147.2,210.34 146.97,210.57 R109.1 147.96,211.65 C116.2 149.35,211.93 R103.2
DVI_HPD_D_R: length 28.6
  TOP w0.102: DVI-D.16 156.62,236.39 156.62,233.9 153.96,231.23 153.96,226.09 151.86,224 U9.6 151.86,221.59 151.34,221.06 151.34,218.14 149.92,216.72 149.92,213.13 R103.1
DVI_SCL: length 33.2
  TOP w0.102: DVI-D.6 161.63,235.9 154.97,229.24 154.97,225.99 154.2,225.21 154.2,221.27 153.76,220.83 U9.3 153.76,219.01 153.31,218.55 152.18,218.55 151.8,218.17 151.8,217.61 151.24,217.05 151.24,213.5 151.11,213.37 151.11,212.23 R105.2 150.58,211.7 150.58,210.37 150.86,210.09 152.31,210.09 QN20.D
DVI_SDA: length 36.7
  TOP w0.102: DVI-D.7 154.44,230.39 154.44,226.07 152.18,223.81 152.18,222.83 152.3,222.72 152.3,219.94 U9.1 151.86,218.56 151.57,218.26 151.57,217.71 151.01,217.15 151.01,216.89 R108.2 150.15,216.03 150.15,210.22 150.71,209.66 155.81,209.66 QN23.D
DVI_TX0_DN_C: length 27
  TOP w0.102: CMK10.4 177.55,219.42 177.22,219.74 177.22,220.25 177.31,220.34 177.31,220.6 177.46,220.75 U10.2 U10.9 177.46,222.54 177.31,222.69 177.31,223.54 178.47,224.7 178.47,232.19 174.15,236.51 174.15,237.65 172.94,238.86 170.68,238.86 170.53,239.02 170.53,239.5 170.75,239.71 DVI-D.17
DVI_TX0_DP_C: length 27
  TOP w0.102: CMK10.1 176.7,219.39 177.02,219.72 177.02,220.33 177.11,220.42 177.11,220.6 176.96,220.75 U10.1 U10.10 176.96,222.54 177.11,222.69 177.11,223.62 178.26,224.78 178.26,232.1 173.95,236.42 173.95,237.57 172.85,238.66 170.6,238.66 170.33,238.93 170.33,239.5 170.11,239.71 DVI-D.18
DVI_TX1_DN_C: length 24.9
  TOP w0.102: CMK11.4 175.29,219.34 174.94,219.69 174.94,220.35 174.87,220.41 174.87,220.6 175.02,220.75 U8.10 U8.1 175.02,222.55 174.87,222.69 174.87,223.52 177.45,226.09 177.45,231.97 172.46,236.96 170.68,236.96 170.53,237.11 170.53,237.46 170.88,237.81 DVI-D.9
DVI_TX1_DP_C: length 24.9
  TOP w0.102: DVI-D.10 170.04,237.81 170.33,237.52 170.33,237.03 170.6,236.76 172.38,236.76 177.25,231.88 177.25,226.18 174.67,223.6 174.67,222.69 174.52,222.55 U8.2 U8.9 174.52,220.75 174.67,220.6 174.67,220.33 174.73,220.27 174.73,219.69 174.44,219.39 CMK11.1
DVI_TX2_DN_C: length 19.3
  TOP w0.102: CMK9.4 173.61,219.32 173.31,219.62 173.31,220.15 173.37,220.21 173.37,220.6 173.52,220.75 U8.7 U8.4 173.52,222.55 173.37,222.69 173.37,223.82 170.53,226.66 170.53,235.74 170.69,235.9 DVI-D.1
DVI_TX2_DP_C: length 19.3
  TOP w0.102: CMK9.1 172.76,219.27 173.11,219.62 173.11,220.23 173.17,220.3 173.17,220.6 173.02,220.75 U8.6 U8.5 173.02,222.55 173.17,222.69 173.17,223.74 170.33,226.58 170.33,235.71 170.14,235.9 DVI-D.2
EECS: length 32.8
  TOP w0.102: RLAN.44 46.67,227.52 44.46,225.31 42.74,225.31 41.94,224.51 41.94,219.36 v2(41.43,218.85) ; ROM2.1 34.07,202.75 34.6,203.28 34.6,207.46 35.97,208.83 v1(35.97,210.85) 35.97,214.03 v2(36.25,214.31)
  BOTTOM w0.102: v2(41.43,218.85) 41,218.85 36.45,214.31 v2(36.25,214.31)
EEDI: length 32.6
  TOP w0.102: v2(42.2,218.85) 42.58,219.23 42.58,221.23 R453.1 44.76,223.42 44.76,224.03 46.75,226.02 RLAN.47 ; v2(35.16,212.96) 34.4,212.2 34.4,211.3 34.12,211.02 34.12,209.33 33.15,208.36 31.48,208.36 30.28,207.17 27.21,207.17 26.6,206.56 ROM2.5
  BOTTOM w0.102: v2(35.16,212.96) 35.67,212.96 37.42,214.71 v1(37.98,214.71) 37.98,215.27 41.05,218.35 41.69,218.35 v2(42.2,218.85)
EEDO: length 32.2
  TOP w0.102: v2(42.58,222.54) 42.32,222.79 42.32,224.57 42.83,225.08 44.55,225.08 46.49,227.02 RLAN.45 ; v2(35.31,213.7) 35.74,213.27 35.74,211.89 35.08,211.23 35.08,210.5 35.74,209.84 35.74,208.92 34.37,207.55 34.37,204.32 34.07,204.02 ROM2.2
  BOTTOM w0.102: v2(35.31,213.7) 35.31,214.15 36.41,215.25 37.07,215.25 42.58,220.76 v1(42.58,221.6) v2(42.58,222.54)
EESK: length 34
  TOP w0.102: v2(43.09,218.85) 44.61,220.38 44.61,222.92 44.99,223.3 44.99,223.93 46.57,225.52 RLAN.48 ; v2(35.16,212.22) 34.65,211.72 34.65,211.18 34.35,210.88 34.35,209.23 33.26,208.13 31.63,208.13 30.41,206.92 27.72,206.92 27.34,206.53 27.34,205.93 26.7,205.29 ROM2.6
  BOTTOM w0.102: v2(35.16,212.22) 35.16,212.09 37.02,213.95 38.21,213.95 38.64,214.38 38.64,215.58 41.18,218.12 42.6,218.12 v1(42.63,218.14) 43.09,218.6 v2(43.09,218.85)
EN1/SS1: length 5.3
  TOP w0.178: 55.64,33.96 U41.12
  TOP w0.203: 55.64,33.96 56.98,33.96 C797.1 57.6,34.58 58.55,34.58 v1(58.96,34.17) 58.97,34.16 R924.1
EN2/SS2: length 6.8
  TOP w0.178: 55.68,33.31 55.53,33.16 U41.10
  TOP w0.203: 55.68,33.31 55.8,33.43 56.71,33.43 C789.1 57.75,32.39 59.24,32.39 59.47,32.16 59.47,31.27 59.56,31.18 R911.1
EUP_SW_N1: length 5
  TOP w0.102: v2(119.51,30.79) 118.78,30.06 QN61.B 118.44,29.62 117.71,30.35 C598.2 117.21,30.35 116.24,31.33 R630.1
EUP_SW_N2: length 4.9
  TOP w0.102: R628.2 R625.1 122.21,32.16 v1(122,32.37) 120.25,32.37 QN61.C
EUP_SW_N3: length 5
  TOP w0.254: R623.1 124.4,28.96 v1(125.38,28.96) ; R623.1 124.37,29.47 124.49,29.6 C597.1 R628.1 ; R623.1 R631.1
EUP_SW_N4: length 14.8
  TOP w0.254: R623.2 125,27.66 v1(125,27.26) 125,24.67 126.27,23.4 133.07,23.4 C594.1 134.4,22.07 QSW2.G
EUP_SW_N5: length 14.8
  TOP w0.254: QSW3.G 112.71,29.34 113.06,28.99 v2(113.06,28.61) ; R631.2 123.22,27.91 v1(123.22,27.26) 123.22,27.08 122.36,26.22 120.81,26.22 119.86,27.17 C600.1 117.23,27.85 116.62,28.46 v2(116.62,28.61)
  BOTTOM w0.254: v2(116.62,28.61) v2(113.06,28.61)
EXT_ARB: length 3.5
  TOP w0.102: R285.1 48.95,143.47 48.95,143.77 v1(49.41,144.23) 49.83,144.23 49.97,144.09 U11.92
F_PANEL_P6: length 3.6
  TOP w0.254: F_PANEL.6 7.09,48.93 8.95,47.07 R1000.1
F_PANEL_P11: length 5.6
  TOP w0.254: F_PANEL.11 5.29,41.31 6.69,39.91 7.45,39.91 8.34,39.02 R429.2
F_PANEL_P12: length 2.5
  TOP w0.254: R392.1 7.86,40.42 F_PANEL.12
F_PANEL_P14: length 15.3
  TOP w0.254: QP3.E 10.88,41.56 8.47,41.56 7.7,42.32 3.77,42.32 3.39,41.94 3.39,40.67 4.02,40.04 5.42,40.04 6.69,38.77 F_PANEL.14
FAN_CTL1: length 78.5
  TOP w0.102: v2(218.6,33.94) 218.48,33.82 U21.9 ; R378.2 R376.1 230.06,90.74 229.78,90.46 229.78,89.31 227.05,86.58 227.05,86.2 225.97,85.12 225.97,77.32 225.18,76.53 225.18,72.73 225.97,70.39 226.23,69.77 227.81,68.19 229.09,68.19 230.97,66.31 230.97,60.17 232.04,59.11 232.04,51.57 228.51,48.04 v2(227.74,48.04)
  BOTTOM w0.102: v2(218.6,33.94) 219.52,33.94 220,34.42 221.11,34.42 v1(221.6,33.94) 222.25,33.94 224.29,35.98 224.29,37.24 225.64,38.59 225.64,43.08 226.75,44.2 226.75,45.96 225.86,46.84 225.86,47.68 226.35,48.17 227.62,48.17 v2(227.74,48.04)
FAN_CTL1_R: length 4.9
  TOP w0.102: R376.2 234.52,91.69 CPU_FAN.4
FAN_CTL2: length 335.3
  TOP w0.102: v2(227.62,49.31) 228.63,50.32 229.65,50.32 231.3,51.98 231.3,58.2 v2(230.66,58.83) ; v2(230.79,201.78) 231.5,201.07 238.41,201.07 240.77,198.71 240.77,87.67 239.37,86.27 232.15,86.27 229.6,83.71 229.6,75.74 235.34,70 v2(235.34,65.82) ; v2(146.32,199.37) 143.74,199.37 143.31,198.94 136.9,198.94 128.43,190.47 128.43,185.32 126.25,183.14 122.8,183.14 121.08,184.87 117.72,184.87 R384.1 R370.2 114.11,183.9 112.94,185.07 R373.1 ; U21.11 217.48,33.41 217.08,33.81 v2(216.69,33.81)
  BOTTOM w0.102: v2(230.79,201.78) 230.11,202.47 210.35,202.47 207.75,199.87 205.05,199.87 203.33,198.15 147.1,198.15 146.32,198.93 v2(146.32,199.37) ; v2(235.34,65.82) 234.88,65.82 233.84,64.78 233.84,64.14 230.66,60.97 v2(230.66,58.83) ; v2(227.62,49.31) 225.84,49.31 v1(225.46,48.93) 224.92,48.39 224.92,38.88 223.58,37.54 223.58,36.27 222.49,35.19 218.98,35.19 218.04,34.25 217.13,34.25 v2(216.69,33.81)
FAN_CTL2_OP_P1:
  vias: v2(117.13,190.91)
FAN_CTL2_OP_P2: length 5.2
  TOP w0.254: R373.2 112.94,187.48 v1(113.7,188.25) 114.08,188.63 C407.1 U22.2
FAN_CTL2_OP_P3: length 3.4
  TOP w0.254: R380.1 v2(114.81,187.2) R381.1 115.7,187.2 115.86,187.36 U22.3
FAN_TAC1: length 83.8
  TOP w0.102: R377.2 R372.2 232.32,95.76 232.06,95.5 232.06,93.98 225.61,87.53 225.61,77.46 224.82,76.68 224.82,72.63 225.56,70.19 225.89,69.27 227.39,67.78 229,67.78 230.56,66.21 230.56,60.08 231.68,58.96 231.68,51.85 229.78,49.94 229.01,49.94 228.38,49.31 v2(228.38,48.8) ; v2(219.23,34.58) 219.11,34.7 219.11,35.21 219.27,35.37 C391.1 219.87,35.12 219.87,34.45 218.98,33.56 U21.8
  BOTTOM w0.102: v2(219.23,34.58) 219.49,34.83 222.64,34.83 223.93,36.13 223.93,37.39 225.28,38.74 225.28,43.62 225.84,44.18 v1(225.84,45.17) 225.84,45.8 225.28,46.36 225.28,47.73 226.22,48.67 228.25,48.67 v2(228.38,48.8)
FAN_TAC1_R: length 16
  TOP w0.102: CPU_FAN.3 236.7,92.06 234.05,92.06 R369.1 232.82,93.28 232.82,94.3 R372.1 233.62,94.81 234.27,95.46 D5.P
FAN_TAC2: length 328.1
  TOP w0.102: v2(229.74,201.73) 230.78,200.69 238.03,200.69 240.42,198.3 240.42,87.85 239.19,86.62 232.01,86.62 229.24,83.86 229.24,75.59 234.7,70.13 234.7,65.21 v2(234.98,64.93) ; R383.2 R382.2 119.9,184.51 120.93,184.51 122.66,182.79 126.4,182.79 128.81,185.2 128.81,189.83 137.56,198.58 201.12,198.58 202.32,199.78 204.65,199.78 v2(205.26,199.17) ; v2(227.24,49.94) 226.7,50.48 226.7,52.46 227.87,53.63 229.14,53.63 229.65,53.12 230.39,53.12 230.92,53.65 230.92,57.69 v2(230.66,57.94) ; v2(217.71,34.96) 218.12,35.37 C392.1 218.47,34.46 217.98,33.97 U21.10
  BOTTOM w0.102: v2(229.74,201.73) 229.38,202.09 210.47,202.09 207.55,199.17 v2(205.26,199.17) ; v2(230.66,57.94) 231.3,58.58 231.3,60.41 v1(234.12,63.23) 234.98,64.09 v2(234.98,64.93) ; v2(227.24,49.94) 225.38,49.94 224.57,49.13 224.57,39.03 223.22,37.68 223.22,36.42 222.34,35.54 218.83,35.54 218.25,34.96 v2(217.71,34.96)
FB2_G: length 6.8
  TOP w0.254: FB17.1 240.19,29.62 240.82,30.26 240.82,33.18 240.44,33.56 THER_HD.3
FDI_CSYNC: length 164.6
  TOP w0.102: PCH1.L2 51.08,107.26 51.08,110 51.49,110.41 51.49,111.95 53.77,114.23 65.8,114.23 70.77,109.25 70.77,102.01 v2(70.26,101.51) ; v2(109.07,131.48) 109.07,148.57 117.79,157.28 127.72,157.28 131.55,153.45 v2(131.55,152.97) ; CPU1.D16 v4(153.85,142.12)
  BOTTOM w0.102: v2(70.26,101.51) 70.44,101.51 76.73,107.79 84.08,107.79 88.39,112.09 91.26,112.09 99.37,120.2 99.37,123.1 100.74,124.47 100.74,127.03 105.8,132.09 v1(106.99,132.09) 107.6,131.48 v2(109.07,131.48) ; v2(131.55,152.97) 132.95,151.57 147,151.57 152.05,146.52 152.05,145.7 153.57,144.18 153.57,143.54 153.37,143.34 153.37,142.78 153.85,142.3 v4(153.85,142.12)
FDI_INT: length 168.1
  TOP w0.102: v2(71.1,101.48) 71.1,109.25 65.89,114.46 53.67,114.46 51.29,112.07 51.29,110.49 50.88,110.08 50.88,107.03 51.22,106.69 PCH1.L3 ; v4(153.77,147.77) 153.77,148.1 148.02,153.84 134.31,153.84 128.95,159.2 116.8,159.2 106.08,148.48 v2(106.08,131.2) ; v4(155.68,143.03) CPU1.D18
  BOTTOM w0.102: v2(71.1,101.48) 71.1,101.84 76.83,107.56 84.18,107.56 88.48,111.86 91.42,111.86 99.6,120.05 99.6,123 101,124.4 101,126.04 v1(103.51,128.56) 103.51,129.39 105.32,131.2 v2(106.08,131.2) ; v4(155.68,143.03) 155.77,143.12 155.77,145.13 154.85,146.05 154.85,146.7 v4(153.77,147.77)
FDI_TX_N0: length 168.3
  TOP w0.102: v2(106.1,129.42) 106.38,129.7 106.38,130.24 106.81,130.67 106.81,148.53 117,158.72 128.63,158.72 133.99,153.36 147.82,153.36 152.89,148.29 152.89,145.91 153.05,145.75 153.05,144.85 152.81,144.61 152.68,144.61 CPU1.B14 ; v2(72.32,101) 72.22,100.9 71.97,100.9 71.84,101.02 71.84,102.2 72.4,102.76 72.4,108.64 66.09,114.94 53.47,114.94 50.9,112.37 50.9,110.61 50.5,110.2 50.5,107.65 PCH1.N1
  BOTTOM w0.102: v2(72.32,101) 72.4,101 72.83,101.43 72.83,102.41 77.29,106.88 84.56,106.88 88.86,111.18 91.75,111.18 100.29,119.72 100.29,122.64 104.05,126.4 v1(104.55,126.4) 104.55,126.91 104.88,127.24 104.88,129.77 105.29,130.18 106.48,130.18 106.61,130.05 106.61,129.6 106.43,129.42 v2(106.1,129.42)
FDI_TX_N1: length 170.1
  TOP w0.102: v2(108.34,129.8) 108.54,130 108.54,130.4 108.13,130.81 108.13,148.62 117.54,158.02 128.28,158.02 133.62,152.67 147.43,152.67 152.37,147.73 152.37,145.83 152.12,145.57 152.12,143.94 151.9,143.72 151.68,143.72 151.57,143.61 CPU1.C13 ; v2(73.64,100.97) 73.31,100.97 73.16,101.12 73.16,102.23 73.65,102.72 73.65,108.35 66.37,115.63 53.19,115.63 50.32,112.76 50.32,110.99 49.87,110.54 49.87,108.53 49.99,108.41 49.99,107.89 49.75,107.65 49.75,107.2 PCH1.P2
  BOTTOM w0.102: v2(108.34,129.8) 108.77,129.8 108.9,129.93 108.9,130.36 108.68,130.58 108.02,130.58 107.58,130.13 107.58,127.39 106,125.81 105.49,125.81 103.22,123.54 v1(103.22,123.03) 102.71,123.03 100.97,121.29 100.97,119.39 92.06,110.47 89.22,110.47 84.94,106.19 77.6,106.19 74.07,102.67 74.07,101.4 v2(73.64,100.97)
FDI_TX_P0: length 168.3
  TOP w0.102: v2(72.32,102.04) 72.6,102.32 72.6,108.72 66.17,115.15 53.39,115.15 50.7,112.46 50.7,110.69 50.29,110.28 50.29,107.85 50.23,107.79 50.23,106.96 PCH1.N2 ; CPU1.A14 152.48,144.92 152.58,144.81 152.73,144.81 152.85,144.93 152.85,145.67 152.69,145.83 152.69,148.21 147.74,153.16 133.91,153.16 128.55,158.52 117.08,158.52 107.02,148.45 107.02,130.59 106.59,130.16 106.59,128.81 v2(106.71,128.68)
  BOTTOM w0.102: v2(106.71,128.68) 106.61,128.79 106.61,129.31 106.81,129.51 106.81,130.13 106.56,130.39 105.21,130.39 104.68,129.86 104.68,127.32 103.38,126.02 v1(102.84,126.02) 102.84,125.48 100.08,122.72 100.08,119.8 91.66,111.38 88.78,111.38 84.47,107.08 77.21,107.08 72.32,102.19 v2(72.32,102.04)
FDI_TX_P1: length 170.1
  TOP w0.102: v2(73.62,102.04) 73.86,102.28 73.86,108.43 66.46,115.83 53.11,115.83 50.12,112.84 50.12,111.08 49.66,110.62 49.66,108.45 49.78,108.33 49.78,107.97 49.54,107.73 49.54,106.59 PCH1.P3 ; CPU1.B13 151.57,144.03 151.67,143.92 151.81,143.92 151.91,144.02 151.91,145.66 152.17,145.91 152.17,147.65 147.34,152.47 133.54,152.47 128.19,157.82 117.62,157.82 108.34,148.53 108.34,130.89 108.74,130.49 108.74,130.08 108.85,129.98 108.85,129.22 v2(108.97,129.09)
  BOTTOM w0.102: v2(108.97,129.09) 108.8,129.27 108.8,129.54 109.1,129.84 109.1,130.44 108.77,130.78 107.94,130.78 107.37,130.22 107.37,127.47 105.92,126.02 105.41,126.02 102.04,122.65 v1(101.51,122.65) 101.51,122.11 100.77,121.38 100.77,119.47 91.97,110.67 89.14,110.67 84.86,106.4 77.52,106.4 73.62,102.5 v2(73.62,102.04)
FP_PWRBTN_L: length 280.6
  TOP w0.102: U21.75 208.98,14.93 208.52,14.46 v1(208.39,14.46) 208.07,14.46 207.39,13.77 207.39,12.31 207.13,12.05 207.13,11.02 R342.1 206.76,10.19 201.21,10.19 200.72,9.71 197.75,9.71 197.01,10.45 v2(197.01,10.57) ; R360.1 194.56,19.62 192.82,17.88 192.82,13.55 192.13,12.86 191.07,12.86 190,11.79 v2(190,10.83) ; C855.1 9.91,45.53 R1000.2 v2(9.91,47.15) ; v2(7.65,35.59) D40.3
  BOTTOM w0.102: v2(9.91,47.15) 9.51,46.75 9.51,37.68 7.65,35.82 v2(7.65,35.59) 7.65,35.48 7.96,35.18 7.96,35.14 8.26,34.83 8.26,29.29 8.47,29.09 8.47,17.61 6.38,15.53 6.38,9.42 11.28,4.52 51.14,4.52 53.92,7.3 59.73,7.3 63.6,3.43 71.71,3.43 72.65,4.37 72.65,9.46 72.74,9.55 72.74,9.59 77.26,14.1 84.5,14.1 85.28,14.88 90.34,14.88 92.72,12.5 101.91,12.5 102.39,12.99 110.4,12.99 111.93,14.51 140.81,14.51 144.57,10.75 161.17,10.75 161.47,10.45 187.23,10.45 187.9,11.12 189.7,11.12 v2(190,10.83) 190.38,10.45 196.88,10.45 v2(197.01,10.57)
FP_RST_L: length 517.1
  TOP w0.102: v3(50.01,82.96) 50.3,82.96 51.57,81.69 51.8,81.69 52.41,81.08 52.41,79.04 53.54,77.91 53.54,69.29 52.13,67.88 52.13,64.65 53.5,63.28 58.07,63.28 C821.1 58.89,64.1 59.79,64.1 60.48,64.8 68.97,64.8 v2(70.9,62.87) 71.25,62.52 75.11,62.52 v2(76.33,61.3) ; v2(234.16,30.2) 234.45,29.9 237.78,29.9 v2(237.8,29.88) ; v2(240.12,66.2) v2(240.12,68.69) ; v2(223.68,131.6) 223.43,131.86 C1.1 221.49,131.35 220.12,131.35 218.35,133.13 214.84,133.13 209,138.97 207.3,138.97 207.04,139.22 207.04,140.49 206.36,141.18 204.07,141.18 203.87,141.38 201.68,141.38 R58.1 ; F_PANEL.7 4.43,45.98 7.45,42.96 7.83,42.96 8.47,42.32 9.62,42.32 C417.1 12.05,44.75 D9.3 12.05,45.09 ; v2(68.99,58.25) 68.23,57.49 64.68,57.49 64.05,58.12 53.3,58.12 50.29,55.11 42.47,55.11 42.01,54.64 42.01,54.39 41.5,53.88 40.88,53.88 34.14,47.15 27.72,47.15 22.26,41.69 22.26,34.17 22.89,33.54 v2(22.89,32.16) ; R390.1 12.05,46.14 12.05,45.09 ; v2(17.18,39.02) 16.67,39.02 15.22,40.47 15.22,44.79 14.92,45.09 12.05,45.09 ; v3(49.88,88.51) 50.04,88.67 PCH1.N36 ; v2(226.22,86.34) 226.22,87.18 v2(227.54,88.5)
  BOTTOM w0.102: v3(50.01,82.96) 49.82,83.16 49.82,84.11 49.64,84.28 49.64,88.27 v3(49.88,88.51) ; v2(226.22,86.34) 224.06,88.5 224.06,99.73 222.79,101 222.79,106.97 231.68,115.86 231.68,118.68 232.14,119.13 232.14,121.72 231.68,122.18 231.68,125 232.44,125.76 232.44,127.67 228.7,131.41 SJ1.48 225.71,131.41 225.39,131.73 223.81,131.73 v2(223.68,131.6) ; v2(22.89,32.16) 22.89,32.75 19.21,36.43 19.21,36.99 v2(17.18,39.02) ; v2(227.54,88.5) 227.67,88.5 230.66,85.5 230.66,76.02 235.74,70.95 237.86,70.95 v2(240.12,68.69) ; v2(237.8,29.88) 238.54,30.61 238.54,33.18 238.28,33.43 236.63,33.43 236.1,33.97 236.1,36.58 237.95,38.44 237.95,43.15 237.55,43.56 237.55,49.59 240.95,52.99 240.95,65.37 v2(240.12,66.2) ; v2(68.99,58.25) 70.9,60.15 v2(70.9,62.87) ; v2(234.16,30.2) 233.84,30.2 233.13,29.48 233.13,25.23 232.19,24.29 229.67,24.29 228.95,23.57 219.59,23.57 218.73,24.42 217.34,25.81 212,25.81 209.71,23.53 v1(209.71,23.15) 209.33,23.15 206.51,20.33 202.46,20.33 200.75,18.63 198.93,18.63 197.75,17.44 192.45,17.44 190.1,19.79 180.14,19.79 178.74,18.4 167.85,18.4 167.09,17.63 156.25,17.63 155.1,18.78 145.17,18.78 141.96,21.98 122.99,21.98 120.68,24.29 113.68,24.29 110.76,27.21 93.1,27.21 88.88,31.42 88.88,32.84 82.52,39.2 81.02,39.2 79.71,40.51 79.71,44.1 78.21,45.6 78.21,59.42 v2(76.33,61.3)
