# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
LQFP48
  round 1.016 smd: (-4.254,-4.239) (4.263,4.278)
  rect 1.524x0.432 smd: 1(-4.25,2.826) 12(-4.25,-2.826) 25(4.25,-2.826) 36(4.25,2.826)
  rect 1.524x0.279 smd: 2(-4.25,2.25) 3(-4.25,1.75) 4(-4.25,1.25) 5(-4.25,0.75) 6(-4.25,0.25) 7(-4.25,-0.25) 8(-4.25,-0.75) 9(-4.25,-1.25) 10(-4.25,-1.75) 11(-4.25,-2.25) 26(4.25,-2.25) 27(4.25,-1.75) 28(4.25,-1.25) 29(4.25,-0.75) 30(4.25,-0.25) 31(4.25,0.25) 32(4.25,0.75) 33(4.25,1.25) 34(4.25,1.75) 35(4.25,2.25)
  rect 0.432x1.524 smd: 13(-2.826,-4.25) 24(2.826,-4.25) 37(2.826,4.25) 48(-2.826,4.25)
  rect 0.279x1.524 smd: 14(-2.25,-4.25) 15(-1.75,-4.25) 16(-1.25,-4.25) 17(-0.75,-4.25) 18(-0.25,-4.25) 19(0.25,-4.25) 20(0.75,-4.25) 21(1.25,-4.25) 22(1.75,-4.25) 23(2.25,-4.25) 38(2.25,4.25) 39(1.75,4.25) 40(1.25,4.25) 41(0.75,4.25) 42(0.25,4.25) 43(-0.25,4.25) 44(-0.75,4.25) 45(-1.25,4.25) 46(-1.75,4.25) 47(-2.25,4.25)
LQFP128_PT04
  round 1.016 smd: (-7.62,-7.62) (7.62,7.62)
  rect 1.626x0.305 smd: 1(-7.7,6.251) 32(-7.7,-6.251) 65(7.7,-6.251) 96(7.7,6.251)
  rect 1.626x0.203 smd: 2(-7.7,5.8) 3(-7.7,5.4) 4(-7.7,5) 5(-7.7,4.6) 6(-7.7,4.2) 7(-7.7,3.8) 8(-7.7,3.4) 9(-7.7,3) 10(-7.7,2.6) 11(-7.7,2.2) 12(-7.7,1.8) 13(-7.7,1.4) 14(-7.7,1) 15(-7.7,0.6) 16(-7.7,0.2) 17(-7.7,-0.2) 18(-7.7,-0.6) 19(-7.7,-1) 20(-7.7,-1.4) 21(-7.7,-1.8) 22(-7.7,-2.2) 23(-7.7,-2.6) 24(-7.7,-3) 25(-7.7,-3.4) 26(-7.7,-3.8) 27(-7.7,-4.2) 28(-7.7,-4.6) 29(-7.7,-5) 30(-7.7,-5.4) 31(-7.7,-5.8) 66(7.7,-5.8) 67(7.7,-5.4) 68(7.7,-5) 69(7.7,-4.6) 70(7.7,-4.2) 71(7.7,-3.8) 72(7.7,-3.4) 73(7.7,-3) 74(7.7,-2.6) 75(7.7,-2.2) 76(7.7,-1.8) 77(7.7,-1.4) 78(7.7,-1) 79(7.7,-0.6) 80(7.7,-0.2) 81(7.7,0.2) 82(7.7,0.6) 83(7.7,1) 84(7.7,1.4) 85(7.7,1.8) 86(7.7,2.2) 87(7.7,2.6) 88(7.7,3) 89(7.7,3.4) 90(7.7,3.8) 91(7.7,4.2) 92(7.7,4.6) 93(7.7,5) 94(7.7,5.4) 95(7.7,5.8)
  rect 0.305x1.626 smd: 33(-6.251,-7.7) 64(6.251,-7.7) 97(6.251,7.7) 128(-6.251,7.7)
  rect 0.203x1.626 smd: 34(-5.8,-7.7) 35(-5.4,-7.7) 36(-5,-7.7) 37(-4.6,-7.7) 38(-4.2,-7.7) 39(-3.8,-7.7) 40(-3.4,-7.7) 41(-3,-7.7) 42(-2.6,-7.7) 43(-2.2,-7.7) 44(-1.8,-7.7) 45(-1.4,-7.7) 46(-1,-7.7) 47(-0.6,-7.7) 48(-0.2,-7.7) 49(0.2,-7.7) 50(0.6,-7.7) 51(1,-7.7) 52(1.4,-7.7) 53(1.8,-7.7) 54(2.2,-7.7) 55(2.6,-7.7) 56(3,-7.7) 57(3.4,-7.7) 58(3.8,-7.7) 59(4.2,-7.7) 60(4.6,-7.7) 61(5,-7.7) 62(5.4,-7.7) 63(5.8,-7.7) 98(5.8,7.7) 99(5.4,7.7) 100(5,7.7) 101(4.6,7.7) 102(4.2,7.7) 103(3.8,7.7) 104(3.4,7.7) 105(3,7.7) 106(2.6,7.7) 107(2.2,7.7) 108(1.8,7.7) 109(1.4,7.7) 110(1,7.7) 111(0.6,7.7) 112(0.2,7.7) 113(-0.2,7.7) 114(-0.6,7.7) 115(-1,7.7) 116(-1.4,7.7) 117(-1.8,7.7) 118(-2.2,7.7) 119(-2.6,7.7) 120(-3,7.7) 121(-3.4,7.7) 122(-3.8,7.7) 123(-4.2,7.7) 124(-4.6,7.7) 125(-5,7.7) 126(-5.4,7.7) 127(-5.8,7.7)
PCI_120P-AB
  round 2.642 hole 2.642 unplated: (-40.64,0) (24.13,0)
  rect 1.372x1.372 hole 1.016: A1(-38.735,3.81)
  round 1.372 hole 1.016: A2(-37.465,1.27) A3(-36.195,3.81) A4(-34.925,1.27) A5(-33.655,3.81) A6(-32.385,1.27) A7(-31.115,3.81) A8(-29.845,1.27) A9(-28.575,3.81) A10(-27.305,1.27) A11(-26.035,3.81) A12(-24.765,1.27) A13(-23.495,3.81) A14(-22.225,1.27) A15(-20.955,3.81) A16(-19.685,1.27) A17(-18.415,3.81) A18(-17.145,1.27) A19(-15.875,3.81) A20(-14.605,1.27) A21(-13.335,3.81) A22(-12.065,1.27) A23(-10.795,3.81) A24(-9.525,1.27) A25(-8.255,3.81) A26(-6.985,1.27) A27(-5.715,3.81) A28(-4.445,1.27) A29(-3.175,3.81) A30(-1.905,1.27) A31(-0.635,3.81) A32(0.635,1.27) A33(1.905,3.81) A34(3.175,1.27) A35(4.445,3.81) A36(5.715,1.27) A37(6.985,3.81) A38(8.255,1.27) A39(9.525,3.81) A40(10.795,1.27) A41(12.065,3.81) A42(13.335,1.27) A43(14.605,3.81) A44(15.875,1.27) A45(17.145,3.81) A46(18.415,1.27) A47(19.685,3.81) A48(20.955,1.27) A49(22.225,3.81) A52(26.035,1.27) A53(27.305,3.81) A54(28.575,1.27) A55(29.845,3.81) A56(31.115,1.27) A57(32.385,3.81) A58(33.655,1.27) A59(34.925,3.81) A60(36.195,1.27) A61(37.465,3.81) A62(38.735,1.27) B1(-38.735,-1.27) B2(-37.465,-3.81) B3(-36.195,-1.27) B4(-34.925,-3.81) B5(-33.655,-1.27) B6(-32.385,-3.81) B7(-31.115,-1.27) B8(-29.845,-3.81) B9(-28.575,-1.27) B10(-27.305,-3.81) B11(-26.035,-1.27) B12(-24.765,-3.81) B13(-23.495,-1.27) B14(-22.225,-3.81) B15(-20.955,-1.27) B16(-19.685,-3.81) B17(-18.415,-1.27) B18(-17.145,-3.81) B19(-15.875,-1.27) B20(-14.605,-3.81) B21(-13.335,-1.27) B22(-12.065,-3.81) B23(-10.795,-1.27) B24(-9.525,-3.81) B25(-8.255,-1.27) B26(-6.985,-3.81) B27(-5.715,-1.27) B28(-4.445,-3.81) B29(-3.175,-1.27) B30(-1.905,-3.81) B31(-0.635,-1.27) B32(0.635,-3.81) B33(1.905,-1.27) B34(3.175,-3.81) B35(4.445,-1.27) B36(5.715,-3.81) B37(6.985,-1.27) B38(8.255,-3.81) B39(9.525,-1.27) B40(10.795,-3.81) B41(12.065,-1.27) B42(13.335,-3.81) B43(14.605,-1.27) B44(15.875,-3.81) B45(17.145,-1.27) B46(18.415,-3.81) B47(19.685,-1.27) B48(20.955,-3.81) B49(22.225,-1.27) B52(26.035,-3.81) B53(27.305,-1.27) B54(28.575,-3.81) B55(29.845,-1.27) B56(31.115,-3.81) B57(32.385,-1.27) B58(33.655,-3.81) B59(34.925,-1.27) B60(36.195,-3.81) B61(37.465,-1.27) B62(38.735,-3.81)
PCIE_X1_36P_2
  round 2.362 hole 2.362 unplated: (0,0) (0,-9.144)
  rect 1.067x1.067 hole 0.711: A1(1.245,11.654)
  round 1.067 hole 0.711: A2(3.251,10.653) A3(1.245,9.652) A4(3.251,8.651) A5(1.245,7.653) A6(3.251,6.652) A7(1.245,5.652) A8(3.251,4.653) A9(1.245,3.653) A10(3.251,2.652) A11(1.245,1.654) A12(3.251,-1.349) A13(1.245,-2.347) A14(3.251,-3.348) A15(1.245,-4.348) A16(3.251,-5.347) A17(1.245,-6.347) A18(3.251,-7.346) B1(-1.245,11.654) B2(-3.251,10.653) B3(-1.245,9.652) B4(-3.251,8.651) B5(-1.245,7.653) B6(-3.251,6.652) B7(-1.245,5.652) B8(-3.251,4.653) B9(-1.245,3.653) B10(-3.251,2.652) B11(-1.245,1.654) B12(-3.251,-1.349) B13(-1.245,-2.347) B14(-3.251,-3.348) B15(-1.245,-4.348) B16(-3.251,-5.347) B17(-1.245,-6.347) B18(-3.251,-7.346)
PCIE_X16_164P_4
  round 2.362 hole 2.362 unplated: (0,0) (0,-73.15)
  rect 1.067x1.067 hole 0.711: A1(1.25,11.65)
  round 1.067 hole 0.711: A2(3.25,10.65) A3(1.25,9.65) A4(3.25,8.65) A5(1.25,7.65) A6(3.25,6.65) A7(1.25,5.65) A8(3.25,4.65) A9(1.25,3.65) A10(3.25,2.65) A11(1.25,1.65) A12(3.25,-1.35) A13(1.25,-2.35) A14(3.25,-3.35) A15(1.25,-4.35) A16(3.25,-5.35) A17(1.25,-6.35) A18(3.25,-7.35) A19(1.25,-8.35) A20(3.25,-9.35) A21(1.25,-10.35) A22(3.25,-11.35) A23(1.25,-12.35) A24(3.25,-13.35) A25(1.25,-14.35) A26(3.25,-15.35) A27(1.25,-16.35) A28(3.25,-17.35) A29(1.25,-18.35) A30(3.25,-19.35) A31(1.25,-20.35) A32(3.25,-21.35) A33(1.25,-22.35) A34(3.25,-23.35) A35(1.25,-24.35) A36(3.25,-25.35) A37(1.25,-26.35) A38(3.25,-27.35) A39(1.25,-28.35) A40(3.25,-29.35) A41(1.25,-30.35) A42(3.25,-31.35) A43(1.25,-32.35) A44(3.25,-33.35) A45(1.25,-34.35) A46(3.25,-35.35) A47(1.25,-36.35) A48(3.25,-37.35) A49(1.25,-38.35) A50(3.25,-39.35) A51(1.25,-40.35) A52(3.25,-41.35) A53(1.25,-42.35) A54(3.25,-43.35) A55(1.25,-44.35) A56(3.25,-45.35) A57(1.25,-46.35) A58(3.25,-47.35) A59(1.25,-48.35) A60(3.25,-49.35) A61(1.25,-50.35) A62(3.25,-51.35) A63(1.25,-52.35) A64(3.25,-53.35) A65(1.25,-54.35) A66(3.25,-55.35) A67(1.25,-56.35) A68(3.25,-57.35) A69(1.25,-58.35) A70(3.25,-59.35) A71(1.25,-60.35) A72(3.25,-61.35) A73(1.25,-62.35) A74(3.25,-63.35) A75(1.25,-64.35) A76(3.25,-65.35) A77(1.25,-66.35) A78(3.25,-67.35) A79(1.25,-68.35) A80(3.25,-69.35) A81(1.25,-70.35) A82(3.25,-71.35) B1(-1.25,11.65) B2(-3.25,10.65) B3(-1.25,9.65) B4(-3.25,8.65) B5(-1.25,7.65) B6(-3.25,6.65) B7(-1.25,5.65) B8(-3.25,4.65) B9(-1.25,3.65) B10(-3.25,2.65) B11(-1.25,1.65) B12(-3.25,-1.35) B13(-1.25,-2.35) B14(-3.25,-3.35) B15(-1.25,-4.35) B16(-3.25,-5.35) B17(-1.25,-6.35) B18(-3.25,-7.35) B19(-1.25,-8.35) B20(-3.25,-9.35) B21(-1.25,-10.35) B22(-3.25,-11.35) B23(-1.25,-12.35) B24(-3.25,-13.35) B25(-1.25,-14.35) B26(-3.25,-15.35) B27(-1.25,-16.35) B28(-3.25,-17.35) B29(-1.25,-18.35) B30(-3.25,-19.35) B31(-1.25,-20.35) B32(-3.25,-21.35) B33(-1.25,-22.35) B34(-3.25,-23.35) B35(-1.25,-24.35) B36(-3.25,-25.35) B37(-1.25,-26.35) B38(-3.25,-27.35) B39(-1.25,-28.35) B40(-3.25,-29.35) B41(-1.25,-30.35) B42(-3.25,-31.35) B43(-1.25,-32.35) B44(-3.25,-33.35) B45(-1.25,-34.35) B46(-3.25,-35.35) B47(-1.25,-36.35) B48(-3.25,-37.35) B49(-1.25,-38.35) B50(-3.25,-39.35) B51(-1.25,-40.35) B52(-3.25,-41.35) B53(-1.25,-42.35) B54(-3.25,-43.35) B55(-1.25,-44.35) B56(-3.25,-45.35) B57(-1.25,-46.35) B58(-3.25,-47.35) B59(-1.25,-48.35) B60(-3.25,-49.35) B61(-1.25,-50.35) B62(-3.25,-51.35) B63(-1.25,-52.35) B64(-3.25,-53.35) B65(-1.25,-54.35) B66(-3.25,-55.35) B67(-1.25,-56.35) B68(-3.25,-57.35) B69(-1.25,-58.35) B70(-3.25,-59.35) B71(-1.25,-60.35) B72(-3.25,-61.35) B73(-1.25,-62.35) B74(-3.25,-63.35) B75(-1.25,-64.35) B76(-3.25,-65.35) B77(-1.25,-66.35) B78(-3.25,-67.35) B79(-1.25,-68.35) B80(-3.25,-69.35) B81(-1.25,-70.35) B82(-3.25,-71.35)
PSOP8_W150_PT50_PAD-UP6281
  rect 0.711x1.524 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75) 8(-1.905,2.75)
  rect 3x2.2 smd: 9(0,0)
PSOP8_W150_PT50_PAD-UP7719B_1
  rect 0.711x1.524 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75) 8(-1.905,2.75)
  rect 3.2x2.3 smd: 9(0,0)
Q_TDSON8-GDS-4
  rect 0.762x1.27 smd: D1(-1.905,2.857) D2(-0.635,2.857) D3(0.635,2.857) D4(1.905,2.857) G(1.905,-2.857) S1(-1.905,-2.857) S2(-0.635,-2.857) S3(0.635,-2.857)
  custom 0.902x0.902 smd: D5(0,1.054)
QFN28_SM331L_PT04MM_1
  oval 0.66x0.178 smd: 1(-1.913,1.2) 2(-1.913,0.8) 3(-1.913,0.4) 4(-1.913,0) 5(-1.913,-0.4) 6(-1.913,-0.8) 7(-1.913,-1.2) 15(1.913,-1.2) 16(1.913,-0.8) 17(1.913,-0.4) 18(1.913,0) 19(1.913,0.4) 20(1.913,0.8) 21(1.913,1.2)
  oval 0.178x0.66 smd: 8(-1.2,-1.913) 9(-0.8,-1.913) 10(-0.4,-1.913) 11(0,-1.913) 12(0.4,-1.913) 13(0.8,-1.913) 14(1.2,-1.913) 22(1.2,1.913) 23(0.8,1.913) 24(0.4,1.913) 25(0,1.913) 26(-0.4,1.913) 27(-0.8,1.913) 28(-1.2,1.913)
  rect 2.7x2.7 smd: 29(0,0)
QFN40_PT04_E2201
  oval 0.711x0.203 smd: 1(-2.4,1.8) 2(-2.4,1.4) 3(-2.4,1) 4(-2.4,0.6) 5(-2.4,0.2) 6(-2.4,-0.2) 7(-2.4,-0.6) 8(-2.4,-1) 9(-2.4,-1.4) 10(-2.4,-1.8) 21(2.4,-1.8) 22(2.4,-1.4) 23(2.4,-1) 24(2.4,-0.6) 25(2.4,-0.2) 26(2.4,0.2) 27(2.4,0.6) 28(2.4,1) 29(2.4,1.4) 30(2.4,1.8)
  oval 0.203x0.711 smd: 11(-1.8,-2.4) 12(-1.4,-2.4) 13(-1,-2.4) 14(-0.6,-2.4) 15(-0.2,-2.4) 16(0.2,-2.4) 17(0.6,-2.4) 18(1,-2.4) 19(1.4,-2.4) 20(1.8,-2.4) 31(1.8,2.4) 32(1.4,2.4) 33(1,2.4) 34(0.6,2.4) 35(0.2,2.4) 36(-0.2,2.4) 37(-0.6,2.4) 38(-1,2.4) 39(-1.4,2.4) 40(-1.8,2.4)
  rect 3.5x3.5 smd: 41(0,0)
QFN48_PT04_3X3
  round 1.016 smd: (-4.191,-4.191) (4.191,4.191)
  oval 0.813x0.203 smd: 1(-2.9,2.2) 2(-2.9,1.8) 3(-2.9,1.4) 4(-2.9,1) 5(-2.9,0.6) 6(-2.9,0.2) 7(-2.9,-0.2) 8(-2.9,-0.6) 9(-2.9,-1) 10(-2.9,-1.4) 11(-2.9,-1.8) 12(-2.9,-2.2) 25(2.9,-2.2) 26(2.9,-1.8) 27(2.9,-1.4) 28(2.9,-1) 29(2.9,-0.6) 30(2.9,-0.2) 31(2.9,0.2) 32(2.9,0.6) 33(2.9,1) 34(2.9,1.4) 35(2.9,1.8) 36(2.9,2.2)
  oval 0.203x0.813 smd: 13(-2.2,-2.9) 14(-1.8,-2.9) 15(-1.4,-2.9) 16(-1,-2.9) 17(-0.6,-2.9) 18(-0.2,-2.9) 19(0.2,-2.9) 20(0.6,-2.9) 21(1,-2.9) 22(1.4,-2.9) 23(1.8,-2.9) 24(2.2,-2.9) 37(2.2,2.9) 38(1.8,2.9) 39(1.4,2.9) 40(1,2.9) 41(0.6,2.9) 42(0.2,2.9) 43(-0.2,2.9) 44(-0.6,2.9) 45(-1,2.9) 46(-1.4,2.9) 47(-1.8,2.9) 48(-2.2,2.9)
  rect 3x3 smd: 49(0,0)
QFN64_RTL8111DP_1
  round 1.016 smd: (-5.715,-5.715) (5.715,5.715)
  oval 0.864x0.279 smd: 1(-4.4,3.75) 2(-4.4,3.25) 3(-4.4,2.75) 4(-4.4,2.25) 5(-4.4,1.75) 6(-4.4,1.25) 7(-4.4,0.75) 8(-4.4,0.25) 9(-4.4,-0.25) 10(-4.4,-0.75) 11(-4.4,-1.25) 12(-4.4,-1.75) 13(-4.4,-2.25) 14(-4.4,-2.75) 15(-4.4,-3.25) 16(-4.4,-3.75) 33(4.4,-3.75) 34(4.4,-3.25) 35(4.4,-2.75) 36(4.4,-2.25) 37(4.4,-1.75) 38(4.4,-1.25) 39(4.4,-0.75) 40(4.4,-0.25) 41(4.4,0.25) 42(4.4,0.75) 43(4.4,1.25) 44(4.4,1.75) 45(4.4,2.25) 46(4.4,2.75) 47(4.4,3.25) 48(4.4,3.75)
  oval 0.279x0.864 smd: 17(-3.75,-4.4) 18(-3.25,-4.4) 19(-2.75,-4.4) 20(-2.25,-4.4) 21(-1.75,-4.4) 22(-1.25,-4.4) 23(-0.75,-4.4) 24(-0.25,-4.4) 25(0.25,-4.4) 26(0.75,-4.4) 27(1.25,-4.4) 28(1.75,-4.4) 29(2.25,-4.4) 30(2.75,-4.4) 31(3.25,-4.4) 32(3.75,-4.4) 49(3.75,4.4) 50(3.25,4.4) 51(2.75,4.4) 52(2.25,4.4) 53(1.75,4.4) 54(1.25,4.4) 55(0.75,4.4) 56(0.25,4.4) 57(-0.25,4.4) 58(-0.75,4.4) 59(-1.25,4.4) 60(-1.75,4.4) 61(-2.25,4.4) 62(-2.75,4.4) 63(-3.25,4.4) 64(-3.75,4.4)
  rect 7.3x7.3 smd: 65(0,0)
QFP128
  round 1.016 smd: (-8,-11) (8.127,10.619)
  rect 1.778x0.432 smd: 1(-8.25,9.326) 38(-8.25,-9.326) 65(8.25,-9.326) 102(8.25,9.326)
  rect 1.778x0.279 smd: 2(-8.25,8.75) 3(-8.25,8.25) 4(-8.25,7.75) 5(-8.25,7.25) 6(-8.25,6.75) 7(-8.25,6.25) 8(-8.25,5.75) 9(-8.25,5.25) 10(-8.25,4.75) 11(-8.25,4.25) 12(-8.25,3.75) 13(-8.25,3.25) 14(-8.25,2.75) 15(-8.25,2.25) 16(-8.25,1.75) 17(-8.25,1.25) 18(-8.25,0.75) 19(-8.25,0.25) 20(-8.25,-0.25) 21(-8.25,-0.75) 22(-8.25,-1.25) 23(-8.25,-1.75) 24(-8.25,-2.25) 25(-8.25,-2.75) 26(-8.25,-3.25) 27(-8.25,-3.75) 28(-8.25,-4.25) 29(-8.25,-4.75) 30(-8.25,-5.25) 31(-8.25,-5.75) 32(-8.25,-6.25) 33(-8.25,-6.75) 34(-8.25,-7.25) 35(-8.25,-7.75) 36(-8.25,-8.25) 37(-8.25,-8.75) 66(8.25,-8.75) 67(8.25,-8.25) 68(8.25,-7.75) 69(8.25,-7.25) 70(8.25,-6.75) 71(8.25,-6.25) 72(8.25,-5.75) 73(8.25,-5.25) 74(8.25,-4.75) 75(8.25,-4.25) 76(8.25,-3.75) 77(8.25,-3.25) 78(8.25,-2.75) 79(8.25,-2.25) 80(8.25,-1.75) 81(8.25,-1.25) 82(8.25,-0.75) 83(8.25,-0.25) 84(8.25,0.25) 85(8.25,0.75) 86(8.25,1.25) 87(8.25,1.75) 88(8.25,2.25) 89(8.25,2.75) 90(8.25,3.25) 91(8.25,3.75) 92(8.25,4.25) 93(8.25,4.75) 94(8.25,5.25) 95(8.25,5.75) 96(8.25,6.25) 97(8.25,6.75) 98(8.25,7.25) 99(8.25,7.75) 100(8.25,8.25) 101(8.25,8.75)
  rect 0.432x1.778 smd: 39(-6.326,-11.25) 64(6.326,-11.25) 103(6.326,11.25) 128(-6.326,11.25)
  rect 0.279x1.778 smd: 40(-5.75,-11.25) 41(-5.25,-11.25) 42(-4.75,-11.25) 43(-4.25,-11.25) 44(-3.75,-11.25) 45(-3.25,-11.25) 46(-2.75,-11.25) 47(-2.25,-11.25) 48(-1.75,-11.25) 49(-1.25,-11.25) 50(-0.75,-11.25) 51(-0.25,-11.25) 52(0.25,-11.25) 53(0.75,-11.25) 54(1.25,-11.25) 55(1.75,-11.25) 56(2.25,-11.25) 57(2.75,-11.25) 58(3.25,-11.25) 59(3.75,-11.25) 60(4.25,-11.25) 61(4.75,-11.25) 62(5.25,-11.25) 63(5.75,-11.25) 104(5.75,11.25) 105(5.25,11.25) 106(4.75,11.25) 107(4.25,11.25) 108(3.75,11.25) 109(3.25,11.25) 110(2.75,11.25) 111(2.25,11.25) 112(1.75,11.25) 113(1.25,11.25) 114(0.75,11.25) 115(0.25,11.25) 116(-0.25,11.25) 117(-0.75,11.25) 118(-1.25,11.25) 119(-1.75,11.25) 120(-2.25,11.25) 121(-2.75,11.25) 122(-3.25,11.25) 123(-3.75,11.25) 124(-4.25,11.25) 125(-4.75,11.25) 126(-5.25,11.25) 127(-5.75,11.25)
R0402_1
  rect 0.572x0.508 smd: 1(-0.476,0) 2(0.476,0)
R0603-SHORT_1
  custom 0.191x0.191 smd: 1(-0.762,0) 2(0.762,0)
R0603-SHORT_1-NMNP
  custom 0.191x0.191 smd: 1(-0.762,0) 2(0.762,0)
R0603_1
  rect 0.889x0.762 smd: 1(-0.699,0) 2(0.699,0)
R0805-SHORT-NMNP
  custom 0.349x0.349 smd: 1(-0.762,0) 2(0.762,0)
R0805_1
  rect 1.016x1.397 smd: 1(-0.889,0) 2(0.889,0)
R2512_1
  rect 2.032x3.302 smd: 1(-2.875,0) 2(2.875,0)
RJ3_0402
  rect 0.635x0.508 smd: 1(-1.016,0) 2(0,0) 3(1.016,0)
RJ45_USB3_32P
  round 1.27 hole 0.94: 1(-3.5,-2.2) 2(-1,-2.2) 3(1,-2.2) 4(3.5,-2.2) 5(4,-0.7) 6(2,-0.7) 7(0,-0.7) 8(-2,-0.7) 9(-4,-0.7) 10(-3.5,1) 11(-1,1) 12(1,1) 13(3.5,1) 14(4,2.5) 15(2,2.5) 16(0,2.5) 17(-2,2.5) 18(-4,2.5)
  round 1.27 hole 0.914: 19(5.715,6.6) 20(4.445,9.14) 21(3.175,6.6) 22(1.905,9.14) 23(0.635,6.6) 24(-0.635,9.14) 25(-1.905,6.6) 26(-3.175,9.14) 27(-4.445,6.6) 28(-5.715,9.14) 29(7.2,11.98) 30(4.66,11.98) 31(-4.66,11.98) 32(-7.2,11.98)
  round 2.692 hole 2.337: G1(6.57,-4.2) G2(-6.57,-4.2) G3(6.57,1.48) G4(-6.57,1.48) G5(9.35,-6.83) G6(-9.35,-6.83) G7(9.35,6.51) G8(-9.35,4.77)
SATA3_7P-HI-TOP
  round 1.372 smd: (-1.725,-0.379) (2.085,-0.379)
  round 1.118 hole 0.762: 1(3.995,0.01) 2(2.935,1.51) 3(1.235,1.51) 4(0.18,0.01) 5(-0.875,1.51) 6(-2.565,1.51) 7(-3.63,0.01)
  round 2.134 hole 1.372: 8(6.45,0.01) 9(-6.38,1.01)
SHORT2-NMNP
  custom 0.159x0.159 smd: 1(-0.318,0) 2(0.318,0)
SOD_123_2
  rect 1.194x1.219 smd: N(1.762,0) P(-1.762,0)
SOD_523
  rect 0.6x0.8 smd: N(0.75,0) P(-0.75,0)
SOP8_W150_PT50
  rect 0.66x1.778 smd: 1(-1.905,-2.667) 2(-0.635,-2.667) 3(0.635,-2.667) 4(1.905,-2.667) 5(1.905,2.667) 6(0.635,2.667) 7(-0.635,2.667) 8(-1.905,2.667)
SOP8_W150_PT50-104X120
  rect 0.66x1.778 smd: 1(-1.905,-2.667) 2(-0.635,-2.667) 3(0.635,-2.667) 4(1.905,-2.667) 5(1.905,2.667) 6(0.635,2.667) 7(-0.635,2.667) 8(-1.905,2.667)
  rect 3.048x2.642 smd: 9(0,0)
SOP8_W210_PT50
  rect 0.66x1.778 smd: 1(-1.905,-3.556) 2(-0.635,-3.556) 3(0.635,-3.556) 4(1.905,-3.556) 5(1.905,3.556) 6(0.635,3.556) 7(-0.635,3.556) 8(-1.905,3.556)
SOT23_3L
  rect 0.914x1.422 smd: 1(-0.95,-1.05) 2(0.95,-1.05) 3(0,1.05)
SOT23_5P_1
  rect 0.686x1.346 smd: 1(-0.95,-1.24) 2(0,-1.24) 3(0.95,-1.24) 4(0.95,1.24) 5(-0.95,1.24)
SOT23_6P_2
  rect 0.508x1.27 smd: 1(-0.95,-1.25) 2(0,-1.25) 3(0.95,-1.25) 4(0.95,1.25) 5(0,1.25) 6(-0.95,1.25)
SOT23_8P_1
  rect 0.457x1.219 smd: 1(-0.975,-1.31) 2(-0.325,-1.31) 3(0.325,-1.31) 4(0.975,-1.31) 5(0.975,1.31) 6(0.325,1.31) 7(-0.325,1.31) 8(-0.975,1.31)
SOT23_BCE_2
  rect 1.016x1.016 smd: B(-1.016,-1.143) C(0,1.143) E(1.016,-1.143)
SOT23_GDS_2
  rect 1.016x1.016 smd: D(0,1.143) G(-1.016,-1.143) S(1.016,-1.143)
SOT23_RAC_Z_2
  rect 1.016x1.016 smd: A(0,1.143) C(1.016,-1.143) R(-1.016,-1.143)
SOT363_6P
  rect 0.457x0.711 smd: B1(0,-1) B2(0,1) C1(-0.65,1) C2(0.65,-1) E1(-0.65,-1) E2(0.65,1)
SOT1059_10P_1
  rect 0.2x0.675 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.4x0.675 smd: 3(0,-0.437) 8(0,0.437)
TO251_BCE_PT90_1
  oval 1.575x1.194 hole 1.194x0.813: B(-2.286,0) C(0,0) E(2.286,0)
TO252_GDS
  rect 6.604x7.112 smd: D(0,1.905)
  rect 1.778x2.54 smd: G(-2.286,-4.204) S(2.286,-4.204)
TP30_SMD
  round 0.762 smd: 1(0,0)
TSSOP20_W170_PT065
  rect 0.305x1.778 smd: 1(-2.925,-2.9) 2(-2.275,-2.9) 3(-1.625,-2.9) 4(-0.975,-2.9) 5(-0.325,-2.9) 6(0.325,-2.9) 7(0.975,-2.9) 8(1.625,-2.9) 9(2.275,-2.9) 10(2.925,-2.9) 11(2.925,2.9) 12(2.275,2.9) 13(1.625,2.9) 14(0.975,2.9) 15(0.325,2.9) 16(-0.325,2.9) 17(-0.975,2.9) 18(-1.625,2.9) 19(-2.275,2.9) 20(-2.925,2.9)
TSSOP28_W170_PT065
  rect 0.406x1.778 smd: 1(-4.225,-2.9) 2(-3.575,-2.9) 3(-2.925,-2.9) 4(-2.275,-2.9) 5(-1.625,-2.9) 6(-0.975,-2.9) 7(-0.325,-2.9) 8(0.325,-2.9) 9(0.975,-2.9) 10(1.625,-2.9) 11(2.275,-2.9) 12(2.925,-2.9) 13(3.575,-2.9) 14(4.225,-2.9) 15(4.225,2.9) 16(3.575,2.9) 17(2.925,2.9) 18(2.275,2.9) 19(1.625,2.9) 20(0.975,2.9) 21(0.325,2.9) 22(-0.325,2.9) 23(-0.975,2.9) 24(-1.625,2.9) 25(-2.275,2.9) 26(-2.925,2.9) 27(-3.575,2.9) 28(-4.225,2.9)
unnamed
  round 1.016 smd: (0,0)
unnamed#3
  round 3.15 hole 3.15 unplated: (-18.1,-12) (18.1,12)
USBX4_2
  round 1.372 hole 1.016: A1(-3.5,4.89) A2(-1,4.89) A3(1,4.89) A4(3.5,4.89) B1(-3.5,2.27) B2(-1,2.27) B3(1,2.27) B4(3.5,2.27) C1(-3.5,-0.35) C2(-1,-0.35) C3(1,-0.35) C4(3.5,-0.35) D1(-3.5,-2.97) D2(-1,-2.97) D3(1,-2.97) D4(3.5,-2.97)
  round 2.692 hole 2.337: G1(-6.57,5.5) G2(6.57,5.5) G3(-6.57,0) G4(6.57,0) G5(-6.57,-5.68) G6(6.57,-5.68)
WCM2012F2S_1
  rect 0.75x0.4 smd: 1(-0.925,0.425) 2(0.925,0.425) 3(0.925,-0.425) 4(-0.925,-0.425)

## Nets
3VR_GO: C773.2 R889.1 R894.1 R896.2
3VSBSW_L: R586.2 R588.1 U21.79
5V_LDO: C781.2 R905.2 R911.2 R924.2 R934.2 U41.27
5VDLSB: C827.1 QN48.C QSW1.G R580.2
12VR_B: QN77.B R892.2
12VR_GO: C774.2 R891.1 R895.1 R897.2
12VR_GR: QN80.B R895.2
12VRC: QN80.C R887.1 R892.1
+1.8V_AUXA: C338.1 PFB4.1 U11.19
+1.8V_AUXD: C339.1 PFB5.1 U11.7
+1.8VA: C327.1 C328.1 C329.1 PFB6.1 U11.11 U11.12
+1.8VD: C340.1 C341.1 C342.1 PFB7.1 U11.23 U11.41 U11.78 U11.96 U11.112 U11.125
+3VSB: C52.1 C300.1 C305.1 C330.1 C354.1 C425.1 C426.1 C436.1 EC29.1 ME_TEST.3 PCH1.AH18 PCH1.AH20 PCH1.AH22 PCH1.AJ20 PCH1.AK20 PCH1.AM33 PCH1.AN33 PCH1.AP35 PCH1.AW26 PCH1.P20 PCI.A14 PCIE1X.B10 PCIE16X_1.B10 PCIE16X_2.B10 QP6.E QSW3.D R53.2 R59.2 R127.1 R181.2 R185.2 R191.2 R197.2 R205.2 R208.2 R211.2 R215.2 R222.1 R223.1 R224.2 R227.1 R228.1 R235.1 R239.2 R242.2 R244.2 R253.2 R258.2 R262.2 R277.2 R278.2 R301.2 R302.2 R307.2 R352.2 R353.2 R354.2 R355.2 R356.2 R403.2 R404.2 R413.2 R420.2 R423.1 R424.2 R456.1 R476.1 R551.1 R552.1 R561.1 R583.1 R586.1 R591.2 R606.2 R635.2 R637.2 R639.2 R886.2 R887.2 R942.2 R963.2 R996.2 R997.2 R998.2 RJ6.1 RN13.1(A) RN13.3(A) RN13.5(A) RN13.7(A) RN14.1(A) RN14.3(A) RN14.5(A) RN14.7(A) SC30.2 SC31.2 SC32.1 SC33.1 U11.4
+5VA: C508.1 C509.1 C510.1 C511.1 CODEC.25 CODEC.38
+5VSB: C583.1 C596.1 C835.1 L5.1 QP8.E QSW1.S QSW2.D R429.1 R580.1 R584.1 R593.2 R614.2 R615.2 R648.2 R652.2 RJ4.1 U12.2 U13.2 U16.2 U19.5 U25.2 U29.5
+12V: ATX_POWER.1 ATX_POWER.2 ATX_POWER.3 C48.1 C55.1 C303.1 C304.1 C308.1 C309.1 C353.1 C406.1 C666.2 C683.2 C685.2 C704.1 C727.1 C728.1 C776.1 C807.1 CPU_FAN.2 D5.N D6.N D29.P EC1.1 EC3.1 EC12.1 L12.1 PCI.A2 PCIE1X.A2 PCIE1X.A3 PCIE1X.B1 PCIE1X.B2 PCIE1X.B3 PCIE16X_1.A2 PCIE16X_1.A3 PCIE16X_1.B1 PCIE16X_1.B2 PCIE16X_1.B3 PCIE16X_2.A2 PCIE16X_2.A3 PCIE16X_2.B1 PCIE16X_2.B2 PCIE16X_2.B3 QP2.E R78.1 R81.1 R82.1 R261.2 R306.2 R333.1 R369.2 R371.1 R375.2 R379.1 R575.1 R589.1 R592.2 R603.2 R632.2 R789.1 R790.1 R798.2 R891.2 R908.1 SATA_PWR1.1 SATA_PWR1.2 SATA_PWR2.1 SATA_PWR2.2 U22.8 U32.8
+12V_4P: ATX_12V.3 ATX_12V.4 C729.2 C731.1 L7.1 R883.1
+12VIN: C777.1 C779.2 C780.1 C795.2 C796.1 C805.1 C806.1 C822.1 EC56.1 EC58.1 EC61.1 L12.2 QD3H1.D1 QD3H1.D2 QD3H1.D3 QD3H1.D4 QD3H1.D5 QD5H1.D1 QD5H1.D2 QD5H1.D3 QD5H1.D4 QD5H1.D5 QD5H2.D1 QD5H2.D2 QD5H2.D3 QD5H2.D4 QD5H2.D5
+A3VSB: C381.2 C382.2 PFB8.1 R956.1 U21.99
+AVDD12: C470.2 C471.2 C472.2 C473.2 C492.2 RLAN.5 RLAN.8 RLAN.11 RLAN.14 RLAN.58 SR44.2
+DVDD12: C464.2 C465.2 C466.2 C467.2 C468.2 C469.2 R455.2 RLAN.15 RLAN.21 RLAN.32 RLAN.38 RLAN.49 RLAN.52 SR1.1 SR43.1 SR44.1
+V95820: C735.1 R811.2 R828.1 R831.1 R858.2 U39.17
+VBAT_IO: C237.2 C386.1 CLR_CMOS.2 R251.2 U21.69
+VCC: BZ.P C350.1 C351.1 C433.2 C526.2 C540.1 C663.2 C684.2 C686.2 C696.2 C726.1 C782.2 C785.1 C786.1 C787.1 C808.1 C809.2 C811.1 C812.1 C813.1 C845.1 D7.N D11.P D20.2 EC5.1 EC57.1 F5.1 L13.2 P9.1 PCI.A3 PCI.A4 PCI.A5 PCI.A8 PCI.A10 PCI.A16 PCI.A59 PCI.A61 PCI.A62 PCI.B5 PCI.B6 PCI.B19 PCI.B59 PCI.B61 PCI.B62 PFB10.2 QN6.G QN22.G QN50.S QN68.G R75.2 R334.1 R385.1 R391.2 R392.2 R411.1 R516.2 R563.1 R629.2 R783.2 R808.1 R811.1 R916.2 SATA_PWR1.5 SATA_PWR1.6 SATA_PWR2.5 SATA_PWR2.6 SC16.2 U12.1 U13.1 U16.1 U19.3 U25.1 U29.3 U30.5 U30.6 U30.7 U30.8 U41.28 U42.20 U43.20
+VCC3: C53.1 C54.1 C139.1 C140.1 C261.1 C263.1 C301.1 C302.1 C306.1 C307.1 C331.1 C332.1 C333.1 C348.1 C349.1 C427.1 C428.1 C429.1 C434.2 C521.1 C522.1 C578.2 C610.2 C659.2 C660.2 C664.2 C798.1 C799.1 C846.1 C848.2 C849.2 C850.2 C851.2 CODEC.1 D9.2 D34.2 DIMM1.117 DIMM1.236 DIMM1.237 DIMM2.117 DIMM2.236 DIMM3.236 DIMM3.237 DIMM4.236 EC2.1 EC4.1 EC6.1 EC59.1 F1.1 L14.2 MN1.G MN2.G P12.1 PCH1.AF26 PCH1.AG1 PCH1.AG12 PCH1.AK11 PCH1.AM7 PCH1.AM9 PCH1.AP5 PCH1.AP7 PCH1.AR4 PCH1.AT5 PCH1.AV3 PCH1.AV4 PCH1.AW3 PCH1.AW4 PCH1.AW9 PCH1.U30 PCH1.W30 PCI.A21 PCI.A27 PCI.A33 PCI.A39 PCI.A45 PCI.A53 PCI.B25 PCI.B31 PCI.B36 PCI.B41 PCI.B43 PCI.B54 PCIE1X.A9 PCIE1X.A10 PCIE1X.B8 PCIE16X_1.A9 PCIE16X_1.A10 PCIE16X_1.B8 PCIE16X_2.A9 PCIE16X_2.A10 PCIE16X_2.B8 PFB11.1 Q7.1 QN20.G QN21.G QN23.G QN30.D QN55.D R95.2 R104.1 R106.1 R107.1 R133.2 R136.2 R156.1 R158.1 R165.2 R167.2 R168.2 R170.2 R171.2 R172.2 R173.2 R177.2 R180.2 R192.1 R193.2 R194.1 R195.2 R196.2 R202.2 R206.2 R241.2 R243.2 R260.1 R282.2 R283.2 R292.1 R293.1 R304.2 R305.2 R330.1 R340.2 R341.2 R370.1 R378.1 R389.2 R390.2 R397.2 R406.2 R407.1 R458.2 R459.2 R471.2 R517.1 R595.2 R646.1 R740.1 R741.2 R803.2 R820.1 R889.2 R927.2 R978.2 RJ1.1 RJ2.1 RJ5.1 RJ6.3 RJ7.1 RJ8.1 RJ9.1 RJ10.1 RJ17.1 RN11.2(B) RN11.4(B) RN11.6(B) RN11.8(B) RN12.2(B) RN12.4(B) RN12.6(B) RN12.8(B) RN15.2(B) RN15.4(B) RN15.6(B) RN45.2(B) RN45.4(B) RN45.6(B) RN45.8(B) RN46.2(B) RN46.4(B) RN46.6(B) RN46.8(B) SC15.2 SC24.1 SC25.1 SC26.1 SC27.2 SC29.2 SC35.2 SC36.2 SC41.2 SC52.2 SR36.1 SR57.2 SR58.2 TPM.9 U11.35 U11.47 U11.57 U11.72 U11.84 U11.94 U11.110 U11.123 U23.24
+VCC3_CSN1: C803.1 P12.2 R930.2 U41.15
+VCC3_CSP1: P11.2 R931.1
+VCC3_FB1: R927.1 R928.2 R932.2
+VCC3_HG1: QD3H1.G R922.1 R923.1
+VCC_CSN2: C790.1 P9.2 R914.2 U41.7
+VCC_CSP2: P10.2 R915.1
+VCC_FB2: R916.1 R917.2 R919.2
+VCC_GH2: QD5H1.G QD5H2.G SR53.1 SR54.1
+VCC_LG2: QD5L1.G QD5L2.G R910.1
+VCC_VGA_S: F5.2 QN76.S R128.1
+VCCIO_OUT: R5.2 R6.2 R11.2 R35.2 R72.1 R73.1 R814.1 R816.1 R818.1 R819.1 R980.1 R981.1 SJ1.43 SJ1.44
+VCCIO_PCH: C284.1 C285.1 C286.1 PCH1.C39 R71.1 SR24.2
+VCCST: CPU1.K9 SC12.2 SC14.1 SR17.2 SR24.1
+VDD33: C451.2 C452.2 C453.2 C455.2 C456.2 C457.2 C458.2 C459.2 C460.2 C478.1 C857.1 QP9.D R449.1 R450.1 R453.2 R454.1 R694.1 R762.2 R763.2 R949.2 RLAN.2 RLAN.16 RLAN.37 RLAN.46 RLAN.53 RLAN.59 RLAN.63 ROM2.3 ROM2.7 ROM2.8 SC46.2
+VIN: C730.1 C732.1 C733.1 C734.1 C743.1 C744.1 C758.1 C759.1 C769.1 C770.1 EC46.1 EC47.1 EC48.1 L7.2 QCH1.D1 QCH1.D2 QCH1.D3 QCH1.D4 QCH1.D5 QCH2.D1 QCH2.D2 QCH2.D3 QCH2.D4 QCH2.D5 QCH3.D1 QCH3.D2 QCH3.D3 QCH3.D4 QCH3.D5 QCH4.D1 QCH4.D2 QCH4.D3 QCH4.D4 QCH4.D5 R810.1 R812.1 R817.1
-12V: ATX_POWER.4 C352.1 C624.1 C625.1 C810.1 D30.N PCI.B1
DGND: R467.1 USB3_LAN.28
GND: A1.2 A2.2 ATX_12V.1 ATX_12V.2 ATX_POWER.5 ATX_POWER.6 ATX_POWER.11 ATX_POWER.12 BAT1.N BIOS_WP.3 C1.2 C2.2 C3.2 C6.1 C9.1 C10.1 C11.1 C12.1 C15.1 C16.1 C17.1 C18.1 C19.1 C20.1 C21.1 C22.1 C23.1 C24.1 C25.1 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C48.2 C50.2 C52.2 C53.2 C54.2 C55.2 C95.1 C107.2 C116.1 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.1 C199.1 C208.2 C210.2 C224.2 C225.2 C226.2 C227.2 C228.1 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.1 C238.1 C239.2 C240.1 C241.2 C242.2 C243.2 C244.2 C245.2 C246.2 C247.2 C248.2 C249.2 C250.1 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C268.2 C269.2 C270.2 C271.2 C273.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C299.2 C300.2 C301.2 C302.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C310.2 C324.2 C325.2 C326.2 C330.2 C331.2 C332.2 C333.2 C334.1 C335.2 C336.2 C337.2 C339.2 C340.2 C341.2 C342.2 C345.2 C346.1 C347.1 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C358.2 C359.2 C360.2 C361.2 C362.2 C368.1 C369.2 C370.2 C371.2 C372.2 C373.2 C381.1 C382.1 C384.2 C386.2 C387.2 C388.2 C389.2 C390.2 C391.2 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.1 C402.1 C403.1 C404.1 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C412.1 C413.1 C414.1 C415.1 C417.2 C418.2 C419.1 C420.2 C422.2 C423.2 C425.2 C426.2 C427.2 C428.2 C429.2 C431.1 C432.1 C433.1 C434.1 C435.2 C436.2 C437.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.2 C449.2 C450.1 C451.1 C452.1 C453.1 C455.1 C456.1 C457.1 C458.1 C459.1 C460.1 C461.1 C462.1 C463.1 C464.1 C465.1 C466.1 C467.1 C468.1 C469.1 C470.1 C471.1 C472.1 C473.1 C474.1 C475.1 C476.1 C477.1 C478.2 C483.1 C484.2 C486.1 C487.1 C488.1 C489.1 C490.1 C492.1 C497.1 C498.1 C499.2 C502.1 C505.2 C520.2 C521.2 C522.2 C523.2 C524.2 C525.2 C526.1 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C563.2 C564.1 C571.1 C572.2 C573.1 C575.2 C576.2 C577.2 C578.1 C579.1 C581.2 C582.2 C584.2 C585.2 C586.2 C587.2 C588.2 C589.2 C590.1 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 C597.2 C598.1 C599.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.1 C607.2 C608.2 C609.2 C610.1 C611.2 C612.2 C613.2 C624.2 C625.2 C654.1 C659.1 C660.1 C663.1 C664.1 C666.1 C668.2 C669.1 C670.2 C671.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.1 C678.2 C679.2 C680.2 C681.2 C682.2 C683.1 C684.1 C685.1 C686.1 C689.2 C690.1 C691.2 C696.1 C697.2 C698.2 C699.1 C700.2 C703.1 C704.2 C705.1 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.1 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.2 C740.2 C743.2 C744.2 C745.1 C746.1 C747.1 C753.2 C756.2 C757.2 C758.2 C759.2 C760.2 C765.2 C766.1 C769.2 C770.2 C771.2 C772.2 C773.1 C774.1 C776.2 C777.2 C778.1 C779.1 C780.2 C781.1 C782.1 C783.1 C785.2 C786.2 C787.2 C788.1 C789.2 C795.1 C796.2 C797.2 C798.2 C799.2 C800.1 C805.2 C806.2 C807.2 C808.2 C809.1 C810.2 C811.2 C812.2 C813.2 C814.2 C817.2 C820.2 C821.2 C822.2 C823.1 C824.1 C825.2 C826.2 C827.2 C828.2 C835.2 C836.1 C838.1 C844.2 C845.2 C846.2 C848.1 C849.1 C850.1 C851.1 C854.2 C855.2 C858.2 C_INTRUSION.1 CN1.1(A) CN1.3(A) CN1.5(A) CN1.7(A) CN2.1(A) CN2.3(A) CN2.5(A) CN2.7(A) CN3.1(A) CN3.3(A) CN3.5(A) CN3.7(A) CN4.1(A) CN4.3(A) CN4.5(A) CN4.7(A) CN5.1(A) CN5.3(A) CN5.5(A) CN5.7(A) CN6.1(A) CN6.3(A) CN6.5(A) CN6.7(A) CN7.2(B) CN7.4(B) CN7.6(B) CN7.8(B) CN8.2(B) CN8.4(B) CN8.6(B) CN8.8(B) CODEC.7 COM1.5 COM1.11 COM1.12 COM2.5 CPU1.A5 CPU1.A7 CPU1.A11 CPU1.A13 CPU1.A15 CPU1.A17 CPU1.A23 CPU1.AA3 CPU1.AA6 CPU1.AA7 CPU1.AA8 CPU1.AA33 CPU1.AA35 CPU1.AA38 CPU1.AB5 CPU1.AB6 CPU1.AB7 CPU1.AB34 CPU1.AB37 CPU1.AC3 CPU1.AC6 CPU1.AC7 CPU1.AC33 CPU1.AC34 CPU1.AC35 CPU1.AC36 CPU1.AC37 CPU1.AC38 CPU1.AC39 CPU1.AC40 CPU1.AD1 CPU1.AD2 CPU1.AD3 CPU1.AD4 CPU1.AD5 CPU1.AD6 CPU1.AD7 CPU1.AD8 CPU1.AD33 CPU1.AD36 CPU1.AE5 CPU1.AE8 CPU1.AE33 CPU1.AE36 CPU1.AE37 CPU1.AE40 CPU1.AF1 CPU1.AF4 CPU1.AF5 CPU1.AF8 CPU1.AF33 CPU1.AF36 CPU1.AG5 CPU1.AG8 CPU1.AG33 CPU1.AG36 CPU1.AG37 CPU1.AG38 CPU1.AG39 CPU1.AG40 CPU1.AH1 CPU1.AH2 CPU1.AH3 CPU1.AH4 CPU1.AH5 CPU1.AH8 CPU1.AH33 CPU1.AH36 CPU1.AJ5 CPU1.AJ8 CPU1.AJ11 CPU1.AJ14 CPU1.AJ16 CPU1.AJ18 CPU1.AJ19 CPU1.AJ22 CPU1.AJ23 CPU1.AJ26 CPU1.AJ27 CPU1.AJ30 CPU1.AJ31 CPU1.AJ32 CPU1.AJ33 CPU1.AJ34 CPU1.AJ35 CPU1.AJ36 CPU1.AJ37 CPU1.AJ40 CPU1.AK1 CPU1.AK4 CPU1.AK5 CPU1.AK6 CPU1.AK7 CPU1.AK8 CPU1.AK9 CPU1.AK10 CPU1.AK11 CPU1.AK12 CPU1.AK13 CPU1.AK14 CPU1.AK18 CPU1.AK19 CPU1.AK24 CPU1.AK25 CPU1.AK26 CPU1.AK27 CPU1.AK28 CPU1.AK29 CPU1.AK30 CPU1.AK36 CPU1.AL5 CPU1.AL11 CPU1.AL14 CPU1.AL17 CPU1.AL21 CPU1.AL22 CPU1.AL24 CPU1.AL27 CPU1.AL30 CPU1.AL36 CPU1.AL37 CPU1.AL38 CPU1.AL39 CPU1.AL40 CPU1.AM1 CPU1.AM2 CPU1.AM3 CPU1.AM4 CPU1.AM5 CPU1.AM11 CPU1.AM14 CPU1.AM15 CPU1.AM19 CPU1.AM24 CPU1.AM27 CPU1.AM30 CPU1.AM31 CPU1.AM32 CPU1.AM33 CPU1.AM34 CPU1.AM35 CPU1.AM36 CPU1.AN5 CPU1.AN6 CPU1.AN7 CPU1.AN8 CPU1.AN9 CPU1.AN10 CPU1.AN11 CPU1.AN14 CPU1.AN16 CPU1.AN18 CPU1.AN19 CPU1.AN22 CPU1.AN23 CPU1.AN24 CPU1.AN27 CPU1.AN30 CPU1.AN36 CPU1.AN37 CPU1.AN40 CPU1.AP1 CPU1.AP4 CPU1.AP5 CPU1.AP11 CPU1.AP14 CPU1.AP15 CPU1.AP24 CPU1.AP27 CPU1.AP30 CPU1.AP36 CPU1.AR5 CPU1.AR11 CPU1.AR14 CPU1.AR16 CPU1.AR17 CPU1.AR18 CPU1.AR19 CPU1.AR20 CPU1.AR21 CPU1.AR22 CPU1.AR23 CPU1.AR24 CPU1.AR27 CPU1.AR30 CPU1.AR31 CPU1.AR32 CPU1.AR33 CPU1.AR34 CPU1.AR35 CPU1.AR36 CPU1.AR37 CPU1.AR38 CPU1.AR39 CPU1.AR40 CPU1.AT1 CPU1.AT2 CPU1.AT3 CPU1.AT4 CPU1.AT5 CPU1.AT6 CPU1.AT7 CPU1.AT8 CPU1.AT9 CPU1.AT10 CPU1.AT11 CPU1.AT12 CPU1.AT13 CPU1.AT14 CPU1.AT15 CPU1.AT16 CPU1.AT24 CPU1.AT25 CPU1.AT26 CPU1.AT27 CPU1.AT28 CPU1.AT29 CPU1.AT30 CPU1.AT32 CPU1.AT34 CPU1.AT36 CPU1.AT38 CPU1.AT39 CPU1.AU2 CPU1.AU3 CPU1.AU5 CPU1.AU7 CPU1.AU25 CPU1.AU30 CPU1.AU34 CPU1.AU38 CPU1.AU40 CPU1.AV3 CPU1.AV7 CPU1.AV21 CPU1.AV28 CPU1.AV30 CPU1.AV34 CPU1.AV38 CPU1.AV39 CPU1.AW3 CPU1.AW7 CPU1.AW26 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AW38 CPU1.AY3 CPU1.AY5 CPU1.AY7 CPU1.AY17 CPU1.AY23 CPU1.AY26 CPU1.AY27 CPU1.AY30 CPU1.B4 CPU1.B8 CPU1.B10 CPU1.B23 CPU1.B24 CPU1.B26 CPU1.B28 CPU1.B30 CPU1.B32 CPU1.B34 CPU1.B36 CPU1.B38 CPU1.B39 CPU1.C3 CPU1.C4 CPU1.C6 CPU1.C12 CPU1.C14 CPU1.C16 CPU1.C18 CPU1.C19 CPU1.C21 CPU1.C23 CPU1.C36 CPU1.C40 CPU1.D2 CPU1.D5 CPU1.D6 CPU1.D7 CPU1.D9 CPU1.D11 CPU1.D13 CPU1.D15 CPU1.D17 CPU1.D23 CPU1.D24 CPU1.D26 CPU1.D28 CPU1.D30 CPU1.D32 CPU1.D34 CPU1.D36 CPU1.D37 CPU1.D40 CPU1.E3 CPU1.E6 CPU1.E7 CPU1.E8 CPU1.E10 CPU1.E18 CPU1.E20 CPU1.E22 CPU1.E23 CPU1.E36 CPU1.E38 CPU1.F1 CPU1.F4 CPU1.F7 CPU1.F12 CPU1.F14 CPU1.F16 CPU1.F19 CPU1.F21 CPU1.F22 CPU1.F24 CPU1.F26 CPU1.F28 CPU1.F30 CPU1.F32 CPU1.F34 CPU1.F36 CPU1.G3 CPU1.G6 CPU1.G7 CPU1.G9 CPU1.G11 CPU1.G12 CPU1.G13 CPU1.G14 CPU1.G15 CPU1.G16 CPU1.G17 CPU1.G21 CPU1.G36 CPU1.G37 CPU1.H1 CPU1.H4 CPU1.H7 CPU1.H8 CPU1.H9 CPU1.H10 CPU1.H11 CPU1.H13 CPU1.H17 CPU1.H18 CPU1.H20 CPU1.H21 CPU1.H22 CPU1.H24 CPU1.H26 CPU1.H28 CPU1.H30 CPU1.H32 CPU1.H34 CPU1.H36 CPU1.H39 CPU1.J3 CPU1.J6 CPU1.J7 CPU1.J11 CPU1.J14 CPU1.J18 CPU1.J19 CPU1.J20 CPU1.J36 CPU1.J37 CPU1.K1 CPU1.K4 CPU1.K7 CPU1.K10 CPU1.K14 CPU1.K15 CPU1.K16 CPU1.K17 CPU1.K18 CPU1.K20 CPU1.K22 CPU1.K24 CPU1.K26 CPU1.K28 CPU1.K30 CPU1.K32 CPU1.K34 CPU1.K36 CPU1.K40 CPU1.L3 CPU1.L6 CPU1.L7 CPU1.L8 CPU1.L9 CPU1.L11 CPU1.L13 CPU1.L14 CPU1.L35 CPU1.L36 CPU1.L38 CPU1.M1 CPU1.M4 CPU1.M5 CPU1.M6 CPU1.M7 CPU1.M9 CPU1.M12 CPU1.M14 CPU1.M16 CPU1.M18 CPU1.M20 CPU1.M22 CPU1.M24 CPU1.M26 CPU1.M28 CPU1.M30 CPU1.M32 CPU1.M34 CPU1.M35 CPU1.M37 CPU1.M40 CPU1.N1 CPU1.N2 CPU1.N3 CPU1.N4 CPU1.N6 CPU1.N7 CPU1.N8 CPU1.N33 CPU1.N34 CPU1.N39 CPU1.P2 CPU1.P5 CPU1.P7 CPU1.P34 CPU1.P35 CPU1.P38 CPU1.P39 CPU1.P40 CPU1.R3 CPU1.R5 CPU1.R6 CPU1.R7 CPU1.R8 CPU1.R35 CPU1.R37 CPU1.R38 CPU1.R39 CPU1.R40 CPU1.T1 CPU1.T2 CPU1.T4 CPU1.T5 CPU1.T6 CPU1.T7 CPU1.T33 CPU1.T36 CPU1.T37 CPU1.T38 CPU1.T39 CPU1.U2 CPU1.U4 CPU1.U7 CPU1.U33 CPU1.U34 CPU1.U35 CPU1.U36 CPU1.U37 CPU1.V3 CPU1.V6 CPU1.V7 CPU1.V8 CPU1.V33 CPU1.V34 CPU1.V40 CPU1.W1 CPU1.W4 CPU1.W7 CPU1.W33 CPU1.W35 CPU1.W37 CPU1.Y4 CPU1.Y5 CPU1.Y6 CPU1.Y33 CPU_FAN.1 D2.8 D3.8 D9.1 D16.8 D17.8 D19.P D22.A D34.1 D35.P D36.P D37.P D38.P D39.P D40.1 DIMM1.2 DIMM1.5 DIMM1.8 DIMM1.11 DIMM1.14 DIMM1.17 DIMM1.20 DIMM1.23 DIMM1.26 DIMM1.29 DIMM1.32 DIMM1.35 DIMM1.38 DIMM1.41 DIMM1.44 DIMM1.47 DIMM1.80 DIMM1.83 DIMM1.86 DIMM1.89 DIMM1.92 DIMM1.95 DIMM1.98 DIMM1.101 DIMM1.104 DIMM1.107 DIMM1.110 DIMM1.113 DIMM1.116 DIMM1.119 DIMM1.121 DIMM1.124 DIMM1.125 DIMM1.127 DIMM1.130 DIMM1.133 DIMM1.134 DIMM1.136 DIMM1.139 DIMM1.142 DIMM1.143 DIMM1.145 DIMM1.148 DIMM1.151 DIMM1.152 DIMM1.154 DIMM1.157 DIMM1.160 DIMM1.161 DIMM1.163 DIMM1.166 DIMM1.199 DIMM1.202 DIMM1.203 DIMM1.205 DIMM1.208 DIMM1.211 DIMM1.212 DIMM1.214 DIMM1.217 DIMM1.220 DIMM1.221 DIMM1.223 DIMM1.226 DIMM1.229 DIMM1.230 DIMM1.232 DIMM1.235 DIMM1.239 DIMM2.2 DIMM2.5 DIMM2.8 DIMM2.11 DIMM2.14 DIMM2.17 DIMM2.20 DIMM2.23 DIMM2.26 DIMM2.29 DIMM2.32 DIMM2.35 DIMM2.38 DIMM2.41 DIMM2.44 DIMM2.47 DIMM2.80 DIMM2.83 DIMM2.86 DIMM2.89 DIMM2.92 DIMM2.95 DIMM2.98 DIMM2.101 DIMM2.104 DIMM2.107 DIMM2.110 DIMM2.113 DIMM2.116 DIMM2.119 DIMM2.121 DIMM2.124 DIMM2.125 DIMM2.127 DIMM2.130 DIMM2.133 DIMM2.134 DIMM2.136 DIMM2.139 DIMM2.142 DIMM2.143 DIMM2.145 DIMM2.148 DIMM2.151 DIMM2.152 DIMM2.154 DIMM2.157 DIMM2.160 DIMM2.161 DIMM2.163 DIMM2.166 DIMM2.199 DIMM2.202 DIMM2.203 DIMM2.205 DIMM2.208 DIMM2.211 DIMM2.212 DIMM2.214 DIMM2.217 DIMM2.220 DIMM2.221 DIMM2.223 DIMM2.226 DIMM2.229 DIMM2.230 DIMM2.232 DIMM2.235 DIMM2.237 DIMM2.239 DIMM3.2 DIMM3.5 DIMM3.8 DIMM3.11 DIMM3.14 DIMM3.17 DIMM3.20 DIMM3.23 DIMM3.26 DIMM3.29 DIMM3.32 DIMM3.35 DIMM3.38 DIMM3.41 DIMM3.44 DIMM3.47 DIMM3.80 DIMM3.83 DIMM3.86 DIMM3.89 DIMM3.92 DIMM3.95 DIMM3.98 DIMM3.101 DIMM3.104 DIMM3.107 DIMM3.110 DIMM3.113 DIMM3.116 DIMM3.117 DIMM3.119 DIMM3.121 DIMM3.124 DIMM3.125 DIMM3.127 DIMM3.130 DIMM3.133 DIMM3.134 DIMM3.136 DIMM3.139 DIMM3.142 DIMM3.143 DIMM3.145 DIMM3.148 DIMM3.151 DIMM3.152 DIMM3.154 DIMM3.157 DIMM3.160 DIMM3.161 DIMM3.163 DIMM3.166 DIMM3.199 DIMM3.202 DIMM3.203 DIMM3.205 DIMM3.208 DIMM3.211 DIMM3.212 DIMM3.214 DIMM3.217 DIMM3.220 DIMM3.221 DIMM3.223 DIMM3.226 DIMM3.229 DIMM3.230 DIMM3.232 DIMM3.235 DIMM3.239 DIMM4.2 DIMM4.5 DIMM4.8 DIMM4.11 DIMM4.14 DIMM4.17 DIMM4.20 DIMM4.23 DIMM4.26 DIMM4.29 DIMM4.32 DIMM4.35 DIMM4.38 DIMM4.41 DIMM4.44 DIMM4.47 DIMM4.80 DIMM4.83 DIMM4.86 DIMM4.89 DIMM4.92 DIMM4.95 DIMM4.98 DIMM4.101 DIMM4.104 DIMM4.107 DIMM4.110 DIMM4.113 DIMM4.116 DIMM4.117 DIMM4.119 DIMM4.121 DIMM4.124 DIMM4.125 DIMM4.127 DIMM4.130 DIMM4.133 DIMM4.134 DIMM4.136 DIMM4.139 DIMM4.142 DIMM4.143 DIMM4.145 DIMM4.148 DIMM4.151 DIMM4.152 DIMM4.154 DIMM4.157 DIMM4.160 DIMM4.161 DIMM4.163 DIMM4.166 DIMM4.199 DIMM4.202 DIMM4.203 DIMM4.205 DIMM4.208 DIMM4.211 DIMM4.212 DIMM4.214 DIMM4.217 DIMM4.220 DIMM4.221 DIMM4.223 DIMM4.226 DIMM4.229 DIMM4.230 DIMM4.232 DIMM4.235 DIMM4.237 DIMM4.239 DP1.2 DP1.5 DP1.8 DP1.11 DP1.14 DP1.16 DP1.19 DP1.G1 DP1.G2 DP1.G3 DP1.G4 DP2.2 DP2.5 DP2.8 DP2.11 DP2.14 DP2.16 DP2.19 DP2.G1 DP2.G2 DP2.G3 DP2.G4 DVI-D.3 DVI-D.11 DVI-D.15 DVI-D.19 DVI-D.22 DVI-D.M1 DVI-D.M2 EC1.2 EC2.2 EC3.2 EC4.2 EC5.2 EC6.2 EC7.2 EC8.2 EC9.2 EC10.2 EC11.2 EC12.2 EC13.2 EC14.2 EC19.2 EC20.2 EC21.2 EC22.2 EC23.2 EC24.2 EC25.2 EC27.2 EC28.2 EC29.2 EC30.2 EC42.2 EC45.2 EC46.2 EC47.2 EC48.2 EC49.2 EC50.2 EC51.2 EC52.2 EC53.2 EC54.2 EC55.2 EC56.2 EC57.2 EC58.2 EC59.2 EC60.2 EC61.2 F_PANEL.5 F_PANEL.8 F_USB1.7 F_USB1.8 F_USB2.7 F_USB2.8 F_USB3.4 FB17.2 H2.2 H2.3 H2.4 H2.5 H3.1 H3.2 H3.3 H3.4 H3.5 H3.6 H3.7 H3.8 H4.1 H4.2 H4.3 H4.4 H4.5 H4.6 H4.7 H4.8 H5.1 H5.2 H5.3 H5.4 H5.5 H5.6 H5.7 H5.8 H6.1 H6.2 H6.3 H6.4 H6.5 H6.6 H6.7 H6.8 H7.1 H7.2 H7.3 H7.4 H7.5 H7.6 H7.7 H7.8 H8.1 H8.2 H8.3 H8.4 H8.5 H8.6 H8.7 H8.8 ILAN.49 LPT.18 LPT.19 LPT.20 LPT.21 LPT.22 LPT.23 LPT.24 LPT.25 ME_TEST.6 OBR.2 PCH1.A12 PCH1.A16 PCH1.A21 PCH1.A35 PCH1.AA5 PCH1.AA8 PCH1.AA10 PCH1.AA11 PCH1.AA12 PCH1.AA14 PCH1.AA17 PCH1.AA22 PCH1.AA28 PCH1.AA30 PCH1.AA34 PCH1.AB4 PCH1.AB14 PCH1.AB28 PCH1.AC5 PCH1.AC8 PCH1.AC30 PCH1.AC31 PCH1.AC34 PCH1.AC38 PCH1.AD14 PCH1.AD26 PCH1.AD28 PCH1.AE4 PCH1.AE8 PCH1.AE12 PCH1.AE31 PCH1.AE41 PCH1.AF3 PCH1.AF14 PCH1.AF16 PCH1.AF17 PCH1.AF28 PCH1.AG2 PCH1.AG4 PCH1.AG8 PCH1.AG30 PCH1.AG34 PCH1.AG38 PCH1.AH14 PCH1.AH16 PCH1.AJ1 PCH1.AJ28 PCH1.AK9 PCH1.AK24 PCH1.AK37 PCH1.AL5 PCH1.AL11 PCH1.AL37 PCH1.AM4 PCH1.AM6 PCH1.AM8 PCH1.AM14 PCH1.AM16 PCH1.AM18 PCH1.AM20 PCH1.AM24 PCH1.AM26 PCH1.AM35 PCH1.AM38 PCH1.AN28 PCH1.AP4 PCH1.AP9 PCH1.AR11 PCH1.AR35 PCH1.AR37 PCH1.AT1 PCH1.AT7 PCH1.AT8 PCH1.AT10 PCH1.AT11 PCH1.AT14 PCH1.AT15 PCH1.AT16 PCH1.AT18 PCH1.AT20 PCH1.AT21 PCH1.AT23 PCH1.AT24 PCH1.AT28 PCH1.AT29 PCH1.AT33 PCH1.AT36 PCH1.AT38 PCH1.AT41 PCH1.AU1 PCH1.AU3 PCH1.AU39 PCH1.AV1 PCH1.AV2 PCH1.AV12 PCH1.AV17 PCH1.AV21 PCH1.AV33 PCH1.AV40 PCH1.AV41 PCH1.AW2 PCH1.AW7 PCH1.AW30 PCH1.AW40 PCH1.B3 PCH1.B25 PCH1.B30 PCH1.B33 PCH1.B38 PCH1.B40 PCH1.B41 PCH1.C6 PCH1.C25 PCH1.C37 PCH1.C41 PCH1.D1 PCH1.D4 PCH1.D6 PCH1.D7 PCH1.D8 PCH1.D9 PCH1.D12 PCH1.D13 PCH1.D14 PCH1.D16 PCH1.D18 PCH1.D19 PCH1.D20 PCH1.D22 PCH1.D24 PCH1.D25 PCH1.D26 PCH1.D27 PCH1.D28 PCH1.D31 PCH1.D32 PCH1.D34 PCH1.D37 PCH1.D41 PCH1.E3 PCH1.E4 PCH1.E5 PCH1.E7 PCH1.E12 PCH1.E31 PCH1.E35 PCH1.E38 PCH1.F18 PCH1.F24 PCH1.F35 PCH1.F37 PCH1.F38 PCH1.G2 PCH1.H4 PCH1.H6 PCH1.H8 PCH1.H9 PCH1.H14 PCH1.H16 PCH1.H20 PCH1.H22 PCH1.H26 PCH1.H28 PCH1.H33 PCH1.H34 PCH1.H38 PCH1.J5 PCH1.J31 PCH1.J37 PCH1.K4 PCH1.K9 PCH1.K31 PCH1.L37 PCH1.L41 PCH1.M16 PCH1.M18 PCH1.M20 PCH1.M22 PCH1.M24 PCH1.M26 PCH1.M28 PCH1.N4 PCH1.N8 PCH1.N31 PCH1.N35 PCH1.N38 PCH1.R1 PCH1.R8 PCH1.R10 PCH1.R34 PCH1.T17 PCH1.T22 PCH1.T23 PCH1.T25 PCH1.T26 PCH1.T28 PCH1.U1 PCH1.U4 PCH1.U8 PCH1.U31 PCH1.U32 PCH1.V26 PCH1.V28 PCH1.V38 PCH1.V40 PCH1.W3 PCH1.W5 PCH1.W8 PCH1.W12 PCH1.W20 PCH1.W22 PCH1.W28 PCH1.Y1 PCH1.Y41 PCI.A1 PCI.A12 PCI.A13 PCI.A18 PCI.A24 PCI.A30 PCI.A35 PCI.A37 PCI.A42 PCI.A48 PCI.A56 PCI.B2 PCI.B3 PCI.B12 PCI.B13 PCI.B15 PCI.B17 PCI.B22 PCI.B28 PCI.B34 PCI.B38 PCI.B46 PCI.B57 PCIE1X.A4 PCIE1X.A12 PCIE1X.A15 PCIE1X.A18 PCIE1X.B4 PCIE1X.B7 PCIE1X.B13 PCIE1X.B16 PCIE1X.B18 PCIE16X_1.A4 PCIE16X_1.A12 PCIE16X_1.A15 PCIE16X_1.A18 PCIE16X_1.A20 PCIE16X_1.A23 PCIE16X_1.A24 PCIE16X_1.A27 PCIE16X_1.A28 PCIE16X_1.A31 PCIE16X_1.A34 PCIE16X_1.A37 PCIE16X_1.A38 PCIE16X_1.A41 PCIE16X_1.A42 PCIE16X_1.A45 PCIE16X_1.A46 PCIE16X_1.A49 PCIE16X_1.A51 PCIE16X_1.A54 PCIE16X_1.A55 PCIE16X_1.A58 PCIE16X_1.A59 PCIE16X_1.A62 PCIE16X_1.A63 PCIE16X_1.A66 PCIE16X_1.A67 PCIE16X_1.A70 PCIE16X_1.A71 PCIE16X_1.A74 PCIE16X_1.A75 PCIE16X_1.A78 PCIE16X_1.A79 PCIE16X_1.A82 PCIE16X_1.B4 PCIE16X_1.B7 PCIE16X_1.B13 PCIE16X_1.B16 PCIE16X_1.B18 PCIE16X_1.B21 PCIE16X_1.B22 PCIE16X_1.B25 PCIE16X_1.B26 PCIE16X_1.B29 PCIE16X_1.B32 PCIE16X_1.B35 PCIE16X_1.B36 PCIE16X_1.B39 PCIE16X_1.B40 PCIE16X_1.B43 PCIE16X_1.B44 PCIE16X_1.B47 PCIE16X_1.B49 PCIE16X_1.B52 PCIE16X_1.B53 PCIE16X_1.B56 PCIE16X_1.B57 PCIE16X_1.B60 PCIE16X_1.B61 PCIE16X_1.B64 PCIE16X_1.B65 PCIE16X_1.B68 PCIE16X_1.B69 PCIE16X_1.B72 PCIE16X_1.B73 PCIE16X_1.B76 PCIE16X_1.B77 PCIE16X_1.B80 PCIE16X_2.A4 PCIE16X_2.A12 PCIE16X_2.A15 PCIE16X_2.A18 PCIE16X_2.A20 PCIE16X_2.A23 PCIE16X_2.A24 PCIE16X_2.A27 PCIE16X_2.A28 PCIE16X_2.A31 PCIE16X_2.B4 PCIE16X_2.B7 PCIE16X_2.B13 PCIE16X_2.B16 PCIE16X_2.B18 PCIE16X_2.B21 PCIE16X_2.B22 PCIE16X_2.B25 PCIE16X_2.B26 PCIE16X_2.B29 PCIE16X_2.B32 PSKM.3 PSKM.9 PSKM.13 PSKM.14 PSKM.15 PSKM.16 PSKM.17 QCL1.S1 QCL1.S2 QCL1.S3 QCL2.S1 QCL2.S2 QCL2.S3 QCL3.S1 QCL3.S2 QCL3.S3 QCL4.S1 QCL4.S2 QCL4.S3 QCL5.S1 QCL5.S2 QCL5.S3 QCL6.S1 QCL6.S2 QCL6.S3 QCL7.S1 QCL7.S2 QCL7.S3 QCL8.S1 QCL8.S2 QCL8.S3 QD3L1.S1 QD3L1.S2 QD3L1.S3 QD3L2.S1 QD3L2.S2 QD3L2.S3 QD5L1.S1 QD5L1.S2 QD5L1.S3 QD5L2.S1 QD5L2.S2 QD5L2.S3 QML1.S1 QML1.S2 QML1.S3 QML2.S1 QML2.S2 QML2.S3 QN1.S QN2.E QN3.E QN4.E QN5.E QN10.S QN11.S QN22.S QN24.E QN25.E QN26.E QN27.E QN28.E QN29.E QN31.E QN33.E QN34.S QN37.E QN39.E QN40.E QN44.S QN45.E QN47.S QN48.E QN49.E QN51.E QN53.E QN54.E QN56.S QN58.S QN59.E QN61.E QN62.E QN64.E QN65.E QN67.E QN72.S QN74.S QN77.E QN78.E QN79.E QN80.E QN82.S QN83.E QN84.E QP3.C QP4.C QP5.C QP7.C R10.1 R13.1 R17.1 R18.1 R20.1 R21.1 R22.1 R23.1 R25.1 R26.1 R28.1 R29.1 R30.1 R31.1 R32.1 R33.1 R34.1 R36.1 R37.1 R39.1 R41.1 R43.1 R44.1 R45.1 R47.1 R49.2 R51.1 R52.1 R56.1 R57.1 R66.1 R67.1 R75.1 R76.2 R87.2 R88.2 R109.2 R110.1 R111.1 R112.1 R117.2 R118.2 R123.2 R124.2 R131.1 R132.1 R137.2 R138.2 R139.2 R140.2 R141.2 R144.1 R145.1 R146.1 R147.1 R149.2 R150.2 R159.1 R160.1 R161.1 R163.2 R164.2 R169.2 R174.2 R175.2 R176.2 R178.2 R179.2 R189.1 R198.1 R199.2 R201.2 R203.2 R204.1 R209.2 R213.2 R218.2 R219.2 R220.2 R226.2 R236.2 R238.2 R240.2 R248.2 R254.1 R256.1 R265.2 R267.1 R276.1 R284.2 R285.2 R286.2 R294.1 R296.2 R297.2 R298.2 R299.2 R300.2 R366.1 R377.1 R381.2 R383.1 R401.1 R409.2 R418.1 R421.2 R434.2 R438.1 R445.1 R446.1 R451.2 R460.1 R468.2 R469.2 R470.2 R505.1 R508.2 R512.2 R554.1 R555.1 R558.1 R562.1 R568.2 R574.2 R578.2 R596.1 R600.1 R608.1 R619.1 R620.1 R621.1 R622.1 R626.1 R654.1 R657.1 R739.1 R777.1 R778.1 R783.1 R784.2 R794.2 R796.2 R809.1 R815.2 R856.2 R861.2 R862.2 R863.2 R864.2 R871.2 R896.1 R897.1 R906.1 R912.1 R921.2 R933.2 R935.1 R936.2 R938.2 R939.2 R943.1 R945.2 R952.2 R964.2 R983.1 R987.1 R995.2 R1001.1 R1002.1 R1002.2 RJ1.3 RJ2.3 RJ5.3 RJ7.3 RJ8.3 RJ9.3 RJ10.3 RJ11.3 RJ17.3 RLAN.25 RLAN.31 RLAN.65 ROM1.4 ROM2.4 RT2.2 SATA1.1 SATA1.4 SATA1.7 SATA2.1 SATA2.4 SATA2.7 SATA3.1 SATA3.4 SATA3.7 SATA4.1 SATA4.4 SATA4.7 SATA5.1 SATA5.4 SATA5.7 SATA_PWR1.3 SATA_PWR1.4 SATA_PWR2.3 SATA_PWR2.4 SC1.2 SC2.2 SC3.2 SC4.2 SC5.2 SC6.2 SC7.2 SC8.2 SC9.1 SC10.1 SC11.2 SC12.1 SC14.2 SC15.1 SC16.1 SC17.2 SC18.2 SC19.2 SC20.2 SC21.2 SC22.2 SC23.2 SC24.2 SC25.2 SC26.2 SC27.1 SC28.2 SC29.1 SC30.1 SC31.1 SC32.2 SC33.2 SC34.2 SC35.1 SC36.1 SC37.1 SC38.1 SC39.1 SC40.1 SC41.1 SC43.1 SC46.1 SC48.2 SC49.2 SC50.1 SC51.1 SC52.1 SJ1.1 SJ1.2 SJ1.7 SJ1.8 SJ1.13 SJ1.14 SJ1.19 SJ1.20 SJ1.25 SJ1.26 SJ1.31 SJ1.32 SJ1.37 SJ1.38 SJ1.49 SJ1.50 SJ1.59 SPI_DEBUG.9 SPIROM1.4 SPIROM2.4 SQP1.C SR15.2 SR19.2 SR20.1 SR23.2 SR32.1 SR37.1 SR38.1 SU1.2 SU2.2 SYS_FAN.1 TPM.2 TPM.12 TPM.17 U1.3 U1.8 U2.3 U2.8 U3.2 U4.3 U4.8 U5.3 U5.8 U6.2 U7.2 U8.3 U8.8 U9.2 U10.3 U10.8 U11.22 U11.36 U11.42 U11.48 U11.58 U11.60 U11.73 U11.79 U11.95 U11.97 U11.111 U11.113 U11.124 U12.3 U13.3 U14.2 U15.2 U16.3 U17.2 U18.2 U19.4 U19.9 U20.2 U21.7 U21.38 U21.74 U22.4 U22.5 U22.6 U23.4 U23.11 U23.18 U23.25 U24.2 U25.3 U26.2 U28.2 U29.4 U29.9 U30.2 U30.9 U31.3 U32.4 U33.2 U33.5 U33.11 U34.8 U34.9 U35.3 U36.3 U39.41 U40.4 U40.9 U41.5 U41.17 U41.29 U42.11 U43.11 USB2X4.A4 USB2X4.B4 USB2X4.C4 USB2X4.D4 USB2X4.G1 USB2X4.G2 USB2X4.G3 USB2X4.G4 USB2X4.G5 USB2X4.G6 USB3F1.4 USB3F1.7 USB3F1.13 USB3F1.16 VGA.5 VGA.6 VGA.7 VGA.8 VGA.10 VGA.G2 X1.3 X2.3 X3.3 Y1.3 Y1.4
GNDA1: C327.2 C328.2 C329.2 C338.2 R276.2 R279.1 U11.3 U11.6 U11.13 U11.14 U11.15
P2V12: D21.1 R563.2
P2VCC: C548.1 R564.1 R565.1 U31.5
P2VCC_R: D20.3 R564.2
P2VIN: C546.1 C547.1 C549.1 C550.1 EC20.1 EC21.1 L3.2 QMH1.D1 QMH1.D2 QMH1.D3 QMH1.D4 QMH1.D5
V1N: P2.1 R835.1 R852.1 R877.1 R900.1
V2N: P4.1 R826.1 R859.1 R878.1 R901.1
V3N: P6.1 R827.1 R853.1 R881.1 R903.1
V3P3_BG_N1: QN32.B R264.2 R265.1
V3P3_BG_N2: QN33.B R268.2
V3P3_BG_N3: QN32.C R262.1 R263.1 R269.1
V3P3_BG_N4: QN30.G QN31.C R261.1
V3P3_BG_N5: QN34.G R269.2
V3P3_BG_N6: QN34.D R266.1
V3P3_BG_N7: QN31.B R263.2
V3P3_BG_N8: QN32.E QN33.C
V4N: P8.1 R833.1 R857.1 R880.1 R904.1
VCCIO_OUT: C838.2 CPU1.L40 R72.2
3P3_EPW_N1: C608.1 QN65.B R645.1
3P3_EPW_N2: QN65.C R642.1 R643.2
3P3_EPW_N3: C607.1 QSW4.G R643.1
662_P3: C520.1 CODEC.3
662_P4: CODEC.4 R505.2
662_P9: C523.1 CODEC.9 RJ6.2
662_P11: C524.1 CODEC.11 R504.1
81038_EN: C783.2 R909.2 R912.2 U41.26
81038_FB1: C801.2 C804.1 R929.2 R932.1 R933.1 U41.14
81038_FB2: C791.2 C793.1 R918.2 R919.1 R921.1 U41.8
81038_VIN: C858.1 R908.2 R909.1 U41.22
95820_P3: C760.1 R861.1 U39.3
95820_P5: R865.1 U39.5
95820_P5_R: R865.2 R871.1 RT2.1
95820_P6: C746.2 C748.2 C751.2 R837.2 U39.6
95820_P6_1: C748.1 R840.2
95820_P6_2: C747.2 R839.1
95820_P6_R: C745.2 R837.1
95820_P8: C752.2 U39.8
95820_P8_C: C751.1 C752.1 R839.2 R840.1 R843.2 R847.2 U39.7
95820_P8_R1: C749.2 R843.1
95820_P9: R850.2 U39.9
95820_P9_R: C749.1 R847.1 R849.1 R850.1
95820_P9_R1: C754.1 C756.1 R846.2 R849.2 R851.2
95820_P14: C754.2 C757.1 R854.2 R856.1 U39.14
95820_P25: C738.1 R817.2 U39.25
95820_P32: C736.1 R812.2 U39.32
95820_P33: R864.1 U39.33
95820_P34: R863.1 U39.34
95820_P35: R862.1 U39.35
95820_P36: R828.2 U39.36
95820_P37: R831.2 U39.37
+1P05V_FB: C574.1 C830.1 C831.1 R601.2 U32.2
+1P5V_FB: C832.1 C833.1 C834.1 R611.2 U32.6
+1P05V_REF: C573.2 QN53.C R591.1 R596.2 U32.3
+1P5V_REF: C579.2 R602.1 R604.1 R608.2 U32.5
+12_VGA_G: QN76.G R798.1
+ATX_3VSB: C281.1 C384.1 C387.1 C396.1 C397.1 C595.1 C599.1 D1.2 EC28.1 ME_TEST.1 PCH1.AV39 PCH1.AW38 PCH1.AW39 PFB8.2 QSW3.S R225.2 R231.2 R234.2 R237.2 R344.2 R345.2 R350.2 R351.2 R367.2 R368.2 R442.2 R624.1 R627.2 R633.2 R634.2 R640.2 R695.1 R944.2 RJ11.1 RN26.2(B) RN26.4(B) RN26.6(B) RN26.8(B) ROM1.8 SR51.2 SR52.2 U21.4 U21.35 U21.67 U34.5 U34.6
+ATX_3VSB_FB: R624.2 R626.2 U34.7
+ATX_5VSB: ATX_POWER.10 C593.1 C601.1 C602.1 C603.1 C604.1 C723.1 D19.N D40.2 EC45.1 PFB9.1 QSW2.S R342.2 R625.2 R647.2 R809.2 R962.1 R990.1 R991.1
+DDR_VTTR: C135.1 C136.1 C137.1 C138.1 C159.1 C160.1 C161.1 C162.1 C544.1 C545.1 DIMM1.120 DIMM1.240 DIMM2.120 DIMM2.240 DIMM3.120 DIMM3.240 DIMM4.120 DIMM4.240 EC19.1 U30.4
+DDR_VTTR_REF: C551.1 R566.2 R568.1 U30.3
+DI_5VDU_N1: QN48.B R585.2
+DI_5VDU_N2: QN49.C R583.2 R584.2 R585.1 R590.2
+DI_5VDU_N3: QN51.B R590.1
+DI_5VDU_N4: C564.2 QN49.B R582.2 R588.2
+DIMM_5VDUAL: C541.1 C563.1 D20.1 D21.2 EC25.1 L3.1 QN50.D QSW1.D R388.1 R393.2 R394.2 R395.1 R565.2
+DP_PWR: C95.2 C703.2 C814.1 DP1.20 DP2.20 R80.2
+DP_VCC3: C107.1 C700.1 QN8.D R77.2 R80.1 R83.2 R84.2 R89.2 R786.2 R791.2 R797.2 U3.5 U6.5
+DVI_VCC: C129.1 C675.1 C676.1 DVI-D.14 PFB12.1 R105.1 R108.1 U9.5
+DVI_VGA_VCC: PFB12.2 PFB13.2 QN76.D R128.2
+ENSR: R449.2 RLAN.62
+EVDD12: C474.2 C475.2 R953.1 RLAN.28 SR1.2
+LDOVDD: C506.1 C843.1 CODEC.29 PFB9.2
+RTCVCC: C282.1 C484.1 CLR_CMOS.1 D1.3 PCH1.AP33 R229.1 R233.1 R247.2 R252.2 R386.1
+RTCVCC_BAT: BAT1.P R250.1
+RTCVCC_BAT_R: D1.1 R250.2
+SPI_3P3V: C370.1 C371.1 C372.1 C373.1 R314.1 R316.1 R764.1 R765.1 SD1.3 SPI_DEBUG.4 SPIROM1.8 SPIROM2.8 SR49.2 SR50.1
+SROUT12: L2.1 RLAN.1
+SROUT12_R: C462.2 C463.2 L2.2 R455.1
+USB3VCC0: C502.2 D39.N EC14.1 R329.1 R468.1 U29.7 U29.8 USB3_LAN.1 USB3_LAN.10
+USB3VCC1: C368.2 C369.1 EC11.1 R300.1 U19.7 U19.8 U20.5 USB3F1.1 USB3F1.19
+USBVCC0: C360.1 C361.1 EC9.1 R298.1 U17.5 U29.6 USB2X4.A1 USB2X4.B1
+USBVCC1: C362.1 C409.1 EC10.1 PSKM.4 PSKM.10 R299.1 RN27.1(A) RN27.3(A) RN27.5(A) RN27.7(A) SC48.1 U16.7 U16.8 U18.5 USB2X4.C1 USB2X4.D1
+USBVCC2: C358.1 C359.1 EC8.1 F_USB2.1 F_USB2.2 R297.1 U12.7 U12.8 U15.5
+USBVCC3: C356.1 C357.1 EC7.1 F_USB1.1 F_USB1.2 R296.1 U13.7 U13.8 U14.5
+USBVCC4: C420.1 C817.1 EC60.1 F_USB3.1 R938.1 U25.7 U25.8 U26.5
+UVDD12: C476.2 C477.2 RLAN.43 SR43.2
+V_1P05_ME: C278.1 C279.1 C280.1 C587.1 C588.1 C589.1 C590.2 C613.1 L6.2 PCH1.AA23 PCH1.AA25 PCH1.AA26 PCH1.AB22 PCH1.AB23 PCH1.AB25 PCH1.AB26 PCH1.AD17 PCH1.AD19 PCH1.AD20 PCH1.AD22 PCH1.AD23 PCH1.AD25 PCH1.AF25 PCH1.W26 R188.2 R597.2 R599.2 R616.1
+V_1P05_ME_R_B: C228.2 QN27.B R188.1 R189.2
+V_1P05_ME_R_C: C227.1 QN25.B QN27.C R183.1
+V_1P05_PCH: C243.1 C244.1 C248.1 C257.1 C258.1 C259.1 C260.1 C268.1 C269.1 C270.1 C271.1 C401.2 C402.2 C403.2 C404.2 C486.2 C487.2 C488.2 C489.2 C490.2 C497.2 C498.2 C575.1 C577.1 C654.2 C668.1 C697.1 C698.1 C829.2 C831.2 C844.1 EC27.1 PCH1.AA16 PCH1.AA19 PCH1.AA20 PCH1.AB2 PCH1.AB16 PCH1.AB17 PCH1.AB19 PCH1.AB20 PCH1.AC12 PCH1.AD16 PCH1.AF19 PCH1.AF20 PCH1.AF22 PCH1.AF23 PCH1.AP22 PCH1.M14 PCH1.P14 PCH1.P16 PCH1.P17 PCH1.P22 PCH1.P23 PCH1.P25 PCH1.P26 PCH1.P28 PCH1.T16 PCH1.T19 PCH1.T20 PCH1.U12 PCH1.V14 PCH1.V16 PCH1.V17 PCH1.V19 PCH1.V20 PCH1.V22 PCH1.V23 PCH1.V25 PCH1.W14 PCH1.W16 PCH1.W17 PCH1.W19 PCH1.W23 PCH1.W25 PFB2.1 QN52.S R15.1 R40.1 R71.2 R73.2 R441.2 R597.1 R599.1 R601.1 R612.2 R985.1 SC9.2 SC18.1 SC19.1 SC20.1 SC21.1 SC23.1 SC28.1
+V_1P5_PCH: C250.2 C580.2 C581.1 C582.1 C834.2 PCH1.A4 PCH1.A19 PCH1.A33 PCH1.A38 PCH1.A39 PCH1.A40 PCH1.B4 PCH1.B13 PCH1.B37 PCH1.B39 PCH1.C1 PCH1.C2 PCH1.K1 PCH1.N10 PCH1.N11 PCH1.T14 PFB1.2 QN55.S R129.1 R130.1 R153.1 R166.2 R264.1 R610.2 R611.1 SC22.1 SR21.1
+V_3P3_BG: C253.1 C254.1 PCH1.AE1 PCH1.AW21 PCH1.B6 QN30.S R260.2 R266.2 R267.2
+V_3P3_EPW: C273.1 PCH1.R41 QSW4.D R182.2 R646.2 R651.2 SD1.1 SD1.2 SR50.2
+V_3P3_EPW_3VSB_R: R181.1 R182.1 R183.2 R184.2
