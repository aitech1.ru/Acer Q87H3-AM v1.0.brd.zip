# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Nets (continued)
+V_3P3_LAN: C442.2 C450.2 C483.2 C499.1 C606.2 C669.2 C670.1 C699.2 C856.2 D38.N EC30.1 ILAN.4 ILAN.5 ILAN.15 ILAN.19 ILAN.29 Q7.5 Q7.6 Q7.7 Q7.8 QP9.S QSW4.S R426.2 R431.2 R436.2 R443.2 R444.1 R447.2 R448.2 R450.2 R462.2 R463.2 R639.1 R640.1 R642.2 R651.1 R964.1 SC10.2 SU1.5 SU2.5 U28.5 USB3_LAN.32
+VCOMP_OUT: CPU1.P4 R1.1 R4.1
+VCORE: C10.2 C11.2 C12.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C39.2 C40.2 C41.2 C42.2 C820.1 CPU1.A24 CPU1.A25 CPU1.A26 CPU1.A27 CPU1.A28 CPU1.A29 CPU1.A30 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B33 CPU1.B35 CPU1.C24 CPU1.C25 CPU1.C26 CPU1.C27 CPU1.C28 CPU1.C29 CPU1.C30 CPU1.C31 CPU1.C32 CPU1.C33 CPU1.C34 CPU1.C35 CPU1.D25 CPU1.D27 CPU1.D29 CPU1.D31 CPU1.D33 CPU1.D35 CPU1.E24 CPU1.E25 CPU1.E26 CPU1.E27 CPU1.E28 CPU1.E29 CPU1.E30 CPU1.E31 CPU1.E32 CPU1.E33 CPU1.E34 CPU1.E35 CPU1.F23 CPU1.F25 CPU1.F27 CPU1.F29 CPU1.F31 CPU1.F33 CPU1.F35 CPU1.G22 CPU1.G23 CPU1.G24 CPU1.G25 CPU1.G26 CPU1.G27 CPU1.G28 CPU1.G29 CPU1.G30 CPU1.G31 CPU1.G32 CPU1.G33 CPU1.G34 CPU1.G35 CPU1.H23 CPU1.H25 CPU1.H27 CPU1.H29 CPU1.H31 CPU1.H33 CPU1.H35 CPU1.J21 CPU1.J22 CPU1.J23 CPU1.J24 CPU1.J25 CPU1.J26 CPU1.J27 CPU1.J28 CPU1.J29 CPU1.J30 CPU1.J31 CPU1.J32 CPU1.J33 CPU1.J34 CPU1.J35 CPU1.K19 CPU1.K21 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K29 CPU1.K31 CPU1.K33 CPU1.K35 CPU1.L15 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L19 CPU1.L20 CPU1.L21 CPU1.L22 CPU1.L23 CPU1.L24 CPU1.L25 CPU1.L26 CPU1.L27 CPU1.L28 CPU1.L29 CPU1.L30 CPU1.L31 CPU1.L32 CPU1.L33 CPU1.L34 CPU1.M8 CPU1.M13 CPU1.M15 CPU1.M17 CPU1.M19 CPU1.M21 CPU1.M23 CPU1.M25 CPU1.M27 CPU1.M29 CPU1.M33 CPU1.P8 EC49.1 EC50.1 EC51.1 EC52.1 EC53.1 EC54.1 EC55.1 L8.2 L9.2 L10.2 L11.2 P2.2 P4.2 P6.2 P8.2 R331.1 R846.1
+VDIMM: C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C43.2 C44.2 C45.2 C46.2 C130.1 C131.1 C132.1 C133.1 C134.1 C141.1 C142.1 C143.1 C144.1 C145.1 C146.1 C147.1 C148.1 C149.1 C150.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.1 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C181.1 C182.1 C542.1 C543.1 C554.1 C555.1 C556.1 C571.2 C572.1 CPU1.AJ9 CPU1.AJ12 CPU1.AJ13 CPU1.AJ15 CPU1.AJ17 CPU1.AJ20 CPU1.AJ21 CPU1.AJ24 CPU1.AJ25 CPU1.AJ28 CPU1.AJ29 CPU1.AT17 CPU1.AT22 CPU1.AU15 CPU1.AU20 CPU1.AU24 CPU1.AV8 CPU1.AV10 CPU1.AV11 CPU1.AV13 CPU1.AV18 CPU1.AV23 CPU1.AW16 CPU1.AY9 CPU1.AY12 CPU1.AY14 DIMM1.51 DIMM1.54 DIMM1.57 DIMM1.60 DIMM1.62 DIMM1.65 DIMM1.66 DIMM1.69 DIMM1.72 DIMM1.75 DIMM1.78 DIMM1.170 DIMM1.173 DIMM1.176 DIMM1.179 DIMM1.182 DIMM1.183 DIMM1.186 DIMM1.189 DIMM1.191 DIMM1.194 DIMM1.197 DIMM2.51 DIMM2.54 DIMM2.57 DIMM2.60 DIMM2.62 DIMM2.65 DIMM2.66 DIMM2.69 DIMM2.72 DIMM2.75 DIMM2.78 DIMM2.170 DIMM2.173 DIMM2.176 DIMM2.179 DIMM2.182 DIMM2.183 DIMM2.186 DIMM2.189 DIMM2.191 DIMM2.194 DIMM2.197 DIMM3.51 DIMM3.54 DIMM3.57 DIMM3.60 DIMM3.62 DIMM3.65 DIMM3.66 DIMM3.69 DIMM3.72 DIMM3.75 DIMM3.78 DIMM3.170 DIMM3.173 DIMM3.176 DIMM3.179 DIMM3.182 DIMM3.183 DIMM3.186 DIMM3.189 DIMM3.191 DIMM3.194 DIMM3.197 DIMM4.51 DIMM4.54 DIMM4.57 DIMM4.60 DIMM4.62 DIMM4.65 DIMM4.66 DIMM4.69 DIMM4.72 DIMM4.75 DIMM4.78 DIMM4.170 DIMM4.173 DIMM4.176 DIMM4.179 DIMM4.182 DIMM4.183 DIMM4.186 DIMM4.189 DIMM4.191 DIMM4.194 DIMM4.197 EC22.1 EC23.1 EC24.1 EC42.1 L4.2 QN52.D R113.1 R114.1 R119.1 R120.1 R332.1 R566.1 R576.2 RJ4.3 SR22.2 U30.1
+VGA_VCC: C189.1 C208.1 C210.1 C705.2 C706.1 PFB13.1 R804.2 R805.2 SC49.1 U7.5 U24.5 U35.5 U36.5 VGA.9
+VREF25: D22.C D22.R R602.2 R629.1
-ACTIVE_P: C491.1 D37.N R466.1 USB3_LAN.31
-LINK_1G: C494.1 D36.N R462.1 R465.1 USB3_LAN.30
-LINK_100: C493.1 D35.N R463.1 R464.1 USB3_LAN.29
A20GATE: PCH1.N30 RN15.1(A) U21.46
AD0: PCI.A58 U11.30
AD1: PCI.B58 U11.31
AD2: PCI.A57 U11.33
AD3: PCI.B56 U11.34
AD4: PCI.A55 U11.37
AD5: PCI.B55 U11.38
AD6: PCI.A54 U11.39
AD7: PCI.B53 U11.40
AD8: PCI.B52 U11.43
AD9: PCI.A49 U11.44
AD10: PCI.B48 U11.45
AD11: PCI.A47 U11.50
AD12: PCI.B47 U11.51
AD13: PCI.A46 U11.52
AD14: PCI.B45 U11.53
AD15: PCI.A44 U11.54
AD16: PCI.A32 R291.2 U11.74
AD17: PCI.B32 U11.75
AD18: PCI.A31 U11.76
AD19: PCI.B30 U11.77
AD20: PCI.A29 U11.80
AD21: PCI.B29 U11.81
AD22: PCI.A28 U11.82
AD23: PCI.B27 U11.83
AD24: PCI.A25 U11.85
AD25: PCI.B24 U11.86
AD26: PCI.A23 U11.88
AD27: PCI.B23 U11.89
AD28: PCI.A22 U11.98
AD29: PCI.B21 U11.99
AD30: PCI.A20 U11.100
AD31: PCI.B20 U11.101
ANTI_POP_L: CODEC.47 R480.2
ATX_3VSB_EN: C836.2 R962.2 U34.2 U34.3 U34.4
ATX_PSON_L: ATX_POWER.8 C724.1 QN47.G QN82.G R344.1 U21.76
ATX_PSON_L_D: QN82.D R956.2
ATX_PSON_LOAD: QN47.D R575.2
ATX_PWRGD: ATX_POWER.9 C725.1 R309.2 R343.1 R582.1 R641.2 R808.2
ATX_PWRGD_3VSB_1: QN39.B R309.1
ATX_PWRGD_3VSB_2: QN37.B QN39.C R307.1
ATX_PWRGD_3VSB_3: QN36.G QN37.C QN38.G R306.1
ATX_PWRGD_R: C394.1 R343.2 U21.19
AUGND: AUDIO.1P AUDIO.2P AUDIO.3P AUDIO.5 AUDIO.G1 AUDIO.G2 AUDIO.G3 AUDIO.G4 C506.2 C507.2 C508.2 C509.2 C510.2 C511.2 C527.1 C528.1 C531.1 C532.1 C533.1 C534.1 C535.2 C536.2 C537.2 C538.2 C722.1 C843.2 CODEC.26 CODEC.42 D24.3 D25.3 D27.3 D28.3 F_AUDIO.2 F_AUDIO.7 H1.1 H1.2 H1.3 H1.4 H1.5 H1.6 H1.7 H1.8 H2.1 H2.6 H2.7 H2.8 INT_SPK.2 INT_SPK.5 INT_SPK.6 Q1.E1 Q1.E2 Q2.E1 Q2.E2 Q3.E1 Q3.E2 Q4.E1 Q4.E2 Q5.E1 Q5.E2 Q6.E1 Q6.E2 QN46.E R491.1 R508.1 R512.1 R514.2 R519.2 R523.2 R524.2 R525.2 R526.2 R528.2 R529.2 R530.2 R531.2 SC44.2 SC45.2 SD2.3 SR15.1 SR45.2 SR46.2
BCLK: C525.1 CODEC.6 R510.1
BRIDGE_100M_N: PCH1.W7 R280.1
BRIDGE_100M_P: PCH1.W6 R281.1
BRIDGE_CLK_N: R280.2 U11.9
BRIDGE_CLK_P: R281.2 U11.10
BRIDGE_RX_N2: C343.1 PCH1.F14
BRIDGE_RX_N2_C: C343.2 U11.20
BRIDGE_RX_P2: C344.1 PCH1.G14
BRIDGE_RX_P2_C: C344.2 U11.21
BRIDGE_TX_N2: C653.1 PCH1.D11
BRIDGE_TX_N2_C: C653.2 U11.18
BRIDGE_TX_P2: C652.1 PCH1.C11
BRIDGE_TX_P2_C: C652.2 U11.17
BST1: R920.1 U41.20
BST1_R: C794.1 R920.2
BST2: R907.1 U41.2
BST2_R: C784.1 R907.2
BZ_P: BZ.N C410.1 D7.P RN28.2(B) RN28.4(B) RN28.6(B) RN28.8(B)
C_BE_L0: PCI.A52 U11.46
C_BE_L1: PCI.B44 U11.49
C_BE_L2: PCI.B33 U11.69
C_BE_L3: PCI.B26 U11.87
CASE_THERMDA: C818.2 C819.2 THER_HD.1 U21.88
CASE_THERMDC: C818.1 C819.1 R941.2 THER_HD.2
CFG0: CPU1.AA37 R18.2 SJ1.9
CFG1: CPU1.Y38 R20.2 SJ1.11
CFG2: CPU1.AA36 R21.2 SJ1.15
CFG3: CPU1.W38 R22.2 SJ1.17 SR40.1
CFG4: CPU1.V39 R23.2 SJ1.27
CFG5: CPU1.U39 R25.2 SJ1.29
CFG6: CPU1.U40 R28.2 SJ1.33
CFG7: CPU1.V38 R30.2 SJ1.35
CFG8: CPU1.T40 R32.2 SJ1.10
CFG9: CPU1.Y35 R33.2 SJ1.12
CFG10: CPU1.AA34 R34.2 SJ1.16
CFG11: CPU1.V37 R36.2 SJ1.18
CFG12: CPU1.Y34 R37.2 SJ1.28
CFG13: CPU1.U38 R50.2 R52.2 SJ1.30
CFG14: CPU1.W34 R39.2 SJ1.34
CFG15: CPU1.V35 R41.2 SJ1.36
CFG16: CPU1.Y37 R44.2 SJ1.6
CFG17: CPU1.Y36 R43.2 SJ1.4
CFG18: CPU1.W36 R47.2 SJ1.24
CFG19: CPU1.V36 R45.2 SJ1.22
CFG_RCOMP: CPU1.H40 R57.2
CK_DMI_100M_N: CPU1.V4 PCH1.R2
CK_DMI_100M_P: CPU1.V5 PCH1.T2
CK_DP_NSSC_N: CPU1.W6 PCH1.W2
CK_DP_NSSC_P: CPU1.W5 PCH1.U2
CK_DP_SSC_N: CPU1.U5 PCH1.T3
CK_DP_SSC_P: CPU1.U6 PCH1.T5
CK_H_XDP_N: PCH1.U6 SR34.1
CK_H_XDP_P: PCH1.U7 SR33.1
CLKIN_GND_N: PCH1.G16 R150.1
CLKIN_GND_P: PCH1.F16 R149.1
CLKIN_SATA_N: PCH1.H35 R163.1
CLKIN_SATA_P: PCH1.H36 R164.1
CLR_CMOS_P3: CLR_CMOS.3 R254.2
COM1_CTS_L: U21.1 U42.14
COM1_DCD_L: U21.127 U42.19
COM1_DSR_L: U21.123 U42.17
COM1_DTR_L: U21.126 U42.13
COM1_NCTS_L: CN5.4(B) COM1.8 U42.7
COM1_NDCD_L: CN6.2(B) COM1.1 U42.2
COM1_NDSR_L: CN6.6(B) COM1.6 U42.4
COM1_NDTR_L: CN5.6(B) COM1.4 U42.8
COM1_NRI_L: CN5.8(B) COM1.9 D15.P U42.9
COM1_NRTS_L: CN5.2(B) COM1.7 U42.6
COM1_NSIN: CN6.4(B) COM1.2 U42.3
COM1_NSOUT: CN6.8(B) COM1.3 U42.5
COM1_RI_L: D32.N R461.2 R695.2 U21.128
COM1_RI_L_IC: D32.P U42.12
COM1_RTS_L: U21.122 U42.15
COM1_SIN: U21.125 U42.18
COM1_SOUT: U21.124 U42.16
COM2_CTS_L: U21.27 U43.14
COM2_DCD_L: U21.26 U43.19
COM2_DSR_L: U21.22 U43.17
COM2_DTR_L: U21.29 U43.13
COM2_NCTS_L: CN8.3(A) COM2.8 U43.7
COM2_NDCD_L: CN7.1(A) COM2.1 U43.2
COM2_NDSR_L: CN7.5(A) COM2.6 U43.4
COM2_NDTR_L: CN8.5(A) COM2.4 U43.8
COM2_NRI_L: CN8.7(A) COM2.9 D14.P U43.9
COM2_NRTS_L: CN8.1(A) COM2.7 U43.6
COM2_NSIN: CN7.3(A) COM2.2 U43.3
COM2_NSOUT: CN7.7(A) COM2.3 U43.5
COM2_RI_L: D31.N U21.28
COM2_RI_L_IC: D31.P U43.12
COM2_RTS_L: U21.23 U43.15
COM2_SIN: U21.20 U43.18
COM2_SOUT: U21.21 U43.16
COM_+12V: D29.N U42.1 U43.1
COM_-12V: D30.P U42.10 U43.10
COM_NRI_L: D14.N D15.N R414.1
COM_NRI_L_R: QN45.B R414.2 R418.2
COMP1: C802.2 C804.2 U41.13
COMP1_RC: C801.1 R928.1
COMP1_RC1: C802.1 R929.1
COMP2: C792.2 C793.2 U41.9
COMP2_RC: C791.1 R917.1
COMP2_RC2: C792.1 R918.1
COPEN_L: C682.1 C711.1 C_INTRUSION.2 D8.3 R386.2 U21.68
CPU_AA35: PCH1.AA35 STP14.1
CPU_AB8: CPU1.AB8 SR17.1
CPU_AC35: PCH1.AC35 STP13.1
CPU_AL20: CPU1.AL20 STP12.1
CPU_AV20: CPU1.AV20 TP14.1
CPU_AW12: CPU1.AW12 TP12.1
CPU_AW27: CPU1.AW27 TP15.1
CPU_E16: CPU1.E16 STP1.1
CPU_G38: CPU1.G38 STP8.1
CPU_H37: CPU1.H37 STP4.1
CPU_H38: CPU1.H38 STP9.1
CPU_J12: CPU1.J12 STP3.1
CPU_J38: CPU1.J38 STP10.1
CPU_K11: CPU1.K11 STP2.1
CPU_K37: CPU1.K37 STP6.1
CPU_K39: CPU1.K39 STP5.1
CPU_M36: CPU1.M36 STP7.1
CPU_N35: CPU1.N35 STP18.1
CPU_PECI: CPU1.N37 R24.1 R27.1
CPU_PLTRST_L: PCH1.F41 R19.2 R986.1
CPU_PWROK: PCH1.D40 R16.2 R64.2 R982.1
CPU_PWROK_RC: C2.1 CPU1.AB35 R16.1 R739.2
CPU_RST_L_RC: C3.1 CPU1.M39 R19.1
CPU_T8: CPU1.T8 STP11.1
CPU_THERMTRIP_L: CPU1.F37 R42.2
CSP1_RC: C803.2 R930.1 R931.2 U41.16
CSP2_RC: C790.2 R914.1 R915.2 U41.6
DDC1CLK: C710.1 R802.1 U24.4 VGA.15
DDC1DATA: C707.1 R801.1 U24.6 VGA.12
DDIB_AUX_N: DP2.17 QN71.D QN75.D R797.1 U6.1
DDIB_AUX_P: DP2.15 QN69.S QN73.D R794.1 U6.6
DDIB_AUXN: C702.1 PCH1.AK6
DDIB_AUXN_C: C702.2 QN75.S
DDIB_AUXP: C701.1 PCH1.AK8
DDIB_AUXP_C: C701.2 QN73.S
DDIB_CTRLCLK: PCH1.AM1 QN69.D R786.1
DDIB_CTRLDATA: PCH1.AJ5 QN71.S R791.1
DDIB_N0_C: C100.2 CMK33.4 RN43.3(A)
DDIB_N0_R: CMK33.3 DP2.3 RN43.4(B) U4.2 U4.9
DDIB_N1_C: C102.2 CMK34.4 RN43.7(A)
DDIB_N1_R: CMK34.3 DP2.6 RN43.8(B) U4.5 U4.6
DDIB_N2_C: C98.2 CMK35.4 RN44.3(A)
DDIB_N2_R: CMK35.3 DP2.9 RN44.4(B) U5.2 U5.9
DDIB_N3_C: C105.2 CMK36.4 RN44.7(A)
DDIB_N3_R: CMK36.3 DP2.12 RN44.8(B) U5.5 U5.6
DDIB_P0_C: C101.2 CMK33.1 RN43.1(A)
DDIB_P0_R: CMK33.2 DP2.1 RN43.2(B) U4.1 U4.10
DDIB_P1_C: C103.2 CMK34.1 RN43.5(A)
DDIB_P1_R: CMK34.2 DP2.4 RN43.6(B) U4.4 U4.7
DDIB_P2_C: C99.2 CMK35.1 RN44.1(A)
DDIB_P2_R: CMK35.2 DP2.7 RN44.2(B) U5.1 U5.10
DDIB_P3_C: C104.2 CMK36.1 RN44.5(A)
DDIB_P3_R: CMK36.2 DP2.10 RN44.6(B) U5.4 U5.7
DDIB_TX_N0: C100.1 CPU1.F17
DDIB_TX_N1: C102.1 CPU1.G18
DDIB_TX_N2: C98.1 CPU1.H19
DDIB_TX_N3: C105.1 CPU1.G20
DDIB_TX_P0: C101.1 CPU1.E17
DDIB_TX_P1: C103.1 CPU1.F18
DDIB_TX_P2: C99.1 CPU1.G19
DDIB_TX_P3: C104.1 CPU1.F20
DDIC_AUX_N: DP1.17 QN9.D QN13.D R89.1 U3.1
DDIC_AUX_P: DP1.15 QN7.S QN12.D R87.1 U3.6
DDIC_AUXN: C94.1 PCH1.AG7
DDIC_AUXN_C: C94.2 QN13.S
DDIC_AUXP: C93.1 PCH1.AG6
DDIC_AUXP_C: C93.2 QN12.S
DDIC_CTRLCLK: PCH1.AN3 QN7.D R77.1
DDIC_CTRLDATA: PCH1.AM2 QN9.S R83.1
DDIC_N0_C: C86.2 CMK1.4 RN1.3(A)
DDIC_N0_R: CMK1.3 DP1.3 RN1.4(B) U1.2 U1.9
DDIC_N1_C: C88.2 CMK2.4 RN1.7(A)
DDIC_N1_R: CMK2.3 DP1.6 RN1.8(B) U1.5 U1.6
DDIC_N2_C: C90.2 CMK3.4 RN2.3(A)
DDIC_N2_R: CMK3.3 DP1.9 RN2.4(B) U2.2 U2.9
DDIC_N3_C: C91.2 CMK4.4 RN2.7(A)
DDIC_N3_R: CMK4.3 DP1.12 RN2.8(B) U2.5 U2.6
DDIC_P0_C: C85.2 CMK1.1 RN1.1(A)
DDIC_P0_R: CMK1.2 DP1.1 RN1.2(B) U1.1 U1.10
DDIC_P1_C: C87.2 CMK2.1 RN1.5(A)
DDIC_P1_R: CMK2.2 DP1.4 RN1.6(B) U1.4 U1.7
DDIC_P2_C: C89.2 CMK3.1 RN2.1(A)
DDIC_P2_R: CMK3.2 DP1.7 RN2.2(B) U2.1 U2.10
DDIC_P3_C: C92.2 CMK4.1 RN2.5(A)
DDIC_P3_R: CMK4.2 DP1.10 RN2.6(B) U2.4 U2.7
DDIC_TX_N0: C86.1 CPU1.E19
DDIC_TX_N1: C88.1 CPU1.D20
DDIC_TX_N2: C90.1 CPU1.E21
DDIC_TX_N3: C91.1 CPU1.D22
DDIC_TX_P0: C85.1 CPU1.D19
DDIC_TX_P1: C87.1 CPU1.C20
DDIC_TX_P2: C89.1 CPU1.D21
DDIC_TX_P3: C92.1 CPU1.C22
DDID_CTRLCLK: PCH1.AN4 QN20.S R104.2
DDID_CTRLDATA: PCH1.AN2 QN23.S R107.2
DDID_LEVEL_SF: QN22.D RN9.2(B) RN9.4(B) RN9.6(B) RN9.8(B) RN10.2(B) RN10.4(B) RN10.6(B) RN10.8(B)
DDID_N0_C: C108.2 CMK10.3 RN7.6(B) RN10.5(A)
DDID_N1_C: C109.2 CMK11.3 RN8.2(B) RN9.1(A)
DDID_N2_C: C110.2 CMK9.3 RN8.6(B) RN9.5(A)
DDID_N3_C: C115.2 CMK12.3 RN7.2(B) RN10.1(A)
DDID_P0_C: C112.2 CMK10.2 RN7.8(B) RN10.7(A)
DDID_P1_C: C113.2 CMK11.2 RN8.4(B) RN9.3(A)
DDID_P2_C: C111.2 CMK9.2 RN8.8(B) RN9.7(A)
DDID_P3_C: C114.2 CMK12.2 RN7.4(B) RN10.3(A)
DDID_TX_N0: C110.1 CPU1.C15
DDID_TX_N1: C109.1 CPU1.B16
DDID_TX_N2: C108.1 CPU1.C17
DDID_TX_N3: C115.1 CPU1.B18
DDID_TX_P0: C111.1 CPU1.B15
DDID_TX_P1: C113.1 CPU1.A16
DDID_TX_P2: C112.1 CPU1.B17
DDID_TX_P3: C114.1 CPU1.A18
DDR3_DRAMRST_L: C9.2 DIMM1.168 DIMM2.168 DIMM3.168 DIMM4.168 R68.2
DEPOP_N1: QP5.B R479.1
DEPOP_N2: QP7.B R480.1
DEPOP_N3: QP4.B QP5.E QP7.E R471.1
DEPOP_N4: C505.1 QP4.E R474.2
DEPOP_N5: QP6.B R474.1 R476.2
DEVSEL_L: PCI.B37 R968.1 U11.66
DIFFCLK_BIASREF: PCH1.R11 SR21.2
DIMM_DQ_AC: C7.1 R66.2
DIMM_DQ_BC: C8.1 R67.2
DIMM_DQ_CPU_VREF_A: C7.2 CPU1.AB39 R125.1
DIMM_DQ_CPU_VREF_A_R: C183.1 R119.2 R121.1 R123.1
DIMM_DQ_CPU_VREF_B: C8.2 CPU1.AB40 R126.1
DIMM_DQ_CPU_VREF_B_R: C184.1 R120.2 R122.1 R124.1
DIMM_VREF_CA_A: C179.1 C671.1 DIMM2.67 DIMM4.67 R46.1 R115.2 R157.1
DIMM_VREF_CA_A_R: R113.2 R115.1 R117.1
DIMM_VREF_CA_B: C180.1 C672.1 DIMM1.67 DIMM3.67 R48.1 R116.2 R157.2
DIMM_VREF_CA_B_R: R114.2 R116.1 R118.1
DIMM_VREF_CPU: C4.1 CPU1.AB38 R46.2 R48.2
DIMM_VREF_CPU_C: C4.2 R49.1
DIMM_VREF_DQ_A: C185.1 C186.1 C673.1 DIMM2.1 DIMM4.1 R121.2 R125.2
DIMM_VREF_DQ_B: C187.1 C188.1 C674.1 DIMM1.1 DIMM3.1 R122.2 R126.2
DLA: C828.1 QN50.G QN51.C R589.2
DMI_RX_N0: CPU1.T3 PCH1.C20
DMI_RX_N1: CPU1.V1 PCH1.D21
DMI_RX_N2: CPU1.V2 PCH1.B22
DMI_RX_N3: CPU1.W3 PCH1.A24
DMI_RX_P0: CPU1.U3 PCH1.B20
DMI_RX_P1: CPU1.U1 PCH1.B21
DMI_RX_P2: CPU1.W2 PCH1.C22
DMI_RX_P3: CPU1.Y3 PCH1.B24
DMI_TX_N0: CPU1.AA5 PCH1.L24
DMI_TX_N1: CPU1.AB4 PCH1.G24
DMI_TX_N2: CPU1.AC4 PCH1.F26
DMI_TX_N3: CPU1.AC2 PCH1.K26
DMI_TX_P0: CPU1.AA4 PCH1.K24
DMI_TX_P1: CPU1.AB3 PCH1.H24
DMI_TX_P2: CPU1.AC5 PCH1.G26
DMI_TX_P3: CPU1.AC1 PCH1.L26
DONGLE_DP: QN73.G QN74.D QN75.G R789.2 R793.1
DONGLE_DP2: QN11.D QN12.G QN13.G R81.2 R85.1
DONGLE_HDMI: QN69.G QN71.G QN72.D R790.2
DONGLE_HDMI2: QN7.G QN9.G QN10.D R82.2
DONGLE_HDMI2_CT: QN10.G R85.2
DONGLE_HDMI_CT: QN72.G R793.2
DOT96_N: PCH1.AP11 R140.1
DOT96_P: PCH1.AM11 R141.1
DP2_HPD: PCH1.AH5 QN6.S
DP2_HPD_QN: C825.1 QN6.D R76.1 R79.1
DP_HPD: PCH1.AJ2 QN68.S
DP_HPD_CNN: DP2.18 R787.2 U6.4
DP_HPD_CNN2: DP1.18 R79.2 U3.4
DP_HPD_QN: C826.1 QN68.D R784.1 R787.1
DP_MOS_G: QN8.G R78.2
DP_PWR_FUSE: F1.2 QN8.S R84.1
DP_RCOMP: CPU1.R4 R1.2
DPWROK: C689.1 C690.2 PCH1.AV38 QN83.C R351.1 R761.2 U21.17
DRAM_PWROK: PCH1.AE38 SR16.2 SR22.1 SR23.1
DRAM_PWROK_RC: CPU1.AK21 SC11.1 SR16.1
DRAMRT: CPU1.AK22 R68.1
DVI_CLK_DN_C: CMK12.4 DVI-D.24 RN7.1(A) U10.5 U10.6
DVI_CLK_DP_C: CMK12.1 DVI-D.23 RN7.3(A) U10.4 U10.7
DVI_HPD: PCH1.AJ4 QN21.S R106.2
DVI_HPD_D: C116.2 QN21.D R103.2 R109.1
DVI_HPD_D_R: DVI-D.16 R103.1 U9.6
DVI_SCL: DVI-D.6 QN20.D R105.2 U9.3
DVI_SDA: DVI-D.7 QN23.D R108.2 U9.1
DVI_TX0_DN_C: CMK10.4 DVI-D.17 RN7.5(A) U10.2 U10.9
DVI_TX0_DP_C: CMK10.1 DVI-D.18 RN7.7(A) U10.1 U10.10
DVI_TX1_DN_C: CMK11.4 DVI-D.9 RN8.1(A) U8.1 U8.10
DVI_TX1_DP_C: CMK11.1 DVI-D.10 RN8.3(A) U8.2 U8.9
DVI_TX2_DN_C: CMK9.4 DVI-D.1 RN8.5(A) U8.4 U8.7
DVI_TX2_DP_C: CMK9.1 DVI-D.2 RN8.7(A) U8.5 U8.6
EECS: RLAN.44 ROM2.1
EEDI: R453.1 RLAN.47 ROM2.5
EEDO: RLAN.45 ROM2.2
EESK: RLAN.48 ROM2.6
EN1/SS1: C797.1 R924.1 U41.12
EN2/SS2: C789.1 R911.1 U41.10
EUP_SW_N1: C598.2 QN61.B R630.1
EUP_SW_N2: QN61.C R625.1 R628.2
EUP_SW_N3: C597.1 R623.1 R628.1 R631.1
EUP_SW_N4: C594.1 QSW2.G R623.2
EUP_SW_N5: C600.1 QSW3.G R631.2
EXT_ARB: R285.1 U11.92
F_PANEL_P6: F_PANEL.6 R1000.1
F_PANEL_P11: F_PANEL.11 R429.2
F_PANEL_P12: F_PANEL.12 R392.1
F_PANEL_P14: F_PANEL.14 QP3.E
FAN_CTL1: R376.1 R378.2 U21.9
FAN_CTL1_R: CPU_FAN.4 R376.2
FAN_CTL2: R370.2 R373.1 R384.1 U21.11
FAN_CTL2_OP_P1: R374.2 U22.1
FAN_CTL2_OP_P1_R: QP2.B R371.2 R374.1
FAN_CTL2_OP_P2: C407.1 R373.2 U22.2
FAN_CTL2_OP_P3: R380.1 R381.1 U22.3
FAN_TAC1: C391.1 R372.2 R377.2 U21.8
FAN_TAC1_R: CPU_FAN.3 D5.P R369.1 R372.1
FAN_TAC2: C392.1 R382.2 R383.2 U21.10
FB2_G: FB17.1 THER_HD.3
FDI_CSYNC: CPU1.D16 PCH1.L2
FDI_INT: CPU1.D18 PCH1.L3
FDI_TX_N0: CPU1.B14 PCH1.N1
FDI_TX_N1: CPU1.C13 PCH1.P2
FDI_TX_P0: CPU1.A14 PCH1.N2
FDI_TX_P1: CPU1.B13 PCH1.P3
FP_PWRBTN_L: C855.1 D40.3 R342.1 R360.1 R1000.2 U21.75
FP_RST_L: C1.1 C417.1 C821.1 D9.3 F_PANEL.7 PCH1.N36 R58.1 R390.1 SJ1.48
FP_RST_L_R: CPU1.G40 R58.2
FRAME_L: PCI.A34 R288.1 U11.71
FRONT_JD: AUDIO.2Q R499.2
FRONT_L: FB13.1 Q1.C1 R484.1 R528.1
FRONT_L1: CODEC.35 EC15.1
FRONT_L2: EC15.2 R484.2
FRONT_L_P: Q1.B1 R483.2
FRONT_LL: AUDIO.21 C535.1 D25.2 FB13.2
FRONT_R: FB14.1 Q1.C2 R485.1 R529.1
FRONT_R1: CODEC.36 EC16.1
FRONT_R2: EC16.2 R485.2
FRONT_R_P: Q1.B2 R486.2
FRONT_RR: AUDIO.24 C536.1 D25.1 FB14.2
FSET: R925.2 R936.1 U41.18
FSET_R: QD3L1.G QD3L2.G R925.1
FW_CE_N: R368.1 ROM1.1 U21.30
FW_HOLD_L: R367.1 ROM1.7
FW_SCK: R349.1 RN26.3(A) ROM1.6
FW_SCK_R: R349.2 U21.25
FW_SI: R347.1 RN26.1(A) ROM1.5
FW_SI_SH: R347.2 U21.24
FW_SMBCLK: FW_DEBUG.2 SR52.1 U21.51
FW_SMBDA: FW_DEBUG.1 SR51.1 U21.52
FW_SOUT: R365.1 RN26.7(A) U21.48
FW_SOUT_SH: R365.2 ROM1.2
FW_WP_L: RN26.5(A) ROM1.3
G1_BOOT: R825.2 U39.18
G1_BOOT_R: C739.2 R825.1
G1_LG: R822.2 U39.21
G1_UG: R813.2 U39.20
G1_UG_R: QCH1.G R813.1 R821.1
G2_BOOT: R834.2 U39.22
G2_BOOT_R: C742.2 R834.1
G2_LG: R844.2 U39.26
G2_UG: R836.2 U39.24
G2_UG_R: QCH2.G R836.1 R838.1
G3_BOOT: R841.2 U39.30
G3_BOOT_R: C750.2 R841.1
G3_LG: R870.2 U39.27
G3_UG: R860.2 U39.29
G3_UG_R: QCH3.G R860.1 R866.1
G4_BOOT: R882.2 U40.2
G4_BOOT_R: C768.2 R882.1
G4_LG: R893.2 U40.5
G4_UG: R884.2 U40.1
G4_UG_R: QCH4.G R884.1 R885.1
G4_VCC: C771.1 R883.2 U40.6 U40.7
GH1: R922.2 U41.21
GH2: SR53.2 U41.1
GL2: R910.2 U41.4
GLAN_RX_N3: PCH1.F11 R428.1 SR3.1
GLAN_RX_P3: PCH1.H11 R425.1 SR2.1
GLAN_TX_N3: PCH1.B9 R440.1 SR6.1
GLAN_TX_P3: PCH1.A9 R433.1 SR5.1
GLED0: F_PANEL.2 QN41.C R393.1
GLED1: F_PANEL.4 QN42.C R394.1
GNT0_L: PCI.A17 U11.108
GPIO8_PCH: R241.1 R245.2 R246.1 R996.1
GPIO8_PCH_B: QN29.B R246.2
GPIO8_PCH_C: QN28.B QN29.C R242.1
GPIO39_CASE: PCH1.R31 RN46.7(A) THER_HD.6
H_BPM0_L: CPU1.G39 SJ1.21
H_BPM1_L: CPU1.J39 SJ1.23
H_PRDY_L: CPU1.L39 SJ1.5
H_PREQ_L: CPU1.L37 SJ1.3
H_SKTOCC_L: CPU1.D38 QN1.G R53.1 R56.2
H_TCK: CPU1.D39 SJ1.57 SR38.2
H_TDI: CPU1.F38 R980.2 SJ1.56
H_TDO: CPU1.F39 R985.2 SJ1.52 SR32.2 SR36.2 SR37.2
H_TMS: CPU1.E39 R981.2 SJ1.58
H_TRST_L: CPU1.E37 R987.2 SJ1.54
HDA_BCLK: R207.1 R510.2
HDA_BCLK_R: C681.1 PCH1.AV23 R207.2
HDA_RST_L: R210.1 R479.2 R504.2
HDA_RST_L_R: PCH1.AU24 R210.2
HDA_SDI0: PCH1.AT26 R509.2
HDA_SDO: CODEC.5 R216.1
HDA_SDO_R: PCH1.AU22 R216.2 RJ12.2
HDA_SDO_R1: ME_DISABLE.2 RJ12.1
HDA_SDO_R_P1: ME_DISABLE.3 R244.1
HDA_SYNC: CODEC.10 R217.1
HDA_SYNC_R: PCH1.AV24 R217.2
HDD_LED_N: F_PANEL.3 QN43.C
HDD_LED_P: F_PANEL.1 R391.1
HDMI_DET: DP2.13 R795.1 R796.1
HDMI_DET2: DP1.13 R86.1 R88.1
HDMI_DET2_R: QN11.G R86.2
HDMI_DET_R: QN74.G R795.2
HDPANEL_DETECT: C722.2 D34.3 F_AUDIO.4 PCH1.AK26 R192.2
HM_5VDUAL: C374.1 R329.2 R335.1 U21.93
HM_12V: C378.1 R333.2 R337.1 U21.96
HM_VCC: C379.1 R334.2 R338.1 U21.95
HM_VCC3: C375.1 R330.2 R336.1 U21.94
HM_VCORE: C376.1 R331.2 U21.98
HM_VDIMM: C377.1 R332.2 U21.97
HSODN4: C292.1 PCIE1X.B15
HSODN5: C291.1 PCIE16X_2.B15
HSODN6: C294.1 PCIE16X_2.B20
HSODN7: C296.1 PCIE16X_2.B24
HSODN8: C298.1 PCIE16X_2.B28
HSODP4: C290.1 PCIE1X.B14
HSODP5: C289.1 PCIE16X_2.B14
HSODP6: C293.1 PCIE16X_2.B19
HSODP7: C295.1 PCIE16X_2.B23
HSODP8: C297.1 PCIE16X_2.B27
HSW_STRAP_CFG13: QN28.C R50.1
I_MDI0N: ILAN.14 R767.2
I_MDI0P: ILAN.13 R766.2
I_MDI1N: ILAN.18 R769.2
I_MDI1P: ILAN.17 R768.2
I_MDI2N: ILAN.21 R771.2
I_MDI2P: ILAN.20 R770.2
I_MDI3N: ILAN.24 R773.2
I_MDI3P: ILAN.23 R772.2
I_VCC3P3: ILAN.1 R436.1
IDSEL1: PCI.A26 R291.1
ILAN_CLK_REQ: ILAN.48 R426.1
ILAN_CLKN: ILAN.45 PCH1.AC11
ILAN_CLKP: ILAN.44 PCH1.AC10
ILAN_CTRL: ILAN.7 L1.1
ILAN_RST: R427.1 R457.2
ILAN_RST_R: C437.2 ILAN.36 R427.2
ILAN_RXN: C439.1 R428.2
ILAN_RXN_C: C439.2 ILAN.39
ILAN_RXP: C438.1 R425.2
ILAN_RXP_C: C438.2 ILAN.38
ILAN_TEST_EN: ILAN.30 R445.2
ILAN_TXN: C441.1 R440.2
ILAN_TXN_C: C441.2 ILAN.42
ILAN_TXP: C440.1 R433.2
ILAN_TXP_C: C440.2 ILAN.41
ILAN_WAKE_L: PCH1.AU34 R234.1 R435.1 R442.1
ILAN_WAKE_L_R: ILAN.2 R435.2 R443.1
INT_DNOISE: INT_SPK.7 QN46.C R517.2
INT_VIN: C527.2 C528.2 INT_SPK.8 R516.1
INTA_L: PCI.A6 R967.1 U11.65
INTB_L: PCI.B7 R972.1 U11.63
INTC_L: PCI.A7 R971.1 U11.64
INTD_L: PCI.B8 R970.1 U11.116
INTF_L: PCH1.AV29 RN12.3(A)
INTVRMEN: PCH1.AV36 R247.1 R248.1
IRDY_L: PCI.B35 R965.1 U11.70
ISEN1: C741.1 R826.2 R827.2 R830.2 R832.1 R833.2 U39.13
ISEN1_1: P1.1 R823.1 R830.1
ISEN1_2: P3.1 R845.1 R848.1
ISEN1_3: P5.1 R873.1 R876.1
ISEN1_4: P7.1 R898.1 R899.1
ISEN2: C755.1 R848.2 R852.2 R853.2 R855.1 R857.2 U39.12
ISEN3: C767.1 R876.2 R877.2 R878.2 R879.1 R880.2 U39.11
ISEN4: C775.1 R858.1 R899.2 R900.2 R901.2 R902.1 R903.2 U39.10
ISOLATEB: R458.1 R460.2 RLAN.36
ISUMN: C763.1 R872.2 U39.15
ISUMN_RC: C763.2 R874.2
ISUMP_RC: C761.2 C762.2 R875.2
JDREF: CODEC.40 R491.2
JP1: R944.1 R945.1 U21.60
JTAG_PCH_RST: PCH1.W37 R236.1
JTAG_PCH_TCK: PCH1.Y40 R558.2
JTAG_PCH_TDI: PCH1.W39 R551.2 R555.2
JTAG_PCH_TDO: PCH1.Y38 R561.2 R562.2
JTAG_PCH_TMS: PCH1.W40 R552.2 R554.2
K2_PCH: PCH1.K2 R153.2
KB_CLK: FB8.1 RN27.6(B) U21.81
KB_DATA: FB7.1 RN27.8(B) U21.80
KBCLK: C414.2 FB8.2 PSKM.5
KBDATA: C415.2 FB7.2 PSKM.1
KBRST_L: R738.2 U21.45
KBRST_L_R: C679.1 PCH1.K36 R738.1 RN15.3(A)
LAN_3P3_N1: QN63.C R633.1 R637.1 R638.2 R650.2
LAN_3P3_N2: QN62.B R638.1
LAN_3P3_N3: QN63.B R641.1
LAN_3P3_N4: QN64.B R644.1
LAN_3P3_N5: QN63.E QN64.C
LAN_3P3_N6: QN62.C R632.1 R636.2
LAN_3P3_N7: QN66.B R650.1
LAN_3P3_N8: QN66.C R647.1 R648.1 R649.2
LAN_3P3_N9: QN66.E QN67.C R652.1 R654.2
LAN_3P3_N10: C612.1 QN67.B R653.1
LAN_3P3_N11: C609.1 Q7.3 R634.1 R635.1
LAN_CLKREQ_L: R459.1 RLAN.33
LAN_DIS_L: PCH1.AL40 R437.1
LAN_DIS_L_R: ILAN.3 R437.2 R438.2 R444.2
LAN_JTCK: ILAN.35 R448.1
LAN_JTDI: ILAN.32 TP21.1
LAN_JTDO: ILAN.34 STP19.1
LAN_JTMS: ILAN.33 R447.1
LAN_XTAL1: ILAN.9 R737.2
LAN_XTAL1_R: C445.2 R737.1 X2.2
LAN_XTAL2: C446.2 ILAN.10 X2.1
LAN_XTL1: C448.1 RLAN.60 X3.2
LAN_XTL2: C449.1 RLAN.61 X3.1
LANDUAL_NCH: C605.1 Q7.2 R636.1
LANDUAL_PCH: C611.1 Q7.4 R649.1
LDO2_ENR: R905.1 R906.2 U41.24
LDO2_OC: C778.2 U41.23
LDO_18: C324.1 C325.1 C326.1 PFB6.2 PFB7.2 U11.59
LDOAUX_18: C335.1 C336.1 C337.1 PFB4.2 PFB5.2 U11.5
LED0: ILAN.26 QP3.B R466.2 RLAN.57
LED1: ILAN.27 R465.2 RLAN.56
LED2: ILAN.25 R464.2 RLAN.54
LGATE1: QCL1.G QCL5.G R822.1
LGATE2: QCL2.G QCL6.G R844.1
LGATE3: QCL3.G QCL7.G R870.1
LGATE4: QCL4.G QCL8.G R893.1
LINE1_JD: AUDIO.3Q R500.2
LINE1_L: Q2.C1 R489.2 SFB2.1 SR46.1
LINE1_L1: C512.2 CODEC.23
LINE1_L2: C512.1 R489.1
LINE1_L_P: Q2.B1 R487.2
LINE1_LL: AUDIO.31 SC45.1 SD2.2 SFB2.2
LINE1_R: Q2.C2 R488.2 SFB1.1 SR45.1
LINE1_R1: C514.2 CODEC.24
LINE1_R2: C514.1 R488.1
LINE1_R_P: Q2.B2 R493.2
LINE1_RR: AUDIO.34 SC44.1 SD2.1 SFB1.2
LINE2_JD: F_AUDIO.10 R481.1
LINE2_L: C531.2 D27.2 F_AUDIO.9 Q4.C1 R498.2 R526.1
LINE2_L1: CODEC.14 EC18.1
LINE2_L2: EC18.2 R498.1
LINE2_L_P: Q4.B1 R503.2
LINE2_R: C532.2 D27.1 F_AUDIO.5 Q4.C2 R497.2 R525.1
LINE2_R1: CODEC.15 EC17.1
LINE2_R2: EC17.2 R497.1
LINE2_R_P: Q4.B2 R507.2
LOCK_L: PCI.B39 R973.1 U11.62
LPC_DRQ0_L: PCH1.AK22 R194.2 U21.5
LPC_FRAME_L: PCH1.AP24 TPM.3 U21.40 U23.22
LPC_LAD0: PCH1.AN24 TPM.11 U21.41 U23.26
LPC_LAD1: PCH1.AP26 TPM.10 U21.42 U23.23
LPC_LAD2: PCH1.AJ24 TPM.8 U21.43 U23.20
LPC_LAD3: PCH1.AN26 TPM.7 U21.44 U23.17
LPC_PME_L: PCH1.AN22 R355.1 U21.73
LPCPD_L: PCH1.AD37 R405.1 R416.2
LPCPDL: R403.1 R405.2 U23.28
LPT_ACK_L: CN1.2(B) LPT.10 RN29.5(A) U21.107
LPT_AFD_L: RN30.5(A) U21.111
LPT_BUSY: CN1.4(B) LPT.11 RN29.3(A) U21.106
LPT_D0: RN30.3(A) U21.113
LPT_D1: RN30.1(A) U21.114
LPT_D2: RN34.5(A) U21.115
LPT_D3: RN34.1(A) U21.116
LPT_D4: RN31.7(A) U21.117
LPT_D5: RN31.5(A) U21.118
LPT_D6: RN31.3(A) U21.119
LPT_D7: RN31.1(A) U21.120
LPT_ERR_L: CN4.8(B) LPT.15 RN35.1(A) U21.110
LPT_INIT_L: RN34.7(A) U21.109
LPT_PE: CN1.6(B) LPT.12 RN29.1(A) U21.105
LPT_SLCT: CN1.8(B) LPT.13 R402.1 U21.104
LPT_SLIN_L: RN34.3(A) U21.108
LPT_STB_L: RN30.7(A) U21.112
LPTVCC: C418.1 D11.N R402.2 RN29.2(B) RN29.4(B) RN29.6(B) RN29.8(B) RN32.2(B) RN32.4(B) RN32.6(B) RN32.8(B) RN33.2(B) RN33.4(B) RN33.6(B) RN33.8(B) RN35.2(B) RN35.4(B) RN35.6(B) RN35.8(B)
LRST_L: C393.1 R358.2 U21.49
M_BS_A0: CPU1.AV12 DIMM2.71 DIMM4.71
M_BS_A1: CPU1.AY11 DIMM2.190 DIMM4.190
M_BS_A2: CPU1.AT21 DIMM2.52 DIMM4.52
M_BS_B0: CPU1.AK17 DIMM1.71 DIMM3.71
M_BS_B1: CPU1.AL18 DIMM1.190 DIMM3.190
M_BS_B2: CPU1.AW28 DIMM1.52 DIMM3.52
M_CAS_A_L: CPU1.AU9 DIMM2.74 DIMM4.74
M_CAS_B_L: CPU1.AP16 DIMM1.74 DIMM3.74
M_CKE_A0: CPU1.AV22 DIMM4.50
M_CKE_A1: CPU1.AT23 DIMM4.169
M_CKE_A2: CPU1.AU22 DIMM2.50
M_CKE_A3: CPU1.AU23 DIMM2.169
M_CKE_B0: CPU1.AW29 DIMM3.50
M_CKE_B1: CPU1.AY29 DIMM3.169
M_CKE_B2: CPU1.AU28 DIMM1.50
M_CKE_B3: CPU1.AU29 DIMM1.169
M_CLK_A_N0: CPU1.AY16 DIMM4.185
M_CLK_A_N1: CPU1.AV15 DIMM4.64
M_CLK_A_N2: CPU1.AW14 DIMM2.185
M_CLK_A_N3: CPU1.AY13 DIMM2.64
M_CLK_A_P0: CPU1.AY15 DIMM4.184
M_CLK_A_P1: CPU1.AW15 DIMM4.63
M_CLK_A_P2: CPU1.AV14 DIMM2.184
M_CLK_A_P3: CPU1.AW13 DIMM2.63
M_CLK_B_N0: CPU1.AM21 DIMM3.185
M_CLK_B_N1: CPU1.AP21 DIMM3.64
M_CLK_B_N2: CPU1.AN21 DIMM1.185
M_CLK_B_N3: CPU1.AP20 DIMM1.64
M_CLK_B_P0: CPU1.AM20 DIMM3.184
M_CLK_B_P1: CPU1.AP22 DIMM3.63
M_CLK_B_P2: CPU1.AN20 DIMM1.184
M_CLK_B_P3: CPU1.AP19 DIMM1.63
M_CS_A_L0: CPU1.AU14 DIMM4.193
M_CS_A_L1: CPU1.AV9 DIMM4.76
M_CS_A_L2: CPU1.AU10 DIMM2.193
M_CS_A_L3: CPU1.AW8 DIMM2.76
M_CS_B_L0: CPU1.AP17 DIMM3.193
M_CS_B_L1: CPU1.AN15 DIMM3.76
M_CS_B_L2: CPU1.AN17 DIMM1.193
M_CS_B_L3: CPU1.AL15 DIMM1.76
M_DATA_A0: CPU1.AD38 DIMM2.3 DIMM4.3
M_DATA_A1: CPU1.AD39 DIMM2.4 DIMM4.4
M_DATA_A2: CPU1.AF38 DIMM2.9 DIMM4.9
M_DATA_A3: CPU1.AF39 DIMM2.10 DIMM4.10
M_DATA_A4: CPU1.AD37 DIMM2.122 DIMM4.122
M_DATA_A5: CPU1.AD40 DIMM2.123 DIMM4.123
M_DATA_A6: CPU1.AF37 DIMM2.128 DIMM4.128
M_DATA_A7: CPU1.AF40 DIMM2.129 DIMM4.129
M_DATA_A8: CPU1.AH38 DIMM2.12 DIMM4.12
M_DATA_A9: CPU1.AH40 DIMM2.13 DIMM4.13
M_DATA_A10: CPU1.AK38 DIMM2.18 DIMM4.18
M_DATA_A11: CPU1.AK39 DIMM2.19 DIMM4.19
M_DATA_A12: CPU1.AH37 DIMM2.131 DIMM4.131
M_DATA_A13: CPU1.AH39 DIMM2.132 DIMM4.132
M_DATA_A14: CPU1.AK37 DIMM2.137 DIMM4.137
M_DATA_A15: CPU1.AK40 DIMM2.138 DIMM4.138
M_DATA_A16: CPU1.AM38 DIMM2.21 DIMM4.21
M_DATA_A17: CPU1.AM40 DIMM2.22 DIMM4.22
M_DATA_A18: CPU1.AP38 DIMM2.27 DIMM4.27
M_DATA_A19: CPU1.AP39 DIMM2.28 DIMM4.28
M_DATA_A20: CPU1.AM37 DIMM2.140 DIMM4.140
M_DATA_A21: CPU1.AM39 DIMM2.141 DIMM4.141
M_DATA_A22: CPU1.AP37 DIMM2.146 DIMM4.146
M_DATA_A23: CPU1.AP40 DIMM2.147 DIMM4.147
M_DATA_A24: CPU1.AU37 DIMM2.30 DIMM4.30
M_DATA_A25: CPU1.AV37 DIMM2.31 DIMM4.31
M_DATA_A26: CPU1.AU35 DIMM2.36 DIMM4.36
M_DATA_A27: CPU1.AV35 DIMM2.37 DIMM4.37
M_DATA_A28: CPU1.AT37 DIMM2.149 DIMM4.149
M_DATA_A29: CPU1.AW37 DIMM2.150 DIMM4.150
M_DATA_A30: CPU1.AT35 DIMM2.155 DIMM4.155
M_DATA_A31: CPU1.AW35 DIMM2.156 DIMM4.156
M_DATA_A32: CPU1.AV6 DIMM2.81 DIMM4.81
M_DATA_A33: CPU1.AY6 DIMM2.82 DIMM4.82
M_DATA_A34: CPU1.AV4 DIMM2.87 DIMM4.87
M_DATA_A35: CPU1.AU4 DIMM2.88 DIMM4.88
M_DATA_A36: CPU1.AW6 DIMM2.200 DIMM4.200
M_DATA_A37: CPU1.AU6 DIMM2.201 DIMM4.201
M_DATA_A38: CPU1.AW4 DIMM2.206 DIMM4.206
M_DATA_A39: CPU1.AY4 DIMM2.207 DIMM4.207
M_DATA_A40: CPU1.AR3 DIMM2.90 DIMM4.90
M_DATA_A41: CPU1.AR1 DIMM2.91 DIMM4.91
M_DATA_A42: CPU1.AN3 DIMM2.96 DIMM4.96
M_DATA_A43: CPU1.AN4 DIMM2.97 DIMM4.97
M_DATA_A44: CPU1.AR2 DIMM2.209 DIMM4.209
M_DATA_A45: CPU1.AR4 DIMM2.210 DIMM4.210
M_DATA_A46: CPU1.AN2 DIMM2.215 DIMM4.215
M_DATA_A47: CPU1.AN1 DIMM2.216 DIMM4.216
M_DATA_A48: CPU1.AL3 DIMM2.99 DIMM4.99
M_DATA_A49: CPU1.AL1 DIMM2.100 DIMM4.100
M_DATA_A50: CPU1.AJ3 DIMM2.105 DIMM4.105
M_DATA_A51: CPU1.AJ4 DIMM2.106 DIMM4.106
M_DATA_A52: CPU1.AL2 DIMM2.218 DIMM4.218
M_DATA_A53: CPU1.AL4 DIMM2.219 DIMM4.219
M_DATA_A54: CPU1.AJ2 DIMM2.224 DIMM4.224
M_DATA_A55: CPU1.AJ1 DIMM2.225 DIMM4.225
M_DATA_A56: CPU1.AG3 DIMM2.108 DIMM4.108
M_DATA_A57: CPU1.AG1 DIMM2.109 DIMM4.109
M_DATA_A58: CPU1.AE3 DIMM2.114 DIMM4.114
M_DATA_A59: CPU1.AE4 DIMM2.115 DIMM4.115
M_DATA_A60: CPU1.AG2 DIMM2.227 DIMM4.227
M_DATA_A61: CPU1.AG4 DIMM2.228 DIMM4.228
M_DATA_A62: CPU1.AE2 DIMM2.233 DIMM4.233
M_DATA_A63: CPU1.AE1 DIMM2.234 DIMM4.234
M_DATA_B0: CPU1.AE34 DIMM1.3 DIMM3.3
M_DATA_B1: CPU1.AE35 DIMM1.4 DIMM3.4
M_DATA_B2: CPU1.AG35 DIMM1.9 DIMM3.9
M_DATA_B3: CPU1.AH35 DIMM1.10 DIMM3.10
M_DATA_B4: CPU1.AD34 DIMM1.122 DIMM3.122
M_DATA_B5: CPU1.AD35 DIMM1.123 DIMM3.123
M_DATA_B6: CPU1.AG34 DIMM1.128 DIMM3.128
M_DATA_B7: CPU1.AH34 DIMM1.129 DIMM3.129
M_DATA_B8: CPU1.AL34 DIMM1.12 DIMM3.12
M_DATA_B9: CPU1.AL35 DIMM1.13 DIMM3.13
M_DATA_B10: CPU1.AK31 DIMM1.18 DIMM3.18
M_DATA_B11: CPU1.AL31 DIMM1.19 DIMM3.19
M_DATA_B12: CPU1.AK34 DIMM1.131 DIMM3.131
M_DATA_B13: CPU1.AK35 DIMM1.132 DIMM3.132
M_DATA_B14: CPU1.AK32 DIMM1.137 DIMM3.137
M_DATA_B15: CPU1.AL32 DIMM1.138 DIMM3.138
M_DATA_B16: CPU1.AP35 DIMM1.21 DIMM3.21
M_DATA_B17: CPU1.AN34 DIMM1.22 DIMM3.22
M_DATA_B18: CPU1.AN32 DIMM1.27 DIMM3.27
M_DATA_B19: CPU1.AN31 DIMM1.28 DIMM3.28
M_DATA_B20: CPU1.AN35 DIMM1.140 DIMM3.140
M_DATA_B21: CPU1.AP34 DIMM1.141 DIMM3.141
M_DATA_B22: CPU1.AP32 DIMM1.146 DIMM3.146
M_DATA_B23: CPU1.AP31 DIMM1.147 DIMM3.147
M_DATA_B24: CPU1.AL29 DIMM1.30 DIMM3.30
M_DATA_B25: CPU1.AM29 DIMM1.31 DIMM3.31
M_DATA_B26: CPU1.AP29 DIMM1.36 DIMM3.36
M_DATA_B27: CPU1.AR29 DIMM1.37 DIMM3.37
M_DATA_B28: CPU1.AM28 DIMM1.149 DIMM3.149
M_DATA_B29: CPU1.AL28 DIMM1.150 DIMM3.150
M_DATA_B30: CPU1.AR28 DIMM1.155 DIMM3.155
M_DATA_B31: CPU1.AP28 DIMM1.156 DIMM3.156
M_DATA_B32: CPU1.AR12 DIMM1.81 DIMM3.81
M_DATA_B33: CPU1.AP12 DIMM1.82 DIMM3.82
M_DATA_B34: CPU1.AL13 DIMM1.87 DIMM3.87
M_DATA_B35: CPU1.AL12 DIMM1.88 DIMM3.88
M_DATA_B36: CPU1.AR13 DIMM1.200 DIMM3.200
M_DATA_B37: CPU1.AP13 DIMM1.201 DIMM3.201
M_DATA_B38: CPU1.AM13 DIMM1.206 DIMM3.206
M_DATA_B39: CPU1.AM12 DIMM1.207 DIMM3.207
M_DATA_B40: CPU1.AP10 DIMM1.90 DIMM3.90
M_DATA_B41: CPU1.AP9 DIMM1.91 DIMM3.91
M_DATA_B42: CPU1.AP7 DIMM1.96 DIMM3.96
M_DATA_B43: CPU1.AP6 DIMM1.97 DIMM3.97
M_DATA_B44: CPU1.AR10 DIMM1.209 DIMM3.209
M_DATA_B45: CPU1.AR9 DIMM1.210 DIMM3.210
M_DATA_B46: CPU1.AR7 DIMM1.215 DIMM3.215
M_DATA_B47: CPU1.AR6 DIMM1.216 DIMM3.216
M_DATA_B48: CPU1.AM10 DIMM1.99 DIMM3.99
M_DATA_B49: CPU1.AL10 DIMM1.100 DIMM3.100
M_DATA_B50: CPU1.AL6 DIMM1.105 DIMM3.105
M_DATA_B51: CPU1.AM7 DIMM1.106 DIMM3.106
M_DATA_B52: CPU1.AM9 DIMM1.218 DIMM3.218
M_DATA_B53: CPU1.AL9 DIMM1.219 DIMM3.219
M_DATA_B54: CPU1.AM6 DIMM1.224 DIMM3.224
M_DATA_B55: CPU1.AL7 DIMM1.225 DIMM3.225
M_DATA_B56: CPU1.AJ6 DIMM1.108 DIMM3.108
M_DATA_B57: CPU1.AJ7 DIMM1.109 DIMM3.109
M_DATA_B58: CPU1.AF6 DIMM1.114 DIMM3.114
M_DATA_B59: CPU1.AE6 DIMM1.115 DIMM3.115
M_DATA_B60: CPU1.AH7 DIMM1.227 DIMM3.227
M_DATA_B61: CPU1.AH6 DIMM1.228 DIMM3.228
M_DATA_B62: CPU1.AF7 DIMM1.233 DIMM3.233
M_DATA_B63: CPU1.AE7 DIMM1.234 DIMM3.234
M_DQS_A_N0: CPU1.AE38 DIMM2.6 DIMM4.6
M_DQS_A_N1: CPU1.AJ38 DIMM2.15 DIMM4.15
M_DQS_A_N2: CPU1.AN38 DIMM2.24 DIMM4.24
M_DQS_A_N3: CPU1.AU36 DIMM2.33 DIMM4.33
M_DQS_A_N4: CPU1.AW5 DIMM2.84 DIMM4.84
M_DQS_A_N5: CPU1.AP2 DIMM2.93 DIMM4.93
M_DQS_A_N6: CPU1.AK2 DIMM2.102 DIMM4.102
M_DQS_A_N7: CPU1.AF2 DIMM2.111 DIMM4.111
M_DQS_A_P0: CPU1.AE39 DIMM2.7 DIMM4.7
M_DQS_A_P1: CPU1.AJ39 DIMM2.16 DIMM4.16
M_DQS_A_P2: CPU1.AN39 DIMM2.25 DIMM4.25
M_DQS_A_P3: CPU1.AV36 DIMM2.34 DIMM4.34
M_DQS_A_P4: CPU1.AV5 DIMM2.85 DIMM4.85
M_DQS_A_P5: CPU1.AP3 DIMM2.94 DIMM4.94
M_DQS_A_P6: CPU1.AK3 DIMM2.103 DIMM4.103
M_DQS_A_P7: CPU1.AF3 DIMM2.112 DIMM4.112
M_DQS_B_N0: CPU1.AF34 DIMM1.6 DIMM3.6
M_DQS_B_N1: CPU1.AK33 DIMM1.15 DIMM3.15
M_DQS_B_N2: CPU1.AN33 DIMM1.24 DIMM3.24
M_DQS_B_N3: CPU1.AN29 DIMM1.33 DIMM3.33
M_DQS_B_N4: CPU1.AN13 DIMM1.84 DIMM3.84
M_DQS_B_N5: CPU1.AR8 DIMM1.93 DIMM3.93
M_DQS_B_N6: CPU1.AM8 DIMM1.102 DIMM3.102
M_DQS_B_N7: CPU1.AG6 DIMM1.111 DIMM3.111
M_DQS_B_P0: CPU1.AF35 DIMM1.7 DIMM3.7
M_DQS_B_P1: CPU1.AL33 DIMM1.16 DIMM3.16
M_DQS_B_P2: CPU1.AP33 DIMM1.25 DIMM3.25
M_DQS_B_P3: CPU1.AN28 DIMM1.34 DIMM3.34
M_DQS_B_P4: CPU1.AN12 DIMM1.85 DIMM3.85
M_DQS_B_P5: CPU1.AP8 DIMM1.94 DIMM3.94
M_DQS_B_P6: CPU1.AL8 DIMM1.103 DIMM3.103
M_DQS_B_P7: CPU1.AG7 DIMM1.112 DIMM3.112
M_MA_A0: CPU1.AU13 DIMM2.188 DIMM4.188
M_MA_A1: CPU1.AV16 DIMM2.181 DIMM4.181
M_MA_A2: CPU1.AU16 DIMM2.61 DIMM4.61
M_MA_A3: CPU1.AW17 DIMM2.180 DIMM4.180
M_MA_A4: CPU1.AU17 DIMM2.59 DIMM4.59
M_MA_A5: CPU1.AW18 DIMM2.58 DIMM4.58
M_MA_A6: CPU1.AV17 DIMM2.178 DIMM4.178
M_MA_A7: CPU1.AT18 DIMM2.56 DIMM4.56
M_MA_A8: CPU1.AU18 DIMM2.177 DIMM4.177
M_MA_A9: CPU1.AT19 DIMM2.175 DIMM4.175
M_MA_A10: CPU1.AW11 DIMM2.70 DIMM4.70
M_MA_A11: CPU1.AV19 DIMM2.55 DIMM4.55
M_MA_A12: CPU1.AU19 DIMM2.174 DIMM4.174
M_MA_A13: CPU1.AY10 DIMM2.196 DIMM4.196
M_MA_A14: CPU1.AT20 DIMM2.172 DIMM4.172
M_MA_A15: CPU1.AU21 DIMM2.171 DIMM4.171
M_MA_B0: CPU1.AL19 DIMM1.188 DIMM3.188
M_MA_B1: CPU1.AK23 DIMM1.181 DIMM3.181
M_MA_B2: CPU1.AM22 DIMM1.61 DIMM3.61
M_MA_B3: CPU1.AM23 DIMM1.180 DIMM3.180
M_MA_B4: CPU1.AP23 DIMM1.59 DIMM3.59
M_MA_B5: CPU1.AL23 DIMM1.58 DIMM3.58
M_MA_B6: CPU1.AY24 DIMM1.178 DIMM3.178
M_MA_B7: CPU1.AV25 DIMM1.56 DIMM3.56
M_MA_B8: CPU1.AU26 DIMM1.177 DIMM3.177
M_MA_B9: CPU1.AW25 DIMM1.175 DIMM3.175
M_MA_B10: CPU1.AP18 DIMM1.70 DIMM3.70
M_MA_B11: CPU1.AY25 DIMM1.55 DIMM3.55
M_MA_B12: CPU1.AV26 DIMM1.174 DIMM3.174
M_MA_B13: CPU1.AR15 DIMM1.196 DIMM3.196
M_MA_B14: CPU1.AV27 DIMM1.172 DIMM3.172
M_MA_B15: CPU1.AY28 DIMM1.171 DIMM3.171
M_ODT_A0: CPU1.AW10 DIMM4.195
M_ODT_A1: CPU1.AY8 DIMM4.77
M_ODT_A2: CPU1.AW9 DIMM2.195
M_ODT_A3: CPU1.AU8 DIMM2.77
M_ODT_B0: CPU1.AM17 DIMM3.195
M_ODT_B1: CPU1.AL16 DIMM3.77
M_ODT_B2: CPU1.AM16 DIMM1.195
M_ODT_B3: CPU1.AK15 DIMM1.77
M_RAS_A_L: CPU1.AU12 DIMM2.192 DIMM4.192
M_RAS_B_L: CPU1.AM18 DIMM1.192 DIMM3.192
M_WE_A_L: CPU1.AU11 DIMM2.73 DIMM4.73
M_WE_B_L: CPU1.AK16 DIMM1.73 DIMM3.73
MDI0N: R767.1 SC2.1 SR7.1 SU1.3 USB3_LAN.21
MDI0P: R766.1 SC1.1 SR8.1 SU1.4 USB3_LAN.20
MDI1N: R769.1 SC4.1 SR9.1 SU1.1 USB3_LAN.23
MDI1P: R768.1 SC3.1 SR10.1 SU1.6 USB3_LAN.22
MDI2N: R771.1 SC6.1 SR11.1 SU2.1 USB3_LAN.25
MDI2P: R770.1 SC5.1 SR12.1 SU2.6 USB3_LAN.24
MDI3N: R773.1 SC8.1 SR13.1 SU2.3 USB3_LAN.27
MDI3P: R772.1 SC7.1 SR14.1 SU2.4 USB3_LAN.26
ME_1P05_N1: QN60.B R614.1 R621.2
ME_1P05_N2: QN60.C R615.1 R617.2
ME_1P05_N3: C583.2 QP8.B R617.1
ME_1P05_N4: C592.1 R618.1
ME_EN: QP8.C R619.2 U33.1
MIC1_JD: AUDIO.1Q R502.2
MIC1_L: FB15.1 Q3.C1 R477.2 R492.2 R530.1
MIC1_L1: C516.2 CODEC.21
MIC1_L2: C516.1 R492.1
MIC1_L_P: Q3.B1 R496.2
MIC1_LL: AUDIO.11 C537.1 D24.2 FB15.2
MIC1_R: FB16.1 Q3.C2 R475.2 R490.2 R531.1
MIC1_R1: C515.2 CODEC.22
MIC1_R2: C515.1 R490.1
MIC1_R_P: Q3.B2 R501.2
MIC1_RR: AUDIO.14 C538.1 D24.1 FB16.2
MIC1_VREFO-L: CODEC.28 R477.1
MIC1_VREFO-R: CODEC.32 R475.1
MIC2-VREFO: CODEC.30 D18.3
MIC2-VREFO_L: D18.2 R473.1
MIC2-VREFO_R: D18.1 R472.1
MIC2_JD: F_AUDIO.6 R482.1
MIC2_L: C534.2 D28.2 F_AUDIO.1 Q5.C1 R473.2 R495.2 R524.1
MIC2_L1: C519.1 CODEC.16
MIC2_L2: C519.2 R495.1
MIC2_L_P: Q5.B1 R511.2
MIC2_R: C533.2 D28.1 F_AUDIO.3 Q5.C2 R472.2 R494.2 R523.1
MIC2_R1: C518.1 CODEC.17
MIC2_R2: C518.2 R494.1
MIC2_R_P: Q5.B2 R513.2
MONO_L: C513.1 INT_SPK.1 Q6.C1 R514.1
MONO_L_C: C513.2 CODEC.39
MONO_L_P: Q6.B1 R515.2
MONO_R: C517.1 INT_SPK.3 Q6.C2 R519.1
MONO_R_C: C517.2 CODEC.41
MONO_R_P: Q6.B2 R520.2
MS_CLK: FB10.1 RN27.2(B) U21.83
MS_DATA: FB9.1 RN27.4(B) U21.82
MSCLK: C412.2 FB10.2 PSKM.11
MSDATA: C413.2 FB9.2 PSKM.7
NAFD_L: CN4.2(B) LPT.14 RN30.6(B) RN35.7(A)
NPINIT_L: CN2.2(B) LPT.16 RN33.7(A) RN34.8(B)
NPRD0: CN4.4(B) LPT.2 RN30.4(B) RN35.5(A)
NPRD1: CN4.6(B) LPT.3 RN30.2(B) RN35.3(A)
NPRD2: CN2.4(B) LPT.4 RN33.5(A) RN34.6(B)
NPRD3: CN2.8(B) LPT.5 RN33.1(A) RN34.2(B)
NPRD4: CN3.2(B) LPT.6 RN31.8(B) RN32.7(A)
NPRD5: CN3.4(B) LPT.7 RN31.6(B) RN32.5(A)
NPRD6: CN3.6(B) LPT.8 RN31.4(B) RN32.3(A)
NPRD7: CN3.8(B) LPT.9 RN31.2(B) RN32.1(A)
NSLIN_L: CN2.6(B) LPT.17 RN33.3(A) RN34.4(B)
NSTB_L: C419.2 LPT.1 RN29.7(A) RN30.8(B)
P2BOOT: R567.1 U31.1
P2BTX: C552.1 D21.3 R567.2
P2COM: C553.1 R570.1 U31.7
P2COMR: C557.1 R570.2
P2FB: C559.1 R577.1 R578.1 U31.6
P2FB_C: C559.2 R579.1
P2FB_R: R576.1 R577.2 R579.2
P2LG: R572.2 R574.1 U31.4
P2LGR: QML1.G QML2.G R572.1
P2PHASE: C552.2 L4.1 QMH1.S1 QMH1.S2 QMH1.S3 QML1.D1 QML1.D2 QML1.D3 QML1.D4 QML1.D5 QML2.D1 QML2.D2 QML2.D3 QML2.D4 QML2.D5 R571.1 R573.2 U31.8
P2SNX: C558.1 R573.1
P2UG: R569.2 U31.2
P2UGR: QMH1.G R569.1 R571.2
P_PWOK_R: CPU1.Y7 SR18.1 SR19.1
PACK64_1_L: PCI.B60 R292.2
PAR: PCI.A43 U11.61
PC_BEEP: CODEC.12 TP23.1
PCH_1P05_N1: C576.1 QN54.B R595.1 R598.1 R600.2
PCH_1P5_N1: QN57.B R609.1
PCH_1P5_N2: QN59.B R612.1
PCH_1P05_N2: QN53.B QN54.C R593.1
PCH_1P5_N3: QN57.C R606.1 R607.2 R613.2
PCH_1P05_N4: C574.2 C829.1 QN52.G R592.1 R777.2 R960.1 U32.1
PCH_1P5_N4: QN56.D R604.2
PCH_1P5_N5: QN58.D R610.1
PCH_1P05_N5: C830.2 R960.2
PCH_1P5_N8: C580.1 C832.2 QN55.G R603.1 R778.2 R961.1 U32.7
PCH_1P5_N9: QN56.G R607.1
PCH_1P5_N10: QN58.G R613.1
PCH_1P5_N11: QN57.E QN59.C
PCH_1P5_N12: C833.2 R961.2
PCH_AE30: PCH1.AE30 STP16.1
PCH_AF2: PCH1.AF2 R257.1
PCH_AF2_R: C252.1 PFB1.1 R257.2
PCH_AF5: PCH1.AF5 R147.2
PCH_AH28: PCH1.AH28 SC34.1
PCH_AJ22: PCH1.AJ22 STP15.1
PCH_AU40: PCH1.AU40 PCH1.AU41 R259.2
PCH_AU40_R: C283.1 R259.1
PCH_AW35: C287.1 PCH1.AW35
PCH_B19: PCH1.B19 R129.2
PCH_C13: PCH1.C13 R130.2
PCH_DSWODVREN: PCH1.AM41 R233.2
PCH_F22: PCH1.F22 R132.2
PCH_G22: PCH1.G22 R131.2
PCH_GPIO0: PCH1.G38 R193.1
PCH_GPIO1: C225.1 OBR.1 PCH1.AT31 R180.1
PCH_GPIO2: PCH1.AR30 RN12.1(A)
PCH_GPIO4: PCH1.AV28 RN12.7(A)
PCH_GPIO5: PCH1.AT27 RN11.3(A)
PCH_GPIO8: PCH1.AC40 R203.1 R245.1
PCH_GPIO15: D23.2 PCH1.AC32 R205.1
PCH_GPIO16: PCH1.M39 R168.1 R169.1
PCH_GPIO18: PCH1.P39 R201.1
PCH_GPIO19: PCH1.J40 R173.1 R179.1
PCH_GPIO20: PCH1.P37 R206.1 R209.1
PCH_GPIO21: PCH1.M37 R167.1
PCH_GPIO24: PCH1.AE34 R208.1 R997.1 R999.2
PCH_GPIO24_DIS_ME: QN35.E RJ12.3
PCH_GPIO25: PCH1.AA39 R218.1
PCH_GPIO26: PCH1.W35 R219.1
PCH_GPIO28: PCH1.V41 R211.1
PCH_GPIO31: PCH1.AM36 R231.1
PCH_GPIO32: PCH1.N32 R195.1
PCH_GPIO33: PCH1.AV26 R196.1 R199.1
PCH_GPIO34: PCH1.N34 R202.1
PCH_GPIO35: PCH1.M40 R133.1
PCH_GPIO36: PCH1.H40 R170.1 R174.1
PCH_GPIO37: PCH1.N41 R171.1 R175.1
PCH_GPIO40: PCH1.AF37 RJ3.3 RN13.8(B)
PCH_GPIO44: PCH1.AA36 R239.1 R240.1
PCH_GPIO45: PCH1.W32 R197.1 SQP1.B SR48.1
PCH_GPIO46: PCH1.AA40 R215.1 R220.1
PCH_GPIO49: PCH1.N40 R172.1 R176.1
PCH_GPIO50: PCH1.AH26 SR57.1
PCH_GPIO51: PCH1.AU31 R177.1 R178.1
PCH_GPIO52: PCH1.AJ26 SR58.1
PCH_GPIO53: PCH1.AV31 R137.1
PCH_GPIO54: PCH1.AW33 R136.1
PCH_GPIO55: PCH1.R30 R139.1
PCH_GPIO57: BIOS_WP.2 PCH1.AC36 R191.1
PCH_GPIO72: PCH1.AJ40 R237.1 R238.1 RJ3.1
PCH_GPIO73: D8.1 D8.2 PCH1.W34 R213.1 R963.1
PCH_INTRUDER_L: PCH1.AR41 R229.2
PCH_MEPWROK: C226.1 QN24.C QN25.C R184.1 R186.1
PCH_MEPWROK_R: PCH1.AA32 R186.2 R190.2
PCH_P19: PCH1.P19 STP17.1
PCH_PCI_CLK2_FB: C195.1 PCH1.AU2 R152.2
PCH_PECI: C224.1 PCH1.G40 R24.2
PCH_PLTRST_L: PCH1.AA37 R275.1 R358.1 R457.1 SR59.1
PCH_PLTRST_L_R: C334.2 R275.2 U11.117
PCH_PW_AB1: C255.1 C256.1 PCH1.AB1 R760.2
PCH_PW_AB1_FB: PFB2.2 R760.1
PCH_PWROK: C395.1 QN1.D R190.1 R200.1 R741.1 SR18.2 U21.32
PCH_RI_L: C435.1 PCH1.AE36 QN45.C R224.1
PCH_RTCX1: C239.1 PCH1.AN40 R249.1 Y1.1
PCH_RTCX2: C242.1 PCH1.AN39 R249.2 Y1.2
PCH_SIO_33M: C194.1 PCH1.AV7 R151.2
PCH_SIO_48M: C197.1 PCH1.AU8 R155.2
PCH_SPI_CLK: PCH1.U39 R221.2
PCH_SPKR: PCH1.R32 R243.1 R387.1
PCH_SYSPWROK: C241.1 PCH1.W31 R253.1 R255.1 R256.2 R989.1
PCH_TACH6: PCH1.AK28 R156.2 R160.2
PCH_TACH7: PCH1.AT34 R158.2 R161.2
PCH_TCM_33M: C193.1 PCH1.AV5 R148.2
PCH_THERMTRIP_L: PCH1.C40 R40.2 R42.1
PCH_TPM_33M: C196.1 PCH1.AU5 R154.2
PCH_VGA_HSYNC: PCH1.AH3 R142.2
PCH_VGA_VSYNC: PCH1.AH2 R143.2
PCI_+VCC_+VCC3_FB: PFB10.1 PFB11.2 R287.2 R288.2 R965.2 R966.2 R967.2 R968.2 R969.2 R970.2 R971.2 R972.2 R973.2 R974.2 R975.2 R976.2 R977.2
PCI_CLK2_FB: PCH1.AM22 R152.1 SC17.1
PCICLK0: C345.1 R289.1 U11.104
PCICLK0_R: C347.2 PCI.B16 R289.2
PCICLK_SEL: RJ2.2 U11.126
PCIE_WAKE_L: PCH1.AK34 PCIE1X.B11 PCIE16X_1.B11 PCIE16X_2.B11 R225.1
PCIRST1_L: R270.2 R271.2 U21.33
PCIRST2_L: R408.1 R412.2 U21.34
PCIRST2_L_IC: C423.1 R408.2 U23.16
PCIRST3_L: D23.1 R96.2 U21.84
PCIRST_L: R290.2 R975.1 U11.115
PCIRST_L_R: C346.2 PCI.A15 R290.1
PEG_RCOMP: CPU1.P3 R4.2
PEG_RX_N0: CPU1.F15 PCIE16X_1.A17
PEG_RX_N1: CPU1.E14 PCIE16X_1.A22
PEG_RX_N2: CPU1.F13 PCIE16X_1.A26
PEG_RX_N3: CPU1.E12 PCIE16X_1.A30
PEG_RX_N4: CPU1.F11 PCIE16X_1.A36
PEG_RX_N5: CPU1.G10 PCIE16X_1.A40
PEG_RX_N6: CPU1.F9 PCIE16X_1.A44
PEG_RX_N7: CPU1.G8 PCIE16X_1.A48
PEG_RX_N8: CPU1.D4 PCIE16X_1.A53
PEG_RX_N9: CPU1.E5 PCIE16X_1.A57
PEG_RX_N10: CPU1.F6 PCIE16X_1.A61
PEG_RX_N11: CPU1.G5 PCIE16X_1.A65
PEG_RX_N12: CPU1.H6 PCIE16X_1.A69
PEG_RX_N13: CPU1.J5 PCIE16X_1.A73
PEG_RX_N14: CPU1.K6 PCIE16X_1.A77
PEG_RX_N15: CPU1.L5 PCIE16X_1.A81
PEG_RX_P0: CPU1.E15 PCIE16X_1.A16
PEG_RX_P1: CPU1.D14 PCIE16X_1.A21
PEG_RX_P2: CPU1.E13 PCIE16X_1.A25
PEG_RX_P3: CPU1.D12 PCIE16X_1.A29
PEG_RX_P4: CPU1.E11 PCIE16X_1.A35
PEG_RX_P5: CPU1.F10 PCIE16X_1.A39
PEG_RX_P6: CPU1.E9 PCIE16X_1.A43
PEG_RX_P7: CPU1.F8 PCIE16X_1.A47
PEG_RX_P8: CPU1.D3 PCIE16X_1.A52
PEG_RX_P9: CPU1.E4 PCIE16X_1.A56
PEG_RX_P10: CPU1.F5 PCIE16X_1.A60
PEG_RX_P11: CPU1.G4 PCIE16X_1.A64
PEG_RX_P12: CPU1.H5 PCIE16X_1.A68
PEG_RX_P13: CPU1.J4 PCIE16X_1.A72
PEG_RX_P14: CPU1.K5 PCIE16X_1.A76
PEG_RX_P15: CPU1.L4 PCIE16X_1.A80
PEG_TX_C_N0: C51.1 PCIE16X_1.B15
PEG_TX_C_N1: C56.1 PCIE16X_1.B20
PEG_TX_C_N2: C58.1 PCIE16X_1.B24
PEG_TX_C_N3: C60.1 PCIE16X_1.B28
PEG_TX_C_N4: C62.1 PCIE16X_1.B34
PEG_TX_C_N5: C64.1 PCIE16X_1.B38
PEG_TX_C_N6: C66.1 PCIE16X_1.B42
PEG_TX_C_N7: C68.1 PCIE16X_1.B46
PEG_TX_C_N8: C70.1 PCIE16X_1.B51
PEG_TX_C_N9: C72.1 PCIE16X_1.B55
PEG_TX_C_N10: C74.1 PCIE16X_1.B59
PEG_TX_C_N11: C76.1 PCIE16X_1.B63
PEG_TX_C_N12: C78.1 PCIE16X_1.B67
PEG_TX_C_N13: C80.1 PCIE16X_1.B71
PEG_TX_C_N14: C82.1 PCIE16X_1.B75
PEG_TX_C_N15: C84.1 PCIE16X_1.B79
PEG_TX_C_P0: C47.1 PCIE16X_1.B14
PEG_TX_C_P1: C49.1 PCIE16X_1.B19
PEG_TX_C_P2: C57.1 PCIE16X_1.B23
PEG_TX_C_P3: C59.1 PCIE16X_1.B27
PEG_TX_C_P4: C61.1 PCIE16X_1.B33
PEG_TX_C_P5: C63.1 PCIE16X_1.B37
PEG_TX_C_P6: C65.1 PCIE16X_1.B41
PEG_TX_C_P7: C67.1 PCIE16X_1.B45
PEG_TX_C_P8: C69.1 PCIE16X_1.B50
PEG_TX_C_P9: C71.1 PCIE16X_1.B54
PEG_TX_C_P10: C73.1 PCIE16X_1.B58
PEG_TX_C_P11: C75.1 PCIE16X_1.B62
PEG_TX_C_P12: C77.1 PCIE16X_1.B66
PEG_TX_C_P13: C79.1 PCIE16X_1.B70
PEG_TX_C_P14: C81.1 PCIE16X_1.B74
PEG_TX_C_P15: C83.1 PCIE16X_1.B78
PEG_TX_N0: C51.2 CPU1.B12
PEG_TX_N1: C56.2 CPU1.C11
PEG_TX_N2: C58.2 CPU1.D10
PEG_TX_N3: C60.2 CPU1.C9
PEG_TX_N4: C62.2 CPU1.D8
PEG_TX_N5: C64.2 CPU1.C7
PEG_TX_N6: C66.2 CPU1.B6
PEG_TX_N7: C68.2 CPU1.C5
PEG_TX_N8: C70.2 CPU1.E2
PEG_TX_N9: C72.2 CPU1.F3
PEG_TX_N10: C74.2 CPU1.G2
PEG_TX_N11: C76.2 CPU1.H3
PEG_TX_N12: C78.2 CPU1.J2
PEG_TX_N13: C80.2 CPU1.K3
PEG_TX_N14: C82.2 CPU1.M3
PEG_TX_N15: C84.2 CPU1.L2
PEG_TX_P0: C47.2 CPU1.A12
PEG_TX_P1: C49.2 CPU1.B11
PEG_TX_P2: C57.2 CPU1.C10
PEG_TX_P3: C59.2 CPU1.B9
PEG_TX_P4: C61.2 CPU1.C8
PEG_TX_P5: C63.2 CPU1.B7
PEG_TX_P6: C65.2 CPU1.A6
PEG_TX_P7: C67.2 CPU1.B5
PEG_TX_P8: C69.2 CPU1.E1
PEG_TX_P9: C71.2 CPU1.F2
PEG_TX_P10: C73.2 CPU1.G1
PEG_TX_P11: C75.2 CPU1.H2
PEG_TX_P12: C77.2 CPU1.J1
PEG_TX_P13: C79.2 CPU1.K2
PEG_TX_P14: C81.2 CPU1.M2
PEG_TX_P15: C83.2 CPU1.L1
PERR_L: PCI.B40 R976.1 U11.55
PEX1_100M_N: PCH1.R6 PCIE1X.A14
PEX1_100M_P: PCH1.R7 PCIE1X.A13
PEX1_RST_L: C310.1 PCIE1X.A11 R271.1
PEX1_RX_N4: PCH1.J11 PCIE1X.A17
PEX1_RX_P4: PCH1.L11 PCIE1X.A16
PEX1_TX_N4: C292.2 PCH1.B8
PEX1_TX_P4: C290.2 PCH1.C8
PEX4_100M_N: PCH1.AA7 PCIE16X_2.A14
PEX4_100M_P: PCH1.AA6 PCIE16X_2.A13
PEX4_RST_L: C299.1 PCIE16X_2.A11 R270.1
PEX4_RX_N5: PCH1.G9 PCIE16X_2.A17
PEX4_RX_N6: PCH1.F7 PCIE16X_2.A22
PEX4_RX_N7: PCH1.K6 PCIE16X_2.A26
PEX4_RX_N8: PCH1.J2 PCIE16X_2.A30
PEX4_RX_P5: PCH1.F9 PCIE16X_2.A16
PEX4_RX_P6: PCH1.H7 PCIE16X_2.A21
PEX4_RX_P7: PCH1.K8 PCIE16X_2.A25
PEX4_RX_P8: PCH1.J3 PCIE16X_2.A29
PEX4_TX_N5: C291.2 PCH1.B7
PEX4_TX_N6: C294.2 PCH1.E1
PEX4_TX_N7: C296.2 PCH1.G3
PEX4_TX_N8: C298.2 PCH1.H2
PEX4_TX_P5: C289.2 PCH1.A7
PEX4_TX_P6: C293.2 PCH1.D2
PEX4_TX_P7: C295.2 PCH1.G5
PEX4_TX_P8: C297.2 PCH1.H1
PEX16_100M_N: PCH1.AA3 PCIE16X_1.A14
PEX16_100M_P: PCH1.AA2 PCIE16X_1.A13
PEX16_RST: D23.3 R95.1 R96.1 R98.1
PEX16_RST_L: C50.1 PCIE16X_1.A11 R98.2
PHASE1: C739.1 L8.1 P1.2 QCH1.S1 QCH1.S2 QCH1.S3 QCL1.D1 QCL1.D2 QCL1.D3 QCL1.D4 QCL1.D5 QCL5.D1 QCL5.D2 QCL5.D3 QCL5.D4 QCL5.D5 R821.2 R829.1 U39.19
PHASE1_RC1: C740.1 R829.2
PHASE2: C742.1 L9.1 P3.2 QCH2.S1 QCH2.S2 QCH2.S3 QCL2.D1 QCL2.D2 QCL2.D3 QCL2.D4 QCL2.D5 QCL6.D1 QCL6.D2 QCL6.D3 QCL6.D4 QCL6.D5 R838.2 R842.1 U39.23
PHASE2_RC1: C753.1 R842.2
PHASE3: C750.1 L10.1 P5.2 QCH3.S1 QCH3.S2 QCH3.S3 QCL3.D1 QCL3.D2 QCL3.D3 QCL3.D4 QCL3.D5 QCL7.D1 QCL7.D2 QCL7.D3 QCL7.D4 QCL7.D5 R866.2 R869.1 U39.28
PHASE3_RC1: C765.1 R869.2
PHASE4: C768.1 L11.1 P7.2 QCH4.S1 QCH4.S2 QCH4.S3 QCL4.D1 QCL4.D2 QCL4.D3 QCL4.D4 QCL4.D5 QCL8.D1 QCL8.D2 QCL8.D3 QCL8.D4 QCL8.D5 R885.2 R888.1 U40.8
PHASE4_RC1: C772.1 R888.2
PIRQA_L: PCH1.AU29 RN12.5(A)
PIRQB_L: PCH1.AU27 RN11.5(A)
PIRQC_L: PCH1.AW28 RN11.1(A)
PIRQD_L: PCH1.AV27 RN11.7(A)
PM66EN: PCI.B49 RJ1.2 U11.122
PM_SYNC: CPU1.P36 PCH1.F40
PME_B_L: R277.1 U11.2
PME_L: PCH1.AA31 PCI.A19 R127.2
POP: QP6.C R483.1 R486.1 R487.1 R493.1 R496.1 R501.1 R503.1 R507.1 R511.1 R513.1 R515.1 R518.2 R520.1
POP_R: QN46.B R518.1
PREQ64_1_L: PCI.A60 R293.2
PROCHOT_L: CPU1.K38 R38.2
PWM4: U39.31 U40.3
PWR_DEBUG: CPU1.N40 R15.2 R17.2 SR30.1
PWROK_RC: C230.1 PCH1.AT40 R200.2 R204.2
R_MDI0N: RLAN.4 SR7.2
R_MDI0P: RLAN.3 SR8.2
R_MDI1N: RLAN.7 SR9.2
R_MDI1P: RLAN.6 SR10.2
R_MDI2N: RLAN.10 SR11.2
R_MDI2P: RLAN.9 SR12.2
R_MDI3N: RLAN.13 SR13.2
R_MDI3P: RLAN.12 SR14.2
RBIAS: ILAN.12 R446.2
REFCLK14IN: PCH1.AR7 R159.2
REQ0_L: PCI.B18 R287.1 U11.107
REQ1_L: R977.1 U11.102
RJ45_P19: C495.1 C496.2 USB3_LAN.19
RLAN_CLKN: PCH1.W11 RLAN.27
RLAN_CLKP: PCH1.W10 RLAN.26
RLAN_R_RST: C461.2 R452.1 RLAN.20
RLAN_RST: R452.2 SR59.2
RLAN_RXN: C481.2 SR3.2
RLAN_RXN_C: C481.1 RLAN.30
RLAN_RXP: C482.2 SR2.2
RLAN_RXP_C: C482.1 RLAN.29
RLAN_TXN: C480.1 SR6.2
RLAN_TXN_C: C480.2 RLAN.24
RLAN_TXP: C479.1 SR5.2
RLAN_TXP_C: C479.2 RLAN.23
RLAN_WAKE_L: R461.1 R694.2 RLAN.19
ROM_CS_L0: R325.2 SPI_DEBUG.1 SPIROM1.1
ROM_CS_L1: R326.2 SPI_DEBUG.11 SPIROM2.1
RREF_8893: R279.2 U11.16
RSET: R451.1 RLAN.64
RSMRST_L: C678.1 C691.1 PCH1.AM40 R198.2 R356.1 R761.1 U21.85
RST_SEL: R286.1 U11.91
RSTIN_L: R354.1 U21.3
RTCRST_L: C238.2 PCH1.AR38 R251.1
SATA3_RX_N0: C205.1 PCH1.B28
SATA3_RX_N0_C: C205.2 SATA1.5
SATA3_RX_N1: C213.1 PCH1.D30
SATA3_RX_N1_C: C213.2 SATA2.5
SATA3_RX_N2: C221.1 PCH1.A31
SATA3_RX_N2_C: C221.2 SATA3.5
SATA3_RX_N3: C204.1 PCH1.B32
SATA3_RX_N3_C: C204.2 SATA4.5
SATA3_RX_N4: C841.1 PCH1.A26
SATA3_RX_N4_C: C841.2 SATA5.5
SATA3_RX_P0: C207.1 PCH1.A28
SATA3_RX_P0_C: C207.2 SATA1.6
SATA3_RX_P1: C215.1 PCH1.C30
SATA3_RX_P1_C: C215.2 SATA2.6
SATA3_RX_P2: C223.1 PCH1.B31
SATA3_RX_P2_C: C223.2 SATA3.6
SATA3_RX_P3: C206.1 PCH1.C32
SATA3_RX_P3_C: C206.2 SATA4.6
SATA3_RX_P4: C842.1 PCH1.B26
SATA3_RX_P4_C: C842.2 SATA5.6
SATA3_TX_N0: C203.1 PCH1.F31
SATA3_TX_N0_C: C203.2 SATA1.3
SATA3_TX_N1: C211.1 PCH1.B34
SATA3_TX_N1_C: C211.2 SATA2.3
SATA3_TX_N2: C219.1 PCH1.B35
SATA3_TX_N2_C: C219.2 SATA3.3
SATA3_TX_N3: C202.1 PCH1.G33
SATA3_TX_N3_C: C202.2 SATA4.3
SATA3_TX_N4: C840.1 PCH1.L28
SATA3_TX_N4_C: C840.2 SATA5.3
SATA3_TX_P0: C201.1 PCH1.H31
SATA3_TX_P0_C: C201.2 SATA1.2
SATA3_TX_P1: C209.1 PCH1.C34
SATA3_TX_P1_C: C209.2 SATA2.2
SATA3_TX_P2: C217.1 PCH1.D35
SATA3_TX_P2_C: C217.2 SATA3.2
SATA3_TX_P3: C200.1 PCH1.F33
SATA3_TX_P3_C: C200.2 SATA4.2
SATA3_TX_P4: C839.1 PCH1.K28
SATA3_TX_P4_C: C839.2 SATA5.2
SATA_RCOMP: PCH1.D33 R166.1
SATALED_L: PCH1.J39 QN43.E R165.1 R397.1
SATALED_L_B: QN43.B R389.1
SCLOCK: PCH1.L38 RN46.3(A)
SDAT1: PCH1.L40 RN46.5(A)
SDI: CODEC.8 R509.1
SENSE-A: CODEC.13 R499.1 R500.1 R502.1
SENSE-B: CODEC.34 R481.2 R482.2
SERIRQ: PCH1.G39 RN15.5(A) TPM.16 U21.39 U23.27
SERR_L: PCI.B42 R974.1 U11.56
SIO_33M: C399.1 R151.1 U21.47
SIO_48M: C398.1 R155.1 U21.37
SIO_BEEP: C411.1 R341.1 R385.2 U21.2
SIO_GND: C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.1 C383.2 C385.1 R335.2 R336.2 R337.2 R338.2 R366.2 RT1.1 U21.86
SIO_GP46: A1.1 R258.1 U21.66
SIO_GP47: A2.1 R424.1 U21.65
SIO_GP70: RJ17.2 U21.62
SIO_GP71: RJ7.2 U21.61
SIO_GP73: RJ9.2 U21.59
SIO_GP74: RJ10.2 U21.58
SIO_GP75: RJ11.2 U21.57
SIO_GP76: RJ8.2 THER_HD.5 U21.56
SIO_GP77: R360.2 U21.54
SIO_LED0: R388.2 R396.2 U21.14
SIO_LED0_R: QN41.B R396.1
SIO_LED1: R395.2 R398.1 U21.12
SIO_LED1_R: QN42.B R398.2
SIO_PECI: R27.2 R357.2
SIO_PECI_R: C400.1 R357.1 U21.55
SIO_PWRON_L: PCH1.AK41 R350.1 R984.1 U21.72
SIO_VCC3: R340.1 U21.92
SIO_VCORE: C388.1 C389.1 U21.36
SIO_VREF: C380.2 R339.1 U21.91
SKIP: R934.1 R935.2 U41.25
SLOAD: PCH1.H41 RN46.1(A)
SLP_AMT_L: ME_TEST.5 PCH1.AN37 QN60.E R187.1 R622.2 R645.2
SLP_AMT_L_B: C229.1 QN26.B R187.2
SLP_AMT_L_C: QN24.B QN26.C R185.1
SLP_LAN_L: PCH1.AU36 R653.2 R657.2
SLP_S3_L: C677.2 ME_TEST.2 PCH1.AK40 R61.1 R268.1 R598.2 R609.2 R644.2 U12.5 U13.5 U16.5 U19.1 U21.71 U25.5 U29.1
SLP_S3_L_QB_1: QN3.B R61.2
SLP_S4_L: ME_TEST.4 PCH1.AT35 R400.2 U21.77
SLP_S4_L_R: QN44.G R400.1
SLP_S4_L_R_D: QN41.E QN42.E QN44.D R401.2
SLPSUS_L: PCH1.AK38 R627.1 R630.2 U21.6
SLS3_B1: QN2.B R60.2
SLS3_B2: QN4.B R63.2
SLS3_B3: QN5.B R65.2
SLS3_BF: QN3.C R59.1 R60.1 R63.1 R65.1
SLS3_C2: QN4.C R62.1
SLS3_C3: QN5.C R64.1
SMBALERT_L: C247.1 R232.1 R454.2 R953.2 RLAN.22
SMBALERT_STBY_R: PCH1.AG31 R232.2 R423.2
SMBCLK_MAIN: DIMM1.118 DIMM2.118 DIMM3.118 DIMM4.118 QN36.S R303.1 R304.1 R417.1 SJ1.53
SMBCLK_STBY: C231.1 PCI.A40 PCIE1X.B5 PCIE16X_1.B5 PCIE16X_2.B5 QN36.D R212.1 R301.1 R303.2 R957.2 SR56.2
SMBCLK_STBY_IO: SC51.2 SR56.1 U21.63
SMBCLK_STBY_R: PCH1.AG36 R212.2
SMBCLK_STBY_R1: C823.2 R762.1 R957.1 RLAN.17
SMBDATA_MAIN: DIMM1.238 DIMM2.238 DIMM3.238 DIMM4.238 QN38.S R305.1 R308.1 R410.1 SJ1.51
SMBDATA_STBY: C232.1 PCI.A41 PCIE1X.B6 PCIE16X_1.B6 PCIE16X_2.B6 QN38.D R214.1 R302.1 R308.2 R958.2 SR55.2
SMBDATA_STBY_IO: SC50.2 SR55.1 U21.64
SMBDATA_STBY_R: PCH1.AG32 R214.2
SMBDATA_STBY_R1: C824.2 R763.1 R958.1 RLAN.18
SML0_ALERT: PCH1.AG35 R456.2
SML0_CLK: C233.1 PCH1.AE32 R223.2 R430.1
SML0_CLK_R: ILAN.28 R430.2
SML0_DATA: C234.1 PCH1.AE35 R222.2 R432.1
SML0_DATA_R: ILAN.31 R432.2
SML1_ALERT: PCH1.AJ39 R235.2
SML1_CLK: C235.1 PCH1.AK36 R228.2 U21.31
SML1_DATA: C236.1 PCH1.AK33 R227.2 U21.53
SMRCOMP0: CPU1.R1 R26.2
SMRCOMP1: CPU1.P1 R29.2
SMRCOMP2: CPU1.R2 R31.2
SPI_CLK: R221.1 R323.2 R324.2
SPI_CLK0: R323.1 SPI_DEBUG.8 SPIROM1.6
SPI_CLK1: R324.1 SPIROM2.6
SPI_CS_L0: PCH1.R38 R325.1 SPI_DEBUG.3
SPI_CS_L1: PCH1.R35 R326.1 SPI_DEBUG.12
SPI_IO2: C262.1 PCH1.U40 R319.2 R321.2 R765.2
SPI_IO2_0: R317.2 R319.1 SPIROM1.3
