# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_3P3_N4: length 2.6
  TOP w0.102: QN64.B R644.1 95.16,186.88 v1(95.16,186.54)
LAN_3P3_N5: length 4.2
  TOP w0.102: QN63.E QN64.C 90.05,188.5 v1(89.52,189.03)
LAN_3P3_N6: length 3.8
  TOP w0.152: QN62.C 97.95,196.12 98.33,196.5 v1(98.33,196.7) R636.2 97.16,197.68 R632.1
LAN_3P3_N7: length 8.5
  TOP w0.102: R650.1 96.52,191.29 v2(98.33,191.29) ; QN66.B 102.14,191.42 v2(101.76,191.04)
  BOTTOM w0.102: v2(101.76,191.04) 101.38,191.42 v1(100.62,191.42) 100.11,190.91 98.71,190.91 v2(98.33,191.29)
LAN_3P3_N8: length 12.6
  TOP w0.102: R647.1 R648.1 104.43,188.37 105.87,189.82 105.87,193.15 105.32,193.71 QN66.C 104.93,194.72 v1(104.93,194.98) R649.2
LAN_3P3_N9: length 8.7
  TOP w0.102: QN66.E 104.93,190.63 R652.1 R654.2 102.62,189.52 101.84,189.52 v1(101.51,189.19) 100.69,188.37 QN67.C
LAN_3P3_N10: length 7.1
  TOP w0.102: R653.1 100.49,184.2 C612.1 100.49,187.1 QN67.B 99.47,186.6 97.67,186.6 v1(97.29,186.21)
LAN_3P3_N11: length 7.1
  TOP w0.508: R635.1 R634.1 103.28,198 103.16,198.13 v2(103.16,198.15) 103.16,199.17 C609.1 103.66,199.68 Q7.3
LAN_CLKREQ_L: length 4.8
  TOP w0.102: RLAN.33 46.63,233.02 45.78,233.86 45.35,233.86 v2(44.74,234.47) 44.74,234.65 43.82,235.57 R459.1
LAN_DIS_L: length 263.3
  TOP w0.102: v2(3.84,62.64) 4.48,62.64 4.73,62.39 5.38,62.39 7.89,64.9 8.03,64.9 8.03,64.9 8.22,64.9 14.99,64.9 15.76,65.67 21.09,65.67 21.71,66.29 25.29,66.29 25.81,65.77 31.12,65.77 33.65,68.3 33.65,71.56 34.92,72.82 34.92,73.35 35.75,74.19 35.75,75.17 v1(36.68,76.11) 37.27,76.69 37.27,78.93 37.06,79.14 37.06,82 40.63,85.57 40.63,86.33 PCH1.AL40 ; R437.1 v2(63.91,205.14) ; v2(44.41,206.71) 44.05,207.07 38.95,207.07 38.41,207.6 36.43,207.6 35.72,206.89 35.72,202.52 34.5,201.3 22.34,201.3 21.89,201.76 17.91,201.76 12.22,196.07 12.22,189.24 15.3,186.16 15.3,176.89 11.92,173.51 8.67,173.51 8.29,173.13 v2(7.55,173.13)
  BOTTOM w0.102: v2(7.55,173.13) 7.17,172.75 4.06,172.75 1.12,169.82 1.12,153.23 2.65,151.71 2.65,143.7 1.47,142.53 1.47,66.41 4.2,63.68 4.2,63 v2(3.84,62.64) ; v2(44.41,206.71) 44.41,206.28 45.24,205.44 46.22,205.44 47.23,204.43 55.07,204.43 55.28,204.63 63.41,204.63 v2(63.91,205.14)
LAN_DIS_L_R: length 10.9
  TOP w0.102: R438.2 65.61,206.33 v1(65.97,206.33) ; R438.2 R437.2 ; R438.2 65.18,206.88 R444.2 66.45,208.51 67.09,209.15 67.09,210.09 68.23,211.23 69.99,211.23 70.51,211.76 ILAN.3
LAN_JTCK: length 3.9
  TOP w0.102: R448.1 68.1,220.63 v2(68.87,219.87) 68.87,219.23 69.5,218.6 69.88,218.6 70.11,218.37 ILAN.35
LAN_JTDI: length 1.3
  TOP w0.102: ILAN.32 71.31,218.82 TP21.1
LAN_JTDO: length 2.8
  TOP w0.102: ILAN.34 70.51,218.35 v2(69.63,219.23)
  BOTTOM w0.102: STP19.1 69.5,219.11 v2(69.63,219.23)
LAN_JTMS: length 6.6
  TOP w0.102: ILAN.33 70.91,218.33 70.26,218.98 70.26,219.65 R447.1 69.6,221.27 69.6,222.1 68.82,222.89 v1(68.82,223.27)
LAN_XTAL1: length 11.8
  TOP w0.152: R737.2 64.24,209.33 v2(64.27,209.35) ; v2(72.73,210.37) 73.06,210.7 73.06,211.49 72.91,211.63 ILAN.9
  BOTTOM w0.152: v2(72.73,210.37) 72.63,210.47 v1(71.41,210.47) 71.2,210.27 65.21,210.27 64.29,209.35 v2(64.27,209.35)
LAN_XTAL1_R: length 5.3
  TOP w0.152: R737.1 C445.2 61.34,209.42 62.26,210.34 X2.2
LAN_XTAL2: length 22.3
  TOP w0.152: ILAN.10 73.31,211.63 73.34,211.6 73.34,210.5 v2(73.46,210.37) ; X2.1 57.18,210 C446.2 58.33,208.85 64.52,208.85 v2(65.01,209.33)
  BOTTOM w0.152: v2(73.46,210.37) 72.96,209.86 65.54,209.86 v2(65.01,209.33)
LAN_XTL1: length 21.7
  TOP w0.203: X3.2 42.45,217.04 C448.1 44.13,218.73 48.8,218.73 49.56,217.96 50.2,217.96 50.71,217.46 52.09,217.46 52.48,217.85 52.48,222.89 53.34,223.75 RLAN.60
LAN_XTL2: length 17.6
  TOP w0.203: X3.1 47.53,217.74 C449.1 47.93,218.14 48.62,218.14 49.34,217.42 49.97,217.42 50.44,216.95 52.36,216.95 52.99,217.58 52.99,222.74 53.84,223.59 RLAN.61
LANDUAL_NCH: length 6.1
  TOP w0.152: Q7.2 102.39,200.95 102.01,200.57 101.25,200.57 100.55,199.87 v1(100.55,199.73) 99.8,198.98 C605.1 98.68,198.98 R636.1
LANDUAL_PCH: length 8.4
  TOP w0.102: v2(103.64,203.89) 104.3,203.89 104.93,203.26 Q7.4 C611.1 105.49,199.18 105.49,197.41 R649.1
LDO2_ENR: length 5.8
  TOP w0.178: R905.1 46.44,33.85 48.3,33.85 R906.2 49.12,33.97 50.69,33.97 50.7,33.96 U41.24
LDO2_OC: length 3.1
  TOP w0.178: C778.2 48.8,35.59 50.03,34.36 U41.23
LDO_18: length 60
  TOP w0.203: 54.48,157.86 54.48,157.65 54.44,157.61 U11.59
  TOP w0.305: C326.1 53.85,159.32 53.25,159.93 53.25,161.58 v2(52.86,161.96)
  TOP w0.381: C326.1 54.13,158.53 54.48,158.19 54.48,157.86 ; v2(53.12,166.78) 56.98,166.78 58.22,165.54 58.22,161.82 v1(58.53,161.51) C325.1 59.66,161.45 C324.1 PFB7.2 61.31,162.97 62.26,162.97 63.02,162.21 64.93,162.21 65.56,161.58 67.72,161.58 68.04,161.26 68.04,156.94 68.74,156.24 72.8,156.24 73.18,156.62 76.36,156.62 76.84,156.14 76.84,150.45 76.26,149.87 76.26,146.87 75.47,146.08 73.3,146.08 PFB6.2
  BOTTOM w0.381: v2(53.12,166.78) 52.99,166.66 52.99,164.12 52.61,163.74 52.61,162.21 v2(52.86,161.96)
LDOAUX_18: length 11.4
  TOP w0.203: U11.5 67.69,144.09
  TOP w0.305: C335.1 70.96,141.26 C336.1 70.74,141.48 C337.1 69.45,141.66 v1(69.45,142.55) 69.45,142.93 69.08,143.3 68.6,143.3 67.81,144.09 67.69,144.09
  TOP w0.508: PFB5.2 72.55,142.72 C335.1 74.14,141.26 PFB4.2
LED0: length 289.7
  TOP w0.102: v2(16.03,203.8) 14.7,203.8 10.7,199.8 10.7,188.63 13.85,185.48 13.85,177.31 11.96,175.42 v2(8.92,175.42) ; R466.2 v2(75.17,219.62) 74.96,219.62 73.71,218.37 ILAN.26 ; v2(2.45,58.45) 2.45,43.77 3.51,42.7 7.75,42.7 8.52,41.94 11.56,41.94 QP3.B ; v2(51.67,218.9) 51.47,219.11 50.58,219.11 49.87,219.82 49.87,222.54 51.84,224.52 RLAN.57
  BOTTOM w0.102: v2(2.45,58.45) 2.49,58.45 4.58,60.54 4.58,62.16 4.43,62.31 4.43,63.78 1.7,66.5 1.7,142.43 2.88,143.61 2.88,151.8 1.35,153.33 1.35,169.73 3.79,172.17 7.27,172.17 8.77,173.67 8.77,175.27 v2(8.92,175.42) ; v2(16.03,203.8) 18.87,200.97 18.87,200.65 19.45,200.07 21.83,200.07 22.13,200.38 v1(22.13,203.36) 22.13,204.02 25.89,207.78 29.29,207.78 32.61,211.1 35.2,211.1 36.1,212 39.35,212 40.25,211.1 48.99,211.1 49.26,210.83 51.12,210.83 52.66,212.37 52.66,215.7 50.27,218.09 50.27,218.6 50.76,219.08 51.49,219.08 v2(51.67,218.9) 53.22,217.35 62.24,217.35 62.9,218.01 62.9,219.76 64.52,221.39 64.52,224.25 65.98,225.71 73.52,225.71 75.19,224.04 75.19,219.64 v2(75.17,219.62)
LED1: length 47.7
  TOP w0.102: v2(51.67,218.14) 51.04,218.78 50.58,218.78 49.64,219.72 49.64,222.69 51.34,224.4 RLAN.56 ; ILAN.27 73.31,218.35 74.58,219.62 74.58,220.12 74.71,220.25 75.22,220.25 75.98,221.01 R465.2 76.42,221.58 75.09,222.92 v2(74.71,222.92)
  BOTTOM w0.102: v2(74.71,222.92) 74.71,223.55 74.58,223.68 v1(74.58,223.81) 74.58,224.18 73.28,225.48 66.07,225.48 64.75,224.16 64.75,221.29 63.13,219.67 63.13,217.92 62.34,217.13 52.69,217.13 v2(51.67,218.14)
LED2: length 47.2
  TOP w0.102: ILAN.25 74.66,217.92 v2(74.84,218.09) 74.96,218.22 R464.2 ; v2(50.88,218.19) 50.84,218.19 49.41,219.62 49.41,222.79 50.34,223.72 RLAN.54
  BOTTOM w0.102: v2(74.84,218.09) 74.45,218.47 v1(74.45,221.14) 74.45,222.28 73.95,222.79 73.95,224.49 73.18,225.25 66.17,225.25 64.98,224.07 64.98,221.2 63.35,219.57 63.35,217.82 62.43,216.9 51.85,216.9 50.88,217.86 v2(50.88,218.19)
LGATE1: length 18.1
  TOP w0.635: QCL1.G 153.46,169.02 v2(152.33,169.02) ; v2(153.96,177.58) 153.96,178.28 QCL5.G 153.19,178.59 152.84,178.24 151.39,178.24 150.65,178.98 R822.1
  BOTTOM w0.635: v2(153.96,177.58) v1(153.96,169.96) 153.02,169.02 v2(152.33,169.02)
LGATE2: length 13.8
  TOP w0.635: R844.1 QCL6.G v2(174.21,177.71) ; v2(174.21,168.24) QCL2.G
  BOTTOM w0.635: 174.21,169.59 v2(174.21,177.71) ; 174.21,169.59 v2(174.21,168.24) ; 174.21,169.59 v1(174.23,169.58)
LGATE3: length 13.9
  TOP w0.635: QCL7.G 226.73,177.32 227.24,176.82 R870.1 229.52,174.91 v1(229.52,170.11) 229.52,170.09 228.63,169.2 QCL3.G
LGATE4: length 21.4
  TOP w0.635: QCL4.G 134.46,169.07 v2(134.46,168.05) ; v2(134.91,177.58) 134.91,178.28 QCL8.G ; R893.1 v2(133.13,184.44)
  BOTTOM w0.635: v2(134.46,168.05) 134.91,168.5 v1(134.91,169.48) v2(134.91,177.58) 134.91,183.42 133.89,184.44 v2(133.13,184.44)
LINE1_JD: length 101.2
  TOP w0.254: v2(72.3,242.09) 72.04,242.35 32.16,242.35 29.17,239.35 29.17,231.59 29.88,230.88 29.88,227.49 v2(31.15,226.22) ; R500.2 v2(30.23,218.19)
  BOTTOM w0.254: v2(31.15,226.22) 32.04,225.33 32.04,220 v2(30.23,218.19) ; AUDIO.3Q 95.2,227.7 87.28,235.62 87.28,240.15 85.16,242.27 74.89,242.27 74.53,241.92 72.47,241.92 v2(72.3,242.09)
LINE1_L: length 109.1
  TOP w0.254: Q2.C1 17.67,237.34 17.1,236.77 17.1,235.57 17.56,235.11 v2(17.81,235.11) 17.81,234.44 R489.2 ; v2(66.71,241.08) 67.67,240.11 67.67,238.68 68.4,237.95 68.4,236.49 69.02,235.87 73.51,235.87 77.44,239.81 82.36,239.81 85.94,236.23 85.94,231.22 82.2,227.49 v2(82.2,226.73)
  BOTTOM w0.254: v2(66.71,241.08) 65.44,242.35 22,242.35 16.8,237.14 v1(16.8,236.63) 16.8,236.13 v2(17.81,235.11) ; SFB2.1 90.39,222.85 90.08,223.17 88.04,223.17 87.57,222.7 SR46.1 85.12,222.28 82.2,225.2 v2(82.2,226.73)
LINE1_L1: length 5.6
  TOP w0.254: CODEC.23 23.53,223.39 25.31,225.16 v2(25.31,225.71) 25.56,225.97 C512.2
LINE1_L2: length 11.3
  TOP w0.254: v2(24.52,230.21) 24.52,230.18 C512.1 ; v2(17.94,232.19) 17.94,232.7 17.56,233.08 R489.1
  BOTTOM w0.254: v2(17.94,232.19) 17.94,232.57 18.24,232.87 22.46,232.87 v1(24.16,231.17) 24.52,230.82 v2(24.52,230.21)
LINE1_L_P: length 4.2
  TOP w0.254: Q2.B1 18.32,236.38 18.58,236.63 18.78,236.63 19.59,237.44 v2(19.59,238.72) 19.59,239.08 R487.2
LINE1_LL: length 11
  BOTTOM w0.254: AUDIO.31 93.32,226.79 96.01,224.09 96.01,222.6 SD2.2 95.06,223.04 93.63,223.04 93.28,222.7 SC45.1 93.16,222.28 SFB2.2
LINE1_R: length 104
  TOP w0.254: v2(65.69,240.95) 67.16,239.48 67.16,238.47 67.89,237.74 67.89,236.28 68.81,235.36 73.72,235.36 77.65,239.3 82.14,239.3 85.43,236.02 85.43,231.6 v2(81.44,227.62) ; R488.2 18.57,234.98 v2(18.7,235.11) 18.9,235.31 18.9,235.95 Q2.C2
  BOTTOM w0.254: v2(18.7,235.11) 18.83,235.24 v1(18.83,236.13) 18.83,236.76 23.91,241.84 64.8,241.84 v2(65.69,240.95) ; SFB1.1 89.71,220.07 87.97,220.07 87.57,220.47 SR45.1 86.81,221.52 84.36,221.52 81.44,224.44 v2(81.44,227.62)
LINE1_R1: length 3.7
  TOP w0.254: CODEC.24 22.7,224.25 23.53,225.08 v2(23.53,225.71) C514.2
LINE1_R2: length 7.9
  TOP w0.254: C514.1 v2(23.53,230.23) ; R488.1 18.57,233.08 18.83,232.82 v2(18.83,232.19)
  BOTTOM w0.254: v2(23.53,230.23) 23.53,230.41 v1(22.13,231.81) 21.75,232.19 v2(18.83,232.19)
LINE1_R_P: length 2.6
  TOP w0.254: v1(17.23,239.94) 17.7,239.46 R493.2 18.32,239.27 Q2.B2
LINE1_RR: length 14.4
  BOTTOM w0.254: AUDIO.34 98.95,225.54 98.95,220.78 98.61,220.44 SD2.1 95.44,220.12 93.76,220.12 93.41,220.47 93.41,220.76 SC44.1 SFB1.2
LINE2_JD: length 50.1
  TOP w0.254: F_AUDIO.10 5.75,194.85 2.62,194.85 0.79,196.67 0.79,225.33 2.83,227.36 7.24,227.36 10.29,230.41 11.18,230.41 R481.1
LINE2_L: length 88
  TOP w0.254: v2(7.02,213.27) 7.24,213.04 R526.1 C531.2 9.43,212.92 9.43,210.47 9.11,210.15 D27.2 9.11,209.01 v2(8.16,208.06) ; 4.86,196.5 3.79,197.57 v2(3.79,200.18) ; Q4.C1 15.13,237.34 14.56,236.77 14.56,235.57 14.72,235.4 15.74,235.4 16.29,234.86 16.29,232.57 v2(16.16,232.44) ; R498.2 v2(33.56,226.22)
  BOTTOM w0.254: v2(3.79,200.18) 3.79,207.58 4.27,208.06 v2(8.16,208.06) ; v2(33.56,226.22) 25.89,233.89 17.36,233.89 16.16,232.7 v2(16.16,232.44) 15.4,231.68 13.24,231.68 12.48,230.92 11.25,230.92 10.65,231.52 9.78,232.39 8.7,232.39 6.72,230.41 5.46,230.41 2.67,227.62 2.67,214.95 4.35,213.27 v2(7.02,213.27)
LINE2_L1: length 13.6
  TOP w0.254: EC18.1 32.98,218.89 CODEC.14
LINE2_L2: length 5.5
  TOP w0.254: EC18.2 34.91,224.22 R498.1
LINE2_L_P: length 4.4
  TOP w0.254: Q4.B1 15.78,236.31 16.11,236.63 16.24,236.63 17.05,237.44 v2(17.05,238.79) 16.38,239.46 R503.2
LINE2_R: length 70.3
  TOP w0.254: Q4.C2 16.43,235.49 16.92,235 16.92,232.57 v2(17.05,232.44) ; v2(3.84,214.79) 3.84,213.39 4.19,213.04 R525.1 C532.2 6.26,212.66 6.26,211.11 7.21,210.15 D27.1 7.21,208 5.93,206.71 5.93,202.65 4.86,201.58 ; R497.2 v2(32.42,226.22)
  BOTTOM w0.254: v2(32.42,226.22) 25.25,233.38 17.99,233.38 v2(17.05,232.44) 17.05,232.32 15.91,231.17 13.45,231.17 12.69,230.41 11.04,230.41 9.59,231.86 8.9,231.86 6.93,229.9 5.67,229.9 3.18,227.41 3.18,215.46 v2(3.84,214.79)
LINE2_R1: length 6.2
  TOP w0.254: CODEC.15 23.65,219.39 23.75,219.49 26.34,219.49 EC17.1
LINE2_R2: length 3.7
  TOP w0.254: R497.1 32.42,223.06 EC17.2
LINE2_R_P: length 1.7
  TOP w0.254: R507.2 15.78,238.95 Q4.B2
LOCK_L: length 39
  TOP w0.127: U11.62 53.24,158.15 51.98,159.41 R973.1 52.61,160.08 52.61,160.94 52.1,161.45 52.1,163.3 52.94,164.14 52.94,164.68 52.74,164.88 48.02,164.88 46.11,162.97 44.17,162.97 43.69,162.49 41.91,162.49 41.18,163.23 38.71,163.23 37.61,164.32 36.94,164.32 36.35,163.74 36.35,157.94 PCI.B39
LPC_DRQ0_L: length 390.8
  TOP w0.102: v2(84.36,15.53) 83.6,14.76 76.81,14.76 71.91,9.87 71.91,5.51 70.63,4.22 57.97,4.22 v2(57.46,4.73) ; v2(109.13,32.54) 108.85,32.27 108.85,29.01 106.05,26.21 106.05,20.2 105.06,19.21 105.06,16.29 v2(104.68,15.91) ; R194.2 24.29,90 24.82,90.53 v2(24.82,90.61) ; PCH1.AK22 41.14,96.02 v3(41.35,95.81) ; U21.5 220.48,31.38 220,30.89 217.71,30.89 217.14,30.32 v2(217.14,29.12)
  BOTTOM w0.102: v2(84.36,15.53) 84.49,15.65 88.04,15.65 v1(88.55,16.16) 88.93,15.78 90.81,15.78 92.46,17.43 103.16,17.43 v2(104.68,15.91) ; v2(109.13,32.54) 109.38,32.29 110.45,32.29 111.56,33.41 112.07,33.41 112.32,33.15 122.25,33.15 123.13,34.03 124.69,34.03 127.1,31.62 127.1,30.55 130.66,26.98 140.13,26.98 141.98,25.13 149.16,25.13 152.36,21.93 160.3,21.93 161.29,20.94 164.65,20.94 165.11,21.39 166.22,21.39 166.42,21.19 177.45,21.19 178.85,22.59 191.35,22.59 192.16,21.77 195.22,21.77 195.66,22.21 198.82,22.21 199.66,23.04 200.93,23.04 201.15,23.27 205.37,23.27 210.75,28.66 216.68,28.66 v2(217.14,29.12) ; v3(41.35,95.81) 40.74,95.2 38.66,95.2 38.14,94.67 36.98,94.67 35.59,93.28 32.95,93.28 30.44,90.77 24.99,90.77 v2(24.82,90.61) 24.82,90.77 22.57,93.02 15.97,93.02 13.7,90.75 13.7,87.5 12.84,86.65 12.16,86.65 10.92,86.65 6.92,82.64 6.38,82.11 6.1,81.83 6.1,75.41 9.51,72.01 9.51,71.13 7.8,69.42 7.8,63.52 8.62,62.71 8.62,60.5 2.93,54.81 2.93,38.15 3.66,37.41 3.66,31.09 1.24,28.67 1.24,3.74 2.94,2.05 3.74,1.24 55.4,1.24 57.46,3.31 v2(57.46,4.73)
LPC_FRAME_L: length 436.3
  TOP w0.102: v2(56.47,3.69) 56.7,3.46 71.03,3.46 72.68,5.11 72.68,9.51 76.92,13.75 83.47,13.75 87.54,9.68 87.54,3.88 88.11,3.3 198.61,3.3 TPM.3 200.44,5.13 200.44,7 201.93,8.49 206.46,8.49 206.79,8.16 208.13,8.16 208.63,7.67 v2(208.63,7.53) ; v2(211.11,20.35) 209.94,21.52 209.94,27.17 209.06,28.04 207.49,28.04 207.05,28.48 204.49,28.48 203.05,29.91 U21.40 ; v3(39.27,94.79) 38.96,95.11 PCH1.AP24 ; v2(229.14,21.04) 229.14,21.24 230.64,22.74 230.64,22.92 231.36,23.65 232.18,23.65 232.75,24.22 U23.22
  BOTTOM w0.102: v2(211.11,20.35) 211.64,20.89 211.64,22.28 212.4,23.04 212.4,23.73 212.79,24.11 216.78,24.11 218.95,21.94 227.81,21.94 228,21.75 228,21.42 228.38,21.04 v2(229.14,21.04) 229.38,21.04 230.02,21.67 231.23,21.67 232.59,20.31 232.59,17.59 228.16,13.16 228.16,12.51 224.21,8.55 213.98,8.55 213.48,8.06 209.16,8.06 v2(208.63,7.53) ; v3(39.27,94.79) 38.55,94.79 38.21,94.46 37.05,94.46 35.67,93.07 33.07,93.07 30.54,90.55 25.7,90.55 24.9,89.75 24.24,89.75 24.01,89.97 24.01,91.26 22.47,92.79 16.06,92.79 13.93,90.65 13.93,87.41 12.94,86.42 12.07,86.42 11.02,86.42 7.01,82.42 7.01,82.42 6.61,82.01 6.33,81.73 6.33,75.51 9.74,72.1 9.74,71.03 8.03,69.33 8.03,63.61 8.85,62.8 8.85,60.4 3.16,54.71 3.16,38.25 3.89,37.51 3.89,30.99 1.47,28.57 1.47,3.84 3.17,2.14 3.84,1.47 55.12,1.47 56.47,2.83 v2(56.47,3.69)
LPC_LAD0: length 436.9
  TOP w0.102: v2(230.03,23.53) 230.15,23.65 U23.26 ; v2(55.13,2.93) 55.35,2.7 71.34,2.7 73.44,4.8 73.44,9.19 77.31,13.06 83.19,13.06 86.82,9.43 86.82,3.63 87.83,2.62 202.26,2.62 203.36,3.72 203.36,4.6 204.25,5.49 205.2,5.49 206,4.7 206,4 206.66,3.33 208.8,3.33 TPM.11 ; v3(40.01,94.79) 39.72,95.08 PCH1.AN24 ; U21.41 203.11,29.41 204.27,28.25 206.96,28.25 207.4,27.81 208.29,27.81 209.46,26.65 v2(209.46,21.88)
  BOTTOM w0.102: v2(209.46,21.88) 210.34,22.77 210.51,22.77 211.23,23.49 211.23,24.3 212.18,25.25 217.25,25.25 219.4,23.11 229.61,23.11 v2(230.03,23.53) 230.31,23.81 232.44,23.81 232.7,23.55 232.7,21.83 233.74,20.79 233.74,17.12 229.31,12.69 229.31,12.03 226.24,8.97 226.24,7.49 224.71,5.96 223.01,5.96 220.68,3.63 214.11,3.63 213.65,4.1 213.65,4.86 213.06,5.44 210.91,5.44 TPM.11 ; v2(55.13,2.93) 55.13,2.8 54.03,1.7 3.93,1.7 3.4,2.24 1.7,3.93 1.7,28.45 4.12,30.87 4.12,37.6 3.39,38.34 3.39,54.62 9.07,60.31 9.07,62.9 8.26,63.71 8.26,69.23 9.96,70.94 9.96,72.2 6.56,75.6 6.56,81.64 6.84,81.92 7.11,82.19 11.11,86.19 11.97,86.19 13.03,86.19 14.15,87.31 14.15,90.56 16.16,92.56 22.38,92.56 23.78,91.16 23.78,89.88 24.14,89.52 25,89.52 25.76,90.28 30.6,90.28 33.19,92.87 35.76,92.87 37.14,94.25 38.29,94.25 38.42,94.38 39.61,94.38 v3(40.01,94.79)
LPC_LAD1: length 431.5
  TOP w0.102: TPM.10 206.33,8.13 201.89,8.13 200.69,6.93 200.69,3.59 200.18,3.07 88.02,3.07 87.31,3.78 87.31,9.59 83.38,13.52 77.05,13.52 72.93,9.4 72.93,5.01 71.13,3.21 56.04,3.21 55.61,3.64 53.68,3.64 v2(52.74,2.7) ; v2(229.27,22.13) 229.52,22.13 231.27,23.88 231.84,23.88 232.1,24.14 U23.23 ; PCH1.AP26 39.01,93.73 v3(38.85,93.57) ; v2(209.96,20.61) 208.82,21.75 208.82,26.88 208.12,27.58 207.3,27.58 206.86,28.02 203.94,28.02 203.05,28.91 U21.42
  BOTTOM w0.102: v3(38.85,93.57) 38.8,93.61 37.36,93.61 36.01,92.26 33.61,92.26 30.9,89.56 26,89.56 25.28,88.83 23.86,88.83 23.1,89.59 23.1,90.88 22.09,91.88 16.44,91.88 14.84,90.28 14.84,87.03 13.32,85.5 11.69,85.5 11.39,85.5 11.39,85.5 7.25,81.36 7.25,75.88 10.65,72.48 10.65,70.65 8.95,68.95 8.95,63.99 9.76,63.18 9.76,59.97 5.87,56.09 5.87,38.18 4.88,37.19 4.88,30.4 2.39,27.9 2.39,4.22 4.08,2.52 4.22,2.39 52.43,2.39 v2(52.74,2.7) ; TPM.10 208.31,6.15 213.68,6.15 214.01,5.82 220.71,5.82 222.99,8.1 224.4,8.1 228.62,12.32 228.62,12.97 233.05,17.4 233.05,20.5 231.43,22.13 v2(229.27,22.13) 229,22.4 219.14,22.4 216.97,24.57 212.47,24.57 211.94,24.04 211.94,23.23 210.6,21.89 210.6,21.11 210.09,20.61 v2(209.96,20.61)
LPC_LAD2: length 436.7
  TOP w0.102: v2(231.36,22.89) 231.87,23.4 232.32,23.4 232.7,23.78 233.78,23.78 234.05,24.06 U23.20 ; v2(209.1,20.73) 209.1,20.96 208.59,21.47 208.59,26.52 207.76,27.36 207.21,27.36 206.77,27.79 203.66,27.79 203.04,28.41 U21.43 ; TPM.8 204.02,7.9 201.99,7.9 200.95,6.86 200.95,3.33 200.46,2.84 87.92,2.84 87.08,3.69 87.08,9.5 83.28,13.29 77.18,13.29 73.18,9.3 73.18,4.9 71.24,2.95 55.89,2.95 55.43,3.41 54.87,3.41 v2(54.39,2.93) ; PCH1.AJ24 41.48,94.91 v3(41.48,94.74)
  BOTTOM w0.102: TPM.8 206.01,7.04 207.12,5.93 213.59,5.93 213.92,5.6 220.81,5.6 223.08,7.87 224.49,7.87 228.85,12.22 228.85,12.88 233.28,17.31 233.28,20.6 231.36,22.52 v2(231.36,22.89) 230.79,22.89 230.52,22.63 219.24,22.63 217.06,24.8 212.37,24.8 211.72,24.14 211.72,23.33 210.37,21.98 210.37,21.52 209.96,21.11 209.58,21.11 209.2,20.73 v2(209.1,20.73) ; v2(54.39,2.93) 54.39,2.8 53.52,1.93 4.03,1.93 3.63,2.33 1.93,4.03 1.93,28.35 4.4,30.82 4.4,37.35 5.42,38.37 5.42,56.28 9.3,60.16 9.3,62.99 8.49,63.8 8.49,69.14 10.19,70.84 10.19,72.29 6.79,75.69 6.79,81.54 7.07,81.82 7.07,81.82 7.2,81.96 11.2,85.96 11.88,85.96 11.88,85.96 13.13,85.96 14.38,87.22 14.38,90.47 16.25,92.34 22.28,92.34 23.55,91.07 23.55,89.78 24.05,89.29 25.09,89.29 25.85,90.05 30.69,90.05 33.31,92.67 35.84,92.67 37.22,94.05 38.38,94.05 38.51,94.18 39.94,94.18 40.12,94.36 41.1,94.36 v3(41.48,94.74)
LPC_LAD3: length 433.1
  TOP w0.102: U21.44 202.98,27.91 203.35,27.54 206.7,27.54 207.16,27.08 207.66,27.08 208.31,26.42 v2(208.31,20.72) ; U23.17 236,23.34 235.81,23.15 232.44,23.15 v2(232.19,22.89) ; v2(53.5,2.7) 53.75,2.45 71.45,2.45 73.69,4.69 73.69,9.09 77.44,12.83 83.09,12.83 86.59,9.34 86.59,3.53 87.73,2.39 203.56,2.39 204.88,3.72 TPM.7 ; PCH1.AN26 39.72,93.84 v3(39.53,93.66)
  BOTTOM w0.102: TPM.7 206.04,4.5 207.22,5.67 213.52,5.67 213.82,5.37 220.9,5.37 223.18,7.64 224.59,7.64 229.08,12.13 229.08,12.78 233.51,17.21 233.51,20.69 232.19,22.02 v2(232.19,22.89) 231.5,23.58 231.01,23.58 230.28,22.85 219.33,22.85 217.16,25.03 212.28,25.03 211.49,24.23 211.49,23.42 210.09,22.03 210.09,21.75 209.71,21.37 208.96,21.37 v2(208.31,20.72) ; v3(39.53,93.66) 39.21,93.97 38.59,93.97 38.46,93.85 37.31,93.85 35.92,92.46 33.49,92.46 30.85,89.82 25.95,89.82 25.19,89.06 23.95,89.06 23.32,89.69 23.32,90.97 22.19,92.11 16.35,92.11 14.61,90.37 14.61,87.12 13.22,85.73 11.78,85.73 11.78,85.73 11.3,85.73 11.3,85.73 7.02,81.45 7.02,75.79 10.42,72.39 10.42,70.75 8.72,69.04 8.72,63.9 9.53,63.08 9.53,60.07 5.65,56.18 5.65,38.28 4.63,37.26 4.63,30.47 2.16,28 2.16,4.12 3.85,2.43 3.85,2.43 4.12,2.16 52.96,2.16 v2(53.5,2.7)
LPC_PME_L: length 357.4
  TOP w0.102: v2(88.42,3.92) 87.84,4.5 87.84,6.99 88.88,8.03 91.98,8.03 92.49,8.54 92.49,13.95 v2(92.23,14.21) ; U21.73 207.98,14.97 R355.1 207.16,13.28 207.16,12.4 206.9,12.15 206.9,11.2 206.13,10.42 201.11,10.42 200.63,9.94 198.53,9.94 v2(197.9,10.57) ; PCH1.AN22 40.24,95.82 v3(40.67,95.82)
  BOTTOM w0.102: v2(197.9,10.57) 197.01,11.46 187.92,11.46 187.16,10.7 161.54,10.7 161.26,10.98 144.66,10.98 140.9,14.74 92.77,14.74 v2(92.23,14.21) ; v3(40.67,95.82) 40.26,95.4 38.58,95.4 38.05,94.88 36.9,94.88 35.5,93.48 32.83,93.48 30.44,91.09 26.83,91.09 v1(26.19,91.73) 24.19,91.73 22.66,93.25 15.88,93.25 13.47,90.84 13.47,87.6 12.8,86.93 10.88,86.93 6.82,82.87 6.15,82.2 5.87,81.92 5.87,75.32 9.28,71.91 9.28,71.22 7.58,69.52 7.58,63.42 8.39,62.61 8.39,60.59 2.7,54.9 2.7,38.06 3.44,37.32 3.44,31.25 1.02,28.83 1.02,3.65 2.71,1.95 3.65,1.02 85.52,1.02 v2(88.42,3.92)
LPCPD_L: length 279.1
  TOP w0.102: v2(44.8,82.76) 45.01,82.97 45.01,86.15 45.05,86.19 45.05,86.69 44.99,86.8 44.9,87.15 44.9,87.72 PCH1.AD37 ; R416.2 R405.1 224.54,5.8 223.76,5.02 v2(223.76,4.29) ; v2(68.71,62.36) 67.32,63.76 60.88,63.76 59.38,62.26 52.03,62.26 48.6,58.83 44.3,58.83 43.09,60.05 43.09,64.93 42.76,65.25 42.76,66.77 43.09,67.09 43.09,67.85 43.34,68.1 43.34,69.68 44.66,71 44.66,73.21 44.25,73.62 v2(44.25,76.11) ; v2(67.47,58.25) 68.41,59.19 71.29,59.19 72.1,58.38 76.21,58.38 77.96,56.63 77.96,47.97 81.65,44.28 86.83,44.28 88.12,42.99 88.12,33.34 89.49,31.97 89.49,23.39 85.61,19.51 85.61,14.6 88.3,11.9 v2(88.3,10.57)
  BOTTOM w0.102: v2(88.3,10.57) 88.35,10.52 88.35,7.44 92.7,3.08 103.09,3.08 105.91,5.9 109.74,5.9 v1(110.4,5.24) 111.06,4.58 113.49,4.58 115.65,2.42 115.86,2.21 221.26,2.21 223.34,4.29 v2(223.76,4.29) ; v2(44.25,76.11) 44.58,76.44 44.58,80.58 45.22,81.21 45.22,82.34 v2(44.8,82.76) ; v2(68.71,62.36) 68.71,59.49 v2(67.47,58.25)
LPCPDL: length 33.5
  TOP w0.102: U23.28 228.85,25.34 228.63,25.56 227.43,25.56 v1(226.54,24.67) 226.02,24.15 226.02,17.42 225.58,16.99 225.58,15.78 225.9,15.46 226.87,15.46 229.43,12.9 230.57,12.9 231.64,11.82 231.64,9.4 231.03,8.79 231.03,5.99 229.65,4.6 225.53,4.6 R403.1 R405.2
LPT_ACK_L: length 66.6
  TOP w0.102: v2(222.16,17.3) 221.9,17.56 221.9,18.18 222.87,19.15 222.87,19.15 222.89,19.18 222.89,19.18 222.93,19.22 222.93,19.35 223.49,19.91 U21.107 ; v2(186.85,12.07) 185.68,13.24 185.68,14.55 184.98,15.25 179.08,15.25 178.73,14.9 RN29.5 178.73,13.75 178.58,13.61 177.18,13.61 176.18,12.61 176.18,11.59 176.75,11.02 CN1.2 177.03,10.04 177.03,5.6 LPT.10
  BOTTOM w0.102: v2(222.16,17.3) 220.35,15.5 211.08,15.5 208.69,13.11 202.47,13.11 201.73,12.38 187.15,12.38 v2(186.85,12.07)
LPT_AFD_L: length 73.1
  TOP w0.102: v2(158.4,12.1) 157.89,12.61 RN30.5 ; v2(220.89,18.17) 221.39,18.68 221.39,19.4 221.39,19.72 222.99,21.32 222.99,21.75 223.16,21.91 U21.111
  BOTTOM w0.102: v2(158.4,12.1) 158.4,12.48 v1(158.91,12.99) 159.32,13.4 168.96,13.4 169.74,14.18 178.49,14.18 182.62,14.18 183.1,14.66 200.73,14.66 201.52,15.45 207.79,15.45 210.13,17.79 211.27,17.79 212.46,18.98 219.03,18.98 219.95,18.07 220.78,18.07 v2(220.89,18.17)
LPT_BUSY: length 66.3
  TOP w0.102: U21.106 223.5,19.41 222.47,18.38 v2(222.47,18.07) ; v2(186.19,11.74) 186.19,12.05 185.45,12.78 185.45,14.45 184.89,15.02 179.36,15.02 179.23,14.89 RN29.3 179.23,13.88 179.48,13.62 180.06,13.62 180.2,13.49 180.2,12.48 179.71,12 179.38,12 178.82,11.44 CN1.4 178.82,10.47 178.54,10.19 177.58,10.19 177.26,9.88 177.26,5.96 LPT.11
  BOTTOM w0.102: v2(186.19,11.74) 186.44,11.49 186.97,11.49 187.63,12.15 201.28,12.15 201.9,11.53 202.34,11.53 203.68,12.86 208.76,12.86 211.17,15.27 220.89,15.27 222.66,17.05 222.66,17.88 v2(222.47,18.07)
LPT_D0: length 74.3
  TOP w0.102: v2(219.93,18.77) 220.48,18.77 220.59,18.88 220.61,18.88 220.94,19.21 220.94,19.91 221.07,20.04 222.41,21.38 222.41,22.33 222.99,22.91 U21.113 ; RN30.3 157.39,12.35 v2(157.64,12.1)
  BOTTOM w0.102: v2(219.93,18.77) 219.93,18.89 219.62,19.21 212.37,19.21 211.17,18.02 210.04,18.02 208.56,16.54 v1(207.91,16.54) 207.04,15.68 201.43,15.68 200.64,14.89 183,14.89 182.52,14.41 179.35,14.41 169.64,14.41 168.86,13.63 158.15,13.63 157.64,13.11 v2(157.64,12.1)
LPT_D1: length 74.6
  TOP w0.102: v2(220.4,19.36) 220.4,19.7 220.71,20 222.18,21.47 222.18,22.53 223.06,23.41 U21.114 ; RN30.1 v2(156.81,12.12)
  BOTTOM w0.102: v2(220.4,19.36) 220.3,19.46 212.3,19.46 211.08,18.24 209.89,18.24 209.56,17.91 208.33,17.91 206.32,15.91 201.33,15.91 200.54,15.12 182.91,15.12 182.43,14.64 179.25,14.64 178.68,14.64 178.68,14.64 169.55,14.64 168.77,13.85 157.75,13.85 v1(157,13.11) 156.81,12.92 v2(156.81,12.12)
LPT_D2: length 67.1
  TOP w0.102: RN34.5 165,12.23 v2(165.26,11.97) ; U21.115 223.05,23.91 221.95,22.81 221.95,21.59 219.17,18.81 219.17,18.04 v2(218.43,17.3)
  BOTTOM w0.102: v2(165.26,11.97) 165.76,12.48 169.33,12.48 170.12,13.27 178.11,13.27 183.12,13.27 183.6,13.75 201.16,13.75 201.93,14.51 208.15,14.51 210.51,16.87 211.65,16.87 212.79,18.02 217.85,18.02 218.18,17.69 218.18,17.56 v2(218.43,17.3)
LPT_D3: length 68.7
  TOP w0.102: U21.116 222.77,24.41 221.65,23.29 221.65,21.61 218.69,18.65 v2(218.69,18.27) ; v2(163.48,11.97) 163.93,12.41 RN34.1
  BOTTOM w0.102: v2(218.69,18.27) 218.49,18.47 212.6,18.47 211.46,17.33 210.32,17.33 207.98,14.99 201.71,14.99 200.92,14.21 183.29,14.21 182.81,13.72 179.63,13.72 179.63,13.72 178.3,13.72 169.93,13.72 169.14,12.94 164.45,12.94 v2(163.48,11.97)
LPT_D4: length 58.5
  TOP w0.102: v2(175.55,11.21) 174.34,12.41 RN31.7 ; U21.117 222.65,24.91 221.39,23.65 221.39,21.68 217.46,17.74 v2(217.46,17.3)
  BOTTOM w0.102: v2(175.55,11.21) 175.8,10.95 182.98,10.95 v1(183.55,11.53) 184.63,12.61 201.64,12.61 202.4,13.37 208.62,13.37 210.98,15.73 215.88,15.73 v2(217.46,17.3)
LPT_D5: length 58.6
  TOP w0.102: RN31.5 173.76,12.1 v2(174.02,11.84) ; v2(216.69,17.3) 216.69,17.31 221.14,21.75 221.14,23.91 222.64,25.41 U21.118
  BOTTOM w0.102: v2(174.02,11.84) 174.51,12.33 183.65,12.33 184.16,12.83 201.54,12.83 202.3,13.6 208.53,13.6 210.89,15.96 215.22,15.96 v1(216.05,16.78) 216.57,17.3 v2(216.69,17.3)
LPT_D6: length 63.2
  TOP w0.102: RN31.3 173.26,11.97 v2(173.13,11.84) ; v2(214.43,17.3) 214.43,18.61 218.09,22.27 218.09,26.24 219.31,27.46 221.62,27.46 223.17,25.91 U21.119
  BOTTOM w0.102: v2(173.13,11.84) 173.84,12.55 183.51,12.55 184.02,13.06 201.45,13.06 202.21,13.82 208.43,13.82 210.8,16.19 214.03,16.19 214.43,16.59 v2(214.43,17.3)
LPT_D7: length 65
  TOP w0.102: v2(213.7,17.3) 213.7,18.2 217.84,22.34 217.84,26.31 219.37,27.85 221.74,27.85 223.17,26.41 U21.120 ; RN31.1 172.69,12.29 v2(172.24,11.84)
  BOTTOM w0.102: v2(172.24,11.84) 171.74,12.35 v1(171.74,12.48) 172.04,12.78 183.41,12.78 183.92,13.29 201.35,13.29 202.12,14.05 208.34,14.05 210.7,16.42 213.21,16.42 213.7,16.9 v2(213.7,17.3)
LPT_ERR_L: length 81.8
  TOP w0.102: RN35.1 155.48,14.26 155.99,13.75 v2(155.99,12.1) 155.43,11.54 CN4.8 156.14,10.31 156.14,7.57 LPT.15 ; U21.110 223.41,21.41 221.9,19.9 v2(221.9,19.53)
  BOTTOM w0.102: v2(221.9,19.53) 221.56,19.87 212.38,19.87 210.98,18.47 209.79,18.47 209.46,18.14 208.23,18.14 206.22,16.14 201.24,16.14 200.45,15.35 182.81,15.35 182.33,14.87 179.16,14.87 179.16,14.87 178.78,14.87 169.45,14.87 168.67,14.08 157.1,14.08 155.99,12.97 v2(155.99,12.1)
LPT_INIT_L: length 65.1
  TOP w0.102: RN34.7 165.58,12.54 v2(166.15,11.97) ; U21.109 223.54,20.91 222.41,19.79 222.41,19.34 221.37,18.3 221.37,17.97 221.09,17.69 221.08,17.69 220.37,16.98 219.5,16.98 v2(219.17,17.3)
  BOTTOM w0.102: v2(219.17,17.3) 218.69,16.82 218.23,16.82 217.95,17.1 217.95,17.59 217.75,17.79 213.35,17.79 v1(212.62,17.06) 212.21,16.64 210.61,16.64 208.24,14.28 202.02,14.28 201.26,13.52 183.7,13.52 183.22,13.04 179.91,13.04 170.21,13.04 169.43,12.25 166.43,12.25 v2(166.15,11.97)
LPT_PE: length 65.2
  TOP w0.102: LPT.12 182.15,5.64 182.15,7.65 181.01,8.8 181.01,10.07 180.88,10.19 179.99,10.19 179.64,10.55 CN1.6 179.64,11.59 180.42,12.38 180.42,13.95 180.25,14.13 179.93,14.13 RN29.1 179.8,14.57 180.02,14.79 184.79,14.79 185.22,14.36 185.22,12.25 v2(185.48,12) ; v2(223.21,17.05) 223.04,17.22 223.04,18.45 223.51,18.91 U21.105
  BOTTOM w0.102: v2(185.48,12) 185.48,11.61 185.83,11.26 187.07,11.26 187.73,11.92 201.19,11.92 201.84,11.27 202.41,11.27 203.72,12.58 208.81,12.58 211.27,15.04 221.1,15.04 223.11,17.05 v2(223.21,17.05)
LPT_SLCT: length 63.6
  TOP w0.102: v2(224,17.18) 223.78,17.18 223.3,17.66 223.3,18.19 223.52,18.41 U21.104 ; LPT.13 182.4,5.89 182.4,9.21 R402.1 181.42,10.19 181.27,10.19 CN1.8 180.45,11.77 180.65,11.97 180.65,14.28 180.93,14.56 184.52,14.56 185,14.09 185,11.41 v2(185.07,11.34)
  BOTTOM w0.102: v2(185.07,11.34) 185.38,11.03 187.16,11.03 187.82,11.69 201.07,11.69 201.74,11.02 202.48,11.02 203.82,12.35 208.9,12.35 211.36,14.82 221.32,14.82 223.07,16.57 223.58,16.57 224,16.99 v2(224,17.18)
LPT_SLIN_L: length 66.6
  TOP w0.102: RN34.3 164.5,12.1 v2(164.37,11.97) ; v2(221.39,17.3) 221.39,17.67 221.6,17.87 221.6,18.2 222.64,19.24 222.64,19.25 222.66,19.27 222.66,19.59 223.49,20.41 U21.108
  BOTTOM w0.102: v2(221.39,17.3) 220.78,16.69 v1(220.35,16.69) 219.74,17.3 219.74,17.43 219.39,17.79 218.4,17.79 217.94,18.24 212.7,18.24 211.55,17.1 210.42,17.1 208.05,14.74 201.83,14.74 201.07,13.98 183.51,13.98 183.03,13.49 179.73,13.49 179.73,13.49 178.21,13.49 178.21,13.49 170.02,13.49 169.24,12.71 165.11,12.71 v2(164.37,11.97)
LPT_STB_L: length 73.3
  TOP w0.102: v2(220.25,17.56) 220.25,18.22 220.69,18.65 220.77,18.65 221.17,19.04 221.17,19.3 221.16,19.81 222.69,21.34 222.69,22.11 222.99,22.41 U21.112 ; v2(159.16,12.1) 159.16,12.73 158.91,12.98 RN30.7
  BOTTOM w0.102: v2(220.25,17.56) 220.12,17.56 218.93,18.75 212.56,18.75 211.36,17.56 210.23,17.56 207.89,15.22 201.62,15.22 200.83,14.43 183.19,14.43 182.71,13.95 179.54,13.95 169.83,13.95 169.05,13.17 161.12,13.17 v1(160.69,12.73) 160.05,12.1 v2(159.16,12.1)
LPTVCC: length 30
  BOTTOM w0.508: v2(153.86,12.12) 154.24,12.12 v1(154.64,11.72) 154.95,11.41 160.74,11.41 v2(161.45,12.12) 162.36,11.21 169.2,11.21 v2(170.09,12.1) 170.97,12.1 171.91,11.16 174.35,11.16 175.09,11.89 177.15,11.89 v2(177.22,11.82) 181.49,11.82 v2(181.72,11.59)
LRST_L: length 6.5
  TOP w0.102: v2(198.38,29.22) 198.61,29.22 199.14,28.69 R358.2 199.3,28.07 199.3,26.75 C393.1 200.18,26.65 200.82,26.02 200.82,25.54 200.95,25.41 U21.49
M_BS_A0: length 56.1
  TOP w0.102: 149.62,105.57 149.62,105.82 150.12,106.32 150.12,107.88 151.12,108.88 151.12,109.43 151.88,110.18 152.22,110.18 152.61,110.57 CPU1.AV12
  TOP w0.165: DIMM4.71 146.74,72.7 146.74,70.21 146.22,69.69 146.22,68.68 147.1,67.8 147.1,65.29 DIMM2.71
  TOP w0.216: 149.62,105.57 149.62,88.47 arc(149.87,88.22) 150.12,88.47 150.12,91.03 arc(150.37,91.28) 150.61,91.03 150.61,82.58 147.43,79.39 147.43,75.73 147.15,75.45 147.15,73.1 DIMM4.71
M_BS_A1: length 52.8
  TOP w0.102: 150.44,105.4 150.44,105.77 150.71,106.03 150.71,107.51 CPU1.AY11
  TOP w0.165: DIMM2.190 147.93,65.64 148.72,66.43 148.72,67.52 147.93,68.31 DIMM4.190
  TOP w0.216: 150.44,105.4 150.44,92.73 151.38,91.8 151.38,89.71 arc(151.62,89.47) 151.87,89.71 151.87,90.31 arc(152.12,90.56) 152.37,90.31 152.37,83.15 148.52,79.32 148.52,75.41 148.69,75.24 148.69,74.32 149.69,73.32 149.69,72.57 149.25,72.13 149.08,72.13 DIMM4.190
M_BS_A2: length 57.2
  TOP w0.102: CPU1.AT21 160.73,112.05 160.73,111.25 160.78,111.2 160.78,110.83 160.73,110.77 160.73,110.31 160.6,110.18 160.6,109.77 161.02,109.36 161.02,107.32 161.5,106.84 161.5,105.9
  TOP w0.165: DIMM2.52 166.12,67.21 166.12,69.68 166.73,70.29 166.73,71.66 166.11,72.28 166.11,74.61 DIMM4.52
  TOP w0.216: DIMM4.52 165.99,74.84 165.99,79.35 167.65,81.01 167.65,84.9 arc(167.89,85.15) 168.14,84.9 168.14,82.25 arc(168.39,82) 168.64,82.25 168.64,91.19 168.03,91.8 168.03,98.08 163.62,102.52 161.5,104.66 161.5,105.9
M_BS_B0: length 90.5
  TOP w0.102: CPU1.AK17 v4(157.88,118.35)
  GND w0.102: 156.97,105.23 157.17,105.43 157.17,107.3 156.86,107.61 156.86,108.25 157.42,108.81 157.42,113.97 157.89,114.44 157.89,115.89 158.34,116.33 158.34,117.89 v4(157.88,118.35)
  GND w0.152: DIMM3.71 146.74,52.72 146.74,50.23 146.22,49.7 146.22,48.64 146.61,48.25 146.61,46.88 147.13,46.36 147.13,42.8 DIMM1.71
  GND w0.178: 156.97,105.23 155,103.26 155,96.4 arc(154.77,96.17) 154.54,96.4 154.54,98.1 arc(154.31,98.33) 154.08,98.1 154.08,83.78 149.32,79.02 149.32,79.01 149.11,78.8 149.11,78.3 149.32,78.09 149.32,76.98 148.42,76.08 148.42,75.57 148.68,75.31 148.68,74.48 147.68,73.48 147.68,72.53 146.68,71.53 146.68,70.58 145.68,69.58 145.68,68.52 146.7,67.51 146.7,66.47 147.68,65.49 147.68,64.52 148.68,63.52 148.68,62.89 147.68,61.88 147.68,59.91 148.64,58.95 148.64,57.18 147.43,55.97 147.43,55.4 147.24,55.21 147.24,53.22 DIMM3.71
M_BS_B1: length 90.3
  TOP w0.102: CPU1.AL18 v4(158.8,116.52)
  GND w0.102: 157.97,107.27 157.97,107.5 158.27,107.8 158.27,109.96 158.57,110.26 158.57,113.85 158.15,114.27 158.15,115.85 158.8,116.5 v4(158.8,116.52)
  GND w0.152: DIMM1.190 147.93,42.97 148.74,43.77 148.74,46.93 147.93,47.74 147.93,51.01 DIMM3.190
  GND w0.178: DIMM3.190 148.13,51.22 148.13,53.33 148.73,53.92 148.73,55.4 149.71,56.38 149.71,61.93 150.68,62.9 150.68,63.52 149.69,64.51 149.69,65.43 148.7,66.43 148.7,67.57 147.7,68.57 147.7,69.64 148.68,70.63 148.68,71.5 149.67,72.49 149.67,73.47 150.68,74.48 150.68,75.52 151.26,76.11 151.26,77.17 150.65,77.78 150.65,78.87 155.02,83.24 155.02,88.02 arc(155.25,88.25) 155.48,88.02 155.48,85.86 arc(155.71,85.63) 155.94,85.86 155.94,102.75 157.97,104.78 157.97,107.27
M_BS_B2: length 84.5
  TOP w0.102: CPU1.AW28 167.13,109.3 167.13,107.82 167.63,107.32 v4(167.63,107.37)
  GND w0.152: 165.9,55.4 165.9,54.86 DIMM3.52 166.15,54.61 166.15,52.25 166.72,51.68 166.72,50.46 166.12,49.86 166.12,48.15 166.35,47.91 166.35,44.92 DIMM1.52
  GND w0.178: v4(167.63,107.37) 167.63,106.69 168.87,105.46 168.87,100.77 174.43,95.21 174.43,81.5 arc(174.66,81.28) 174.89,81.5 174.89,84.94 arc(175.11,85.17) 175.34,84.94 175.34,81.08 171.51,77.25 171.51,74.05 172.7,72.85 172.7,71 171.64,69.93 171.64,66.15 172.7,65.08 172.7,62.75 171.74,61.79 171.74,59.72 169.37,57.36 167.48,57.36 165.9,55.78 165.9,55.4
M_CAS_A_L: length 53.9
  TOP w0.102: 147.55,105.8 147.55,106.2 148.65,107.31 148.65,108.43 149.48,109.26 149.48,110.78 149.22,111.05 149.22,111.65 148.99,111.88 148.43,111.88 CPU1.AU9
  TOP w0.165: DIMM2.74 143.75,67.21 143.75,69.5 142.93,70.31 142.93,71.76 143.65,72.48 143.65,73.19 143.48,73.37 143.48,73.64 143.93,74.1 DIMM4.74
  TOP w0.216: DIMM4.74 143.93,78.93 147.47,82.47 arc(147.47,82.82) 147.11,82.82 146,81.7 arc(145.65,81.7) 145.65,82.05 146.77,83.17 146.77,85.21 147.55,85.99 147.55,105.8
M_CAS_B_L: length 93.4
  TOP w0.102: v4(156.08,113.77) 156.51,114.21 CPU1.AP16
  GND w0.102: 155.25,107.02 155.42,107.19 155.42,108.69 155.3,108.8 155.3,109.58 156.15,110.42 156.15,113.71 v4(156.08,113.77)
  GND w0.152: DIMM1.74 143.75,44.68 143.75,49.54 142.93,50.36 142.93,51.75 143.64,52.45 143.64,53.39 143.59,53.44 143.59,54.47 DIMM3.74
  GND w0.178: 155.25,107.02 153.8,105.57 151.49,103.27 151.49,87.37 145.86,81.73 arc(145.86,81.41) 146.18,81.41 150.53,85.76 arc(150.85,85.76) 150.85,85.44 144.05,78.63 144.05,76.41 143.16,75.51 143.16,74.21 142.17,73.23 142.17,72.35 141.17,71.35 141.17,70.46 140.15,69.45 140.15,68.68 141.16,67.67 141.16,66.67 142.16,65.67 142.16,64.75 143.15,63.76 143.15,62.65 142.15,61.65 142.15,60.56 142.95,59.77 142.95,57.57 144.1,56.42 144.1,54.99 DIMM3.74
M_CKE_A0: length 50
  TOP w0.102: CPU1.AV22 162.03,110.54 162.03,109.35 161.93,109.25 161.93,107.7 162.69,106.94 162.69,105.22 162.85,105.07
  TOP w0.165: DIMM4.50 167.93,79.31 arc(168.14,79.51) 168.34,79.31 168.34,77.35 arc(168.54,77.15) 168.75,77.35 168.75,80.2 171.58,83.04 171.58,90.79 arc(171.38,90.99) 171.18,90.79 171.18,89.36 arc(170.97,89.16) 170.77,89.36 170.77,92.84 169.35,94.27 169.35,98.57 162.85,105.07
M_CKE_A1: length 52.7
  TOP w0.102: CPU1.AT23 162.48,111.76 162.48,111.23 162.35,111.1 162.35,110.33 162.26,110.25 162.26,109.04 162.21,108.99 162.21,107.83 163,107.04 163,105.49 163.23,105.27
  TOP w0.165: DIMM4.169 169.65,69.81 169.65,70.16 169.65,70.51 169.65,79.27 170.92,80.54 arc(170.92,80.83) 170.64,80.83 169.62,79.81 arc(169.33,79.81) 169.33,80.1 171.99,82.76 171.99,92.34 169.83,94.5 169.83,98.66 163.23,105.27
M_CKE_A2: length 57.1
  TOP w0.102: CPU1.AU22 161.82,110.95 161.64,110.77 161.64,110.38 161.76,110.25 161.76,109.51 161.65,109.4 161.65,107.6 162.39,106.86 162.39,104.95 162.52,104.83
  TOP w0.165: 162.52,104.83 168.94,98.4 168.94,93.78 169.55,93.17 169.55,89.7 arc(169.76,89.49) 169.96,89.7 169.96,92.13 arc(170.16,92.34) 170.36,92.13 170.36,89.01 171.1,88.27 171.1,83.22 167.11,79.23 167.11,74.47 168.16,73.43 168.16,72.27 168.82,71.61 168.82,70.37 167.93,69.48 DIMM2.50
M_CKE_A3: length 57.1
  TOP w0.102: 163.64,105.43 163.28,105.79 163.28,109.02 163.13,109.18 162.72,109.18 162.55,109.34 162.55,110.77 162.91,111.13 CPU1.AU23
  TOP w0.165: 163.64,105.43 166.55,102.52 170.24,98.83 170.24,94.93 172.42,92.74 172.42,81.44 172.21,81.22 arc(172.06,81.17) 171.92,81.22 171.72,81.42 arc(171.44,81.42) 171.44,81.13 171.63,80.94 arc(171.69,80.79) 171.63,80.65 170.16,79.18 170.16,65.13 168.93,63.91 DIMM2.169
M_CKE_B0: length 71.3
  TOP w0.102: v4(169.4,104.17) 169.4,105.95 168.45,106.9 168.45,107.6 168.04,108.01 168.04,108.91 CPU1.AW29
  GND w0.14: DIMM3.50 167.93,54.83 168.51,55.4 169.27,55.4 169.97,56.11 169.97,56.41 173.51,59.95 173.51,61.65 174.71,62.85 174.71,63.56 173.66,64.6 173.66,65.62 174.71,66.67 174.71,67.45 173.69,68.47 173.69,69.62 174.71,70.65 174.71,71.37 173.68,72.4 173.68,73.27 172.63,74.32 172.63,77 176.37,80.75 176.37,90.14 arc(176.13,90.38) 175.88,90.14 175.88,87.91 arc(175.64,87.66) 175.39,87.91 175.39,96.15 169.96,101.58 169.96,103.61 v4(169.4,104.17)
M_CKE_B1: length 70.6
  TOP w0.102: CPU1.AY29 168.4,108.27 169.04,107.63 v4(169.04,107.14)
  GND w0.14: v4(169.04,107.14) 169.04,106.97 170.97,105.04 170.97,102.17 176.41,96.73 176.41,95.99 177.3,95.1 177.4,95 177.4,79.71 174.7,77.01 174.7,74.27 175.71,73.27 175.71,72.34 176.71,71.34 176.71,70.63 175.71,69.64 175.71,68.47 176.71,67.47 176.71,66.69 175.71,65.69 175.71,64.57 176.71,63.57 176.71,62.87 175.7,61.86 175.7,60.17 171.35,55.82 171.35,54.98 170.96,54.58 170.31,54.58 169.71,53.98 169.71,49.89 DIMM3.169
M_CKE_B2: length 87.2
  TOP w0.102: CPU1.AU28 167.45,111.49 v3(167,111.05)
  GND w0.14: v3(167,111.05) 167,110.8 167.7,110.1 167.7,109.1 168.38,108.43 168.38,106.95 170.47,104.86 170.47,101.96 175.89,96.54 175.89,91.16 arc(176.13,90.91) 176.38,91.16 176.38,94.33 arc(176.62,94.57) 176.87,94.33 176.87,80.55 173.11,76.8 173.11,74.48 174.13,73.46 174.13,72.59 175.17,71.56 175.17,70.46 174.14,69.43 174.14,68.66 175.17,67.64 175.17,66.48 174.12,65.43 174.12,64.81 175.17,63.76 175.17,62.66 173.97,61.47 173.97,59.41 168.15,53.6 168.15,52.26 168.9,51.51 168.9,50.54 167.92,49.55 167.92,48.3 168.76,47.45 168.76,45.33 DIMM1.50
M_CKE_B3: length 86.6
  TOP w0.102: CPU1.AU29 168.96,110.93 168.96,108.2 169.78,107.37 v4(169.78,107.14)
  GND w0.14: v4(169.78,107.14) 169.78,106.92 171.46,105.24 171.46,102.39 176.92,96.93 176.92,96.17 177.91,95.18 177.91,79.34 176.47,77.91 arc(176.4,77.74) 176.47,77.56 177.32,76.72 arc(177.32,76.38) 176.97,76.38 176.13,77.22 arc(175.96,77.29) 175.78,77.22 175.46,76.9 175.46,75.79 175.16,75.49 175.16,74.46 176.16,73.46 176.16,72.53 177.16,71.53 177.16,70.45 176.17,69.45 176.17,68.66 177.17,67.66 177.17,66.5 176.17,65.5 176.17,64.75 177.17,63.76 177.17,62.68 176.16,61.67 176.16,58.99 170.11,52.94 170.11,47.72 169.8,47.4 169.8,42.03 168.93,41.17 DIMM1.169
M_CLK_A_N0: length 48.6
  TOP w0.102: 155.63,106.18 155.56,106.26 155.56,106.76 156.15,107.35 156.15,108.55 156.34,108.74 CPU1.AY16
  TOP w0.178: 156.68,75.52 156.94,75.26 156.94,74.13 156.46,73.66
  TOP w0.203: 156.68,75.52 156.52,75.68 156.52,80.21 157.86,81.56 arc(158.06,82.04) 157.86,82.53 157.47,82.92 arc(157.37,83.17) 157.47,83.42 157.47,83.42 arc(157.72,83.52) 157.97,83.42 158.36,83.03 arc(158.85,82.83) 159.33,83.03 160.36,84.06 160.36,88.54 160.03,88.87 160.03,89.91 160.28,90.17 160.28,96.3 155.63,100.95 155.63,106.18 ; 156.46,73.66 156.31,73.5 156.14,73.33 156.14,72.43 155.16,71.46 155.16,70.37 153.89,69.09 DIMM4.185
M_CLK_A_N1: length 49.7
  TOP w0.102: CPU1.AV15 155.6,110.18 155.52,110.11 155.29,110.11 155.04,109.85 155.04,108.46 155.26,108.24 155.26,107.78 154.26,106.79 154.26,106.26 154.19,106.19
  TOP w0.203: 154.19,106.19 154.19,100.29 155.84,98.65 155.84,96.5 arc(156.04,96.01) 156.52,95.81 157.66,95.81 arc(158.02,95.46) 157.66,95.1 156.52,95.1 arc(155.84,94.41) 156.52,93.73 157.66,93.73 arc(158.02,93.37) 157.66,93.02 156.52,93.02 arc(155.84,92.33) 156.52,91.65 157.68,91.65 arc(158.04,91.29) 157.68,90.93 156.52,90.93 arc(156.04,90.73) 155.84,90.25 155.84,81.68 154.84,80.68 154.84,74.53 154.66,74.35 154.37,74.35 DIMM4.64
M_CLK_A_N2: length 56.5
  TOP w0.102: CPU1.AW14 154.68,109.89 154.55,110.02 154.41,110.02 154.33,109.94 154.33,108.46 154.1,108.23 154.1,107.31 153.33,106.54 153.33,106.25 153.39,106.18 153.39,106.17
  TOP w0.203: DIMM2.185 153.47,61.86 154.18,61.86 155.11,62.78 155.11,63.67 156.02,64.58 156.02,65.9 155.2,66.72 155.2,67.46 154.47,68.18 152.66,68.18 152.2,68.65 152.2,69.72 153.04,70.56 153.04,71.25 154,72.22 154,73.51 153.19,74.33 153.19,75.52 153.45,75.78 153.45,80.4 154.92,81.87 154.92,98.43 153.39,99.96 153.39,106.17
M_CLK_A_N3: length 55.7
  TOP w0.102: CPU1.AY13 153.77,109.14 153.68,109.23 153.58,109.23 153.41,109.06 153.41,107.69 152.18,106.46 152.18,106.17 152.23,106.12
  TOP w0.203: DIMM2.64 154.03,66.93 154.03,65.35 153.77,65.09 153.77,64.66 153.42,64.32 152.52,64.32 152.15,64.68 152.15,65.63 151.19,66.59 151.19,67.56 150.2,68.55 150.2,69.56 151.12,70.48 151.12,71.35 152.18,72.41 152.18,73.4 151.07,74.51 151.07,79.67 153.83,82.43 153.83,94.37 152.23,95.96 152.23,96.3 arc(152.34,96.55) 152.58,96.65 152.8,96.65 arc(153.28,96.84) 153.47,97.32 153.47,97.34 arc(153.27,97.83) 152.78,98.03 152.6,98.03 arc(152.34,98.14) 152.23,98.39 152.23,106.12
M_CLK_A_P0: length 48.6
  TOP w0.102: 155.3,106.18 155.35,106.23 155.35,106.84 155.94,107.43 155.94,108.69 155.89,108.74 CPU1.AY15
  TOP w0.178: 156.46,75.3 156.46,75.28 156.66,75.09 156.66,74.25 156.36,73.95 156.34,73.95 156.29,73.95
  TOP w0.203: 156.29,73.95 155.81,73.47 155.81,72.57 154.83,71.59 154.83,70.5 154.08,69.75 153.84,69.75 153.65,69.93 153.65,70.19 153.85,70.39 153.93,70.47 DIMM4.184 ; 155.3,106.18 155.3,100.81 159.95,96.16 159.95,90.3 159.7,90.05 159.7,88.73 160.03,88.4 160.03,84.19 159.1,83.26 arc(158.85,83.16) 158.6,83.26 158.21,83.65 arc(157.72,83.85) 157.24,83.65 157.24,83.65 arc(157.04,83.17) 157.24,82.68 157.63,82.29 arc(157.73,82.04) 157.63,81.79 156.19,80.35 156.19,75.58 156.46,75.3
M_CLK_A_P1: length 49.7
  TOP w0.102: CPU1.AW15 155.6,109.82 155.52,109.9 155.38,109.9 155.24,109.77 155.24,108.55 155.46,108.33 155.46,107.7 154.46,106.7 154.46,106.25 154.52,106.19
  TOP w0.203: 154.52,106.19 154.52,100.43 156.17,98.78 156.17,96.5 arc(156.27,96.25) 156.52,96.14 157.66,96.14 arc(158.35,95.46) 157.66,94.77 156.52,94.77 arc(156.17,94.41) 156.52,94.06 157.66,94.06 arc(158.35,93.37) 157.66,92.69 156.52,92.69 arc(156.17,92.33) 156.52,91.98 157.68,91.98 arc(158.37,91.29) 157.68,90.6 156.52,90.6 arc(156.27,90.5) 156.17,90.25 156.17,81.54 155.17,80.54 155.17,74.4 154.96,74.19 154.96,72.91 DIMM4.63
M_CLK_A_P2: length 56.5
  TOP w0.102: CPU1.AV14 154.68,110.57 154.12,110.02 154.12,108.55 153.89,108.32 153.89,107.39 153.12,106.62 153.12,106.25 153.06,106.18 153.06,106.17
  TOP w0.203: 153.06,106.17 153.06,99.83 154.59,98.3 154.59,82.01 153.12,80.54 153.12,75.91 152.86,75.65 152.86,74.19 153.67,73.38 153.67,72.35 152.71,71.39 152.71,70.7 151.87,69.86 151.87,68.51 152.53,67.85 154.34,67.85 154.87,67.32 154.87,66.58 155.69,65.76 155.69,64.71 154.78,63.81 154.78,62.92 154.05,62.19 153.71,62.19 153.48,62.41 153.48,62.79 153.92,63.22 DIMM2.184
M_CLK_A_P3: length 55.7
  TOP w0.102: 151.9,106.13 151.98,106.2 151.98,106.55 153.21,107.78 153.21,109.14 153.5,109.43 153.73,109.43 153.78,109.48 153.78,109.65 CPU1.AW13
  TOP w0.203: DIMM2.63 154.84,65.22 154.37,65.22 154.1,64.95 154.1,64.52 153.56,63.99 152.38,63.99 151.82,64.54 151.82,65.49 150.86,66.45 150.86,67.43 149.87,68.41 149.87,69.69 150.79,70.61 150.79,71.48 151.85,72.54 151.85,73.27 150.74,74.38 150.74,79.81 153.5,82.57 153.5,94.23 151.9,95.83 151.9,96.3 arc(152.1,96.78) 152.58,96.98 152.8,96.98 arc(153.04,97.08) 153.14,97.32 153.14,97.34 arc(153.04,97.59) 152.78,97.7 152.6,97.7 arc(152.11,97.9) 151.9,98.39 151.9,106.13
M_CLK_B_N0: length 80.1
  TOP w0.191: CPU1.AM21 v4(161.54,116.52)
  GND w0.102: v4(161.54,116.52) 161.4,116.52 161.32,116.43 161.32,115.78 162.15,114.95 162.15,111.39 161.73,110.97 161.73,103.87 161.78,103.82
  GND w0.165: 156.83,55.38 156.92,55.29 156.92,54.3
  GND w0.178: 161.78,103.82 161.78,96.73 164.35,94.16 164.35,93.46 arc(164.15,92.99) 163.68,92.79 163.56,92.79 arc(163.37,92.71) 163.29,92.52 163.29,92.35 arc(163.37,92.17) 163.55,92.09 163.58,92.09 arc(164.24,91.43) 163.58,90.76 163.56,90.76 arc(163.37,90.68) 163.29,90.49 163.29,90.32 arc(163.37,90.14) 163.55,90.06 163.68,90.06 arc(164.15,89.87) 164.35,89.39 164.35,82.24 159.11,77.01 159.11,74.39 158.1,73.38 158.1,72.5 159.08,71.52 159.08,70.39 158.13,69.44 158.13,68.63 159.04,67.73 159.04,66.4 158.11,65.47 158.11,64.76 159.09,63.78 159.09,62.58 158.05,61.54 158.05,60.57 156.62,59.15 156.62,55.58 156.83,55.38 ; 156.92,54.3 156.92,54.28 156.03,53.39 156.03,52.4 155.18,51.55 155.18,50.42 154.16,49.4 153.2,49.4 152.93,49.12 DIMM3.185
M_CLK_B_N1: length 75.6
  TOP w0.191: CPU1.AP21 161.06,114.23 160.6,113.77 v4(160.59,113.77)
  GND w0.102: v4(160.59,113.77) 160.87,113.77 161.06,113.58 161.06,113.31 160.87,113.12 160.87,111.03 160.45,110.61 160.45,102.49 160.39,102.43
  GND w0.178: DIMM3.64 153.93,54.46 154.17,54.22 154.48,54.22 154.9,54.64 154.9,55.85 155.24,56.2 155.24,59.93 155.8,60.49 155.8,61.9 156.72,62.82 156.72,63.63 155.73,64.62 155.73,65.56 156.77,66.6 156.77,67.45 155.77,68.45 155.77,69.6 156.85,70.68 156.85,71.17 155.77,72.25 155.77,73.48 156.76,74.47 156.76,79.13 158.47,80.84 arc(158.95,81.04) 159.42,80.84 159.77,80.5 arc(160.01,80.39) 160.26,80.5 arc(160.36,80.74) 160.26,80.99 159.94,81.31 arc(159.94,82.25) 160.89,82.25 161.2,81.93 arc(161.45,81.83) 161.7,81.93 arc(161.8,82.18) 161.7,82.43 161.35,82.78 arc(161.15,83.25) 161.35,83.72 161.61,83.98 161.61,84.98 arc(161.81,85.45) 162.28,85.64 162.59,85.64 arc(162.83,85.75) 162.94,85.99 162.94,86.02 arc(162.84,86.25) 162.62,86.34 162.28,86.34 arc(161.61,87.01) 162.28,87.68 162.59,87.68 arc(162.83,87.78) 162.94,88.02 162.94,88.06 arc(162.84,88.28) 162.62,88.37 162.28,88.37 arc(161.81,88.57) 161.61,89.04 161.61,94.64 160.39,95.86 160.39,102.43
M_CLK_B_N2: length 88.9
  TOP w0.191: v4(160.64,115.6) 160.62,115.6 CPU1.AN21
  GND w0.102: v4(160.64,115.6) 160.62,115.6 160.27,115.25 160.27,115.1 160.46,114.91 160.46,114.41 160.14,114.09 160.14,113.35 160.39,113.1 160.39,111.59 159.96,111.16 159.96,103.02 159.63,102.68 159.63,102.6 159.61,102.59
  GND w0.178: 159.61,102.59 159.48,102.45 159.48,95.49 160.68,94.29 160.68,84.61 155.17,79.1 155.17,74.45 154.11,73.39 154.11,72.54 155.08,71.57 155.08,70.55 154.11,69.58 154.11,68.66 155.05,67.71 155.05,66.38 154.14,65.47 154.14,64.7 155.07,63.77 155.07,62.67 154.15,61.74 154.15,56.99 153.07,55.91 153.07,54.33 154.07,53.32 154.07,52.39 152.99,51.31 152.99,50.43 152.18,49.61 152.18,47.98 155.11,45.05 155.11,44.06 156.04,43.14 156.04,42.13 155.18,41.27 155.18,40.18 154.37,39.37 153.5,39.37 DIMM1.185
M_CLK_B_N3: length 88.7
  TOP w0.191: v4(159.74,114.69) 160.17,114.26 CPU1.AP20
  GND w0.102: v4(159.74,114.69) 159.39,114.35 159.39,113.53 159.28,113.42 159.28,103.83 159.19,103.75 159.19,103.66 159.14,103.61
  GND w0.178: 159.14,103.61 157.46,101.93 157.46,93.73 arc(157.51,93.56) 157.63,93.43 arc(157.71,93.39) 157.81,93.38 158.32,93.38 arc(158.99,92.71) 158.32,92.04 157.81,92.04 arc(157.76,92.04) 157.71,92.03 arc(157.53,91.9) 157.46,91.69 157.46,83.15 153.73,79.42 153.73,75.94 153.08,75.29 153.08,74.29 152.15,73.36 152.15,72.49 153.11,71.54 153.11,70.49 152.08,69.47 152.08,68.64 153.07,67.65 153.07,66.51 152.14,65.59 152.14,64.73 153.09,63.78 153.09,62.67 151.96,61.54 151.96,56.35 151.1,55.49 151.1,54.45 152.08,53.47 152.08,52.36 151.12,51.4 151.12,50.52 150.09,49.48 150.09,48.55 151.21,47.43 151.21,46.69 150.49,45.98 150.49,45.51 151.1,44.9 151.1,44.11 152.08,43.14 152.08,42.05 152.57,41.56 153.32,41.56 153.66,41.9 153.66,42.57 153.93,42.85 DIMM1.64
M_CLK_B_P0: length 80.1
  TOP w0.191: CPU1.AM20 v4(160.62,116.52)
  GND w0.102: v4(160.62,116.52) 160.62,116.52 161.12,116.03 161.12,115.7 161.95,114.87 161.95,111.48 161.53,111.06 161.53,103.88 161.46,103.82
  GND w0.165: 156.63,54.44 156.63,55.13
  GND w0.178: 156.63,55.13 156.31,55.45 156.31,59.28 157.73,60.7 157.73,61.67 158.77,62.71 158.77,63.65 157.79,64.63 157.79,65.6 158.72,66.53 158.72,67.6 157.81,68.5 157.81,69.57 158.76,70.52 158.76,71.38 157.78,72.37 157.78,73.51 158.8,74.53 158.8,77.14 164.03,82.38 164.03,89.39 arc(163.93,89.64) 163.68,89.74 163.55,89.74 arc(163.14,89.91) 162.97,90.32 162.97,90.49 arc(163.15,90.9) 163.56,91.08 163.58,91.08 arc(163.93,91.43) 163.58,91.78 163.55,91.78 arc(163.14,91.94) 162.97,92.35 162.97,92.52 arc(163.15,92.94) 163.56,93.11 163.68,93.11 arc(163.93,93.21) 164.03,93.46 164.03,94.03 161.46,96.6 161.46,103.82 ; 156.63,54.44 155.71,53.52 155.71,52.53 154.86,51.68 154.86,50.55 154.03,49.72 153.8,49.72 153.69,49.82 153.69,50.78 DIMM3.184
