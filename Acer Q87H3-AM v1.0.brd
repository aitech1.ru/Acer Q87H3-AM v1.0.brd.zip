# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FP_RST_L_R: length 23.7
  TOP w0.102: CPU1.G40 179.43,138.92 181.26,140.75 v2(193.45,140.75) 195.23,142.53 199.58,142.53 R58.2
FRAME_L: length 17.4
  TOP w0.127: PCI.A34 47.03,160.8 v2(49.05,158.78) ; U11.71 49.76,152.49 v2(49.31,152.94) 48.93,152.56 48.93,152.37 48.84,152.28 48.84,151.96 48.39,151.51 R288.1
  BOTTOM w0.127: v2(49.05,158.78) 49.05,153.19 v2(49.31,152.94)
FRONT_JD: length 100.9
  TOP w0.254: R499.2 v2(25.91,218.19) ; v2(74.2,242.6) 73.44,243.36 31.27,243.36 28.15,240.24 28.15,231.17 28.86,230.46 28.86,226.09 v2(29.12,225.84)
  BOTTOM w0.254: v2(74.2,242.6) 74.38,242.78 85.37,242.78 87.79,240.36 87.79,236 90.71,233.08 94.65,233.08 95.2,232.53 AUDIO.2Q ; v2(25.91,218.19) 26.45,218.73 26.45,222.87 29.12,225.54 v2(29.12,225.84)
FRONT_L: length 75.2
  TOP w0.254: R528.1 69.53,237.55 FB13.1 69.29,237.78 68.18,238.89 68.18,240.52 69.12,241.46 v2(69.12,241.59) ; Q1.C1 9.48,237.44 9.48,237.06 9.43,237.01 9.43,235.78 9.33,235.68 9.33,234.42 R484.1 9.81,234.19 10.07,234.44 v2(10.07,235.1)
  BOTTOM w0.254: v2(69.12,241.59) 69.12,241.97 67.72,243.36 17.94,243.36 v1(11.46,236.89) 10.07,235.49 v2(10.07,235.1)
FRONT_L1: length 13.6
  TOP w0.254: CODEC.35 16.2,226.18 15.4,226.98 13.23,226.98 12.34,227.87 9.32,227.87 7.79,226.35 6.53,226.35 EC15.1
FRONT_L2: length 10.2
  TOP w0.254: R484.2 8.53,232.2 8.53,230.75 8.19,230.41 8.19,229.29 7.02,228.12 v2(6.51,228.12)
  BOTTOM w0.254: EC15.2 6.51,226.33 v2(6.51,228.12)
FRONT_L_P: length 4.5
  TOP w0.254: R483.2 11.28,239.46 v2(11.96,238.78) 11.96,237.43 11.28,236.75 10.95,236.75 10.7,236.51 Q1.B1
FRONT_LL: length 52.1
  TOP w0.254: 87.98,221.24 88.19,221.44 89.87,221.44 93.89,225.46 93.89,230.54 92.7,231.72 AUDIO.21 ; 87.98,221.24 87.98,222.35 v2(89.69,224.06) ; 87.98,221.24 D25.2 ; v2(73.82,237.78) 73.79,237.74 C535.1 72.01,237.78 FB13.2
  BOTTOM w0.254: v2(89.69,224.06) 89.69,226.09 86.52,229.27 86.52,239.55 85.63,240.44 76.99,240.44 74.33,237.78 v2(73.82,237.78)
FRONT_R: length 99.3
  TOP w0.254: Q1.C2 11.35,235.49 v2(10.95,235.1) 10.83,234.97 10.83,234.32 R485.1 ; v2(74.96,239.94) 75.35,240.32 82.56,240.32 86.44,236.44 86.44,231.01 83.47,228.04 83.47,226.35 82.96,225.84 82.07,225.84 81.69,225.46 R529.1 81.73,224.63 FB14.1
  BOTTOM w0.254: v2(10.95,235.1) 12.08,236.22 13.34,236.22 v1(14.13,237.01) 19.97,242.86 65.9,242.86 68.82,239.94 v2(74.96,239.94)
FRONT_R1: length 18.1
  TOP w0.254: CODEC.36 15.62,225.87 15.02,226.47 13.02,226.47 12.13,227.36 9.53,227.36 9.05,226.89 9.05,222.41 5.26,218.62 EC16.1
FRONT_R2: length 21.1
  TOP w0.254: R485.2 9.25,231.79 v2(9.25,231.12)
  BOTTOM w0.254: EC16.2 3.68,222.29 3.68,227.2 5.88,229.39 7.96,229.39 8.31,229.75 8.31,230.56 8.87,231.12 v2(9.25,231.12)
FRONT_R_P: length 2.5
  TOP w0.254: Q1.B2 10.7,238.95 R486.2 v1(9.3,239.46)
FRONT_RR: length 25.5
  TOP w0.254: AUDIO.24 99.84,231.79 96.43,228.38 96.43,225.2 91.29,220.07 86.95,220.07 86.08,220.95 D25.1 86.08,221.33 84.33,223.08 C536.1 83.12,223.08 FB14.2
FSET: length 32.1
  TOP w0.178: 53.82,36.42 53.41,36.01 53.28,36.01 53.12,35.85 U41.18
  TOP w0.508: R936.1 54.9,37.5 v2(54.52,37.12) 53.82,36.42
  TOP w0.635: v2(78.77,37.75) 78.77,40.55 R925.2
  BOTTOM w0.635: v2(78.77,37.75) 77.81,38.72 71.36,38.72 70.52,37.88 v1(65.56,37.88) 63.89,37.88 63.12,37.11 54.51,37.11 v2(54.52,37.12)
FSET_R: length 17.5
  TOP w0.635: QD3L1.G 74.39,55.53 v2(75.34,55.53) ; R925.1 77.5,43.59 77.5,45.24 75.72,47.02 QD3L2.G v2(74.26,47.98)
  BOTTOM w0.635: v2(75.34,55.53) 75.22,55.4 74.71,55.4 73.95,54.64 v1(73.95,50.25) 73.95,48.29 v2(74.26,47.98)
FW_CE_N: length 45.3
  TOP w0.102: v2(226.73,39.53) 225.97,40.29 225.97,42.58 226.04,42.65 226.04,42.65 227.49,44.11 230.39,44.11 230.86,44.58 R368.1 232.06,44.69 233.2,45.83 238.59,45.83 238.92,45.5 ROM1.1 ; U21.30 v2(207.98,31.02)
  BOTTOM w0.102: v2(207.98,31.02) 208.54,31.58 v1(209.89,31.58) 210.4,32.09 222.46,32.09 225.18,34.81 225.69,34.81 227.21,36.33 227.21,36.83 227.21,39.18 226.86,39.53 v2(226.73,39.53)
FW_HOLD_L: length 5.5
  TOP w0.102: v2(240.67,41.08) 240.67,40.11 R367.1 239.75,40.32 237.95,40.32 237.65,40.01 ROM1.7
FW_SCK: length 34.9
  TOP w0.102: ROM1.6 236.38,40.16 236.12,40.42 RN26.3 233.11,40.42 232.85,40.16 232.85,39.61 232.26,39.02 231.17,39.02 230.28,38.13 226.07,38.13 v2(225.46,37.52) ; v2(211.69,33.81) 211.46,33.59 210.65,33.59 209.51,34.73 209.51,35.89 R349.1
  BOTTOM w0.102: v2(225.46,37.52) 224.64,36.71 224.64,35.83 221.99,33.18 217.96,33.18 v1(217.58,33.56) 217.2,33.18 212.38,33.18 211.74,33.81 v2(211.69,33.81)
FW_SCK_R: length 4.5
  TOP w0.102: R349.2 208.69,34.99 v1(208.69,34.2) 209.72,34.2 210.48,33.43 U21.25
FW_SI: length 3.9
  TOP w0.102: ROM1.5 235.11,39.53 234.79,39.85 RN26.1 233.46,38.64 R347.1
FW_SI_SH: length 25.8
  TOP w0.102: v2(227.69,37.62) 230.92,37.62 R347.2 ; U21.24 v2(210.98,31.02)
  BOTTOM w0.102: v2(210.98,31.02) 212,31.02 v1(212.25,31.27) 212.83,31.86 222.56,31.86 225.27,34.58 225.78,34.58 227.69,36.49 v2(227.69,37.62)
FW_SMBCLK: length 17.4
  TOP w0.102: v2(205.01,26.83) 204.76,26.83 203.36,25.43 203.36,24.67 203.1,24.41 U21.51 ; v2(201.33,33.05) 201.33,31.88 202.09,31.12 203.33,31.12 204.7,29.75 205.26,29.75 v2(205.77,29.24)
  BOTTOM w0.102: v2(205.77,29.24) 205.77,28.59 SR52.1 204.08,26.83 v2(205.01,26.83) ; v2(201.33,33.05) 201.12,33.26 FW_DEBUG.2
FW_SMBDA: length 21.1
  TOP w0.102: v2(200.44,33.05) 200.44,31.91 201.45,30.89 203.23,30.89 204.88,29.24 v2(205.01,29.24) ; v2(204.76,25.56) 203.87,25.56 203.59,25.28 203.59,24.39 203.11,23.91 U21.52
  BOTTOM w0.102: v2(204.76,25.56) 204.7,25.62 204.31,25.62 203.96,25.97 203.11,25.97 202.85,26.22 SR51.1 202.57,26.86 202.42,27.01 202.42,28.17 202.98,28.73 204.5,28.73 v2(205.01,29.24) ; FW_DEBUG.1 198.58,34.91 v2(200.44,33.05)
FW_SOUT: length 47.8
  TOP w0.102: v2(228.25,39.5) 228.48,39.5 230.92,41.94 232.95,41.94 233.39,41.5 RN26.7 234.54,41.5 234.86,41.82 234.86,42.45 234.47,42.83 R365.1 ; v2(205.49,25.23) 205.66,25.39 205.66,27.05 205.39,27.31 204.35,27.31 202.95,25.91 U21.48
  BOTTOM w0.102: v2(228.25,39.5) 228.66,39.09 228.66,36.45 226.07,33.87 225.63,33.87 222.91,31.15 217.72,31.15 215.92,29.34 209.57,29.34 208.47,28.25 207.98,28.25 v1(207.5,27.77) 207.11,27.38 207.11,27.05 205.49,25.43 v2(205.49,25.23)
FW_SOUT_SH: length 7.5
  TOP w0.102: R365.2 234.47,45.5 237.4,45.5 237.65,45.24 ROM1.2 237.65,42.98 v2(237.4,42.73)
FW_WP_L: length 5.5
  TOP w0.102: RN26.5 234.95,40.92 236.38,42.35 ROM1.3
G1_BOOT: length 11
  TOP w0.203: U39.18 232.97,151.53 233.43,151.06
  TOP w0.635: 233.43,151.06 234.5,151.06 237.52,154.08 v1(237.52,155.1) R825.2
G1_BOOT_R: length 1.5
  TOP w0.635: C739.2 R825.1
G1_LG: length 123.3
  TOP w0.203: U39.21 230.91,152.93 231.17,153.19
  TOP w0.635: 231.17,153.19 231.78,153.19 v2(233.97,155.39) ; v2(152.81,183.93) 151.29,183.93 R822.2
  BOTTOM w0.635: v2(233.97,155.39) 235.74,157.16 235.74,180.69 228.26,188.17 215.83,188.17 213.25,190.75 160.22,190.75 v1(159.29,189.82) 155.94,186.47 154.97,186.47 152.81,184.31 v2(152.81,183.93)
G1_UG: length 105.9
  TOP w0.203: U39.20 231.96,152.33 232.7,153.07 233.26,153.07 233.59,153.39
  TOP w0.635: v2(234.6,178.28) 236.53,176.35 236.53,163.51 235.11,162.08 235.11,154.91 233.59,153.39 ; v2(168.69,182.79) 168.69,181.44 R813.2
  BOTTOM w0.635: v2(168.69,182.79) 168.94,183.04 168.94,185.66 v1(169.91,186.62) 171.88,188.59 211.76,188.59 214.63,185.72 227.16,185.72 v2(234.6,178.28)
G1_UG_R: length 7.1
  TOP w0.635: QCH1.G 165.2,184.88 166.66,183.42 166.66,181.19 166.48,181.01 R821.1
G2_BOOT: length 5.8
  TOP w0.203: U39.22 229.91,153.32 230.66,154.08
  TOP w0.635: R834.2 233.46,156.62 v1(232.82,155.99) 230.92,154.08 230.66,154.08
G2_BOOT_R: length 1.5
  TOP w0.508: C742.2 R834.1
G2_LG: length 107.6
  TOP w0.203: 227.78,155.06 228.31,154.54 U39.26
  TOP w0.635: R844.2 170.72,176.82 170.21,177.32 170.21,181.77 v2(170.34,181.9) ; 227.78,155.06 226.35,156.5 226.35,158.53 226.93,159.11 226.93,161.32 235.11,169.5 235.11,176.12 v2(234.6,176.63)
  BOTTOM w0.635: v2(170.34,181.9) 170.34,185 v1(171.61,186.27) 172.79,187.45 211.28,187.45 214.15,184.58 226.65,184.58 v2(234.6,176.63)
G2_UG: length 74.1
  TOP w0.203: 229.78,155.35 229.11,154.68 U39.24
  TOP w0.635: 229.78,155.35 230.16,155.73 230.16,156.81 231.11,157.77 231.11,161.77 233.18,163.84 v2(233.18,164.47) ; 185.96,182.66 186.71,181.91 v2(187.6,181.91)
  BOTTOM w0.635: v2(233.18,164.47) v1(233.18,172.88) 233.18,174.89 226.16,181.91 v2(187.6,181.91)
G2_UG_R: length 3.9
  TOP w0.635: QCH2.G 181.91,184.88 182.53,184.26 182.53,183.26 R838.1 183.71,183.13 R836.1
G3_BOOT: length 5.7
  TOP w0.254: U39.30 226.23,152.93 225.58,153.58 225.58,154.21 225.31,154.49
  TOP w0.635: 225.31,154.49 v1(224.06,155.73) 223.7,156.09 R841.2
G3_BOOT_R: length 3.9
  TOP w0.102: v1(223.3,162.21) 223.62,161.89 C750.2
  TOP w0.635: R841.1 223.7,160.6 C750.2
G3_LG: length 30.4
  TOP w0.203: U39.27 227.91,154 v2(227.77,154.13)
  TOP w0.635: R870.2 228.25,178.59 230.79,176.05 v2(230.79,174.02)
  BOTTOM w0.635: v2(227.77,154.13) 228.12,154.49 228.12,156.62 229.27,157.77 v1(230.54,157.77) 231.93,159.16 231.93,161.87 230.79,163.01 v2(230.79,174.02)
G3_UG: length 39.2
  TOP w0.203: v2(226.47,154.21) 226.47,154.08 227.11,153.45 U39.29
  TOP w0.635: R860.2 218.55,180.5 224.51,180.5 v2(225.84,179.17)
  BOTTOM w0.635: v2(226.47,154.21) 226.47,156.62 228.76,158.91 229.39,158.91 230.49,160.01 v1(230.49,160.69) 230.49,161.5 229.65,162.34 229.65,175.36 v2(225.84,179.17)
G3_UG_R: length 4.5
  TOP w0.635: R860.1 217.96,178.04 R866.1 217.21,176.4 216.29,175.48 QCH3.G
G4_BOOT: length 2.7
  TOP w0.254: U40.2 146.85,182.34 147.23,181.96 147.73,181.96 R882.2
G4_BOOT_R: length 1.7
  TOP w0.635: C768.2 R882.1
G4_LG: length 16.3
  TOP w0.254: v2(148.56,184.82) 147.91,184.82 U40.5
  TOP w0.635: v2(135.8,186.72) 134.91,186.72 R893.2
  BOTTOM w0.635: v2(148.56,184.82) 146.59,184.82 144.18,187.23 v1(138.28,187.23) 136.3,187.23 v2(135.8,186.72)
G4_UG: length 11.1
  TOP w0.254: v2(146.15,182.21) 146.15,182.78 U40.1
  TOP w0.635: v2(148.75,187.93) 148.11,187.29 R884.2
  BOTTOM w0.635: v2(148.75,187.93) 149.77,186.91 v1(149.77,186.85) 149.77,183.93 148.88,183.04 146.97,183.04 v2(146.15,182.21)
G4_UG_R: length 4.8
  TOP w0.635: R884.1 144.56,184.94 143.99,184.94 QCH4.G 143.92,183.33 R885.1
G4_VCC: length 1.7
  TOP w0.635: C771.1 149.83,185.96 R883.2
GH1: length 22.4
  TOP w0.178: U41.21 51.65,35.47 50.64,36.48
  TOP w0.635: R922.2 59.42,44.03 58.8,44.65 53.46,44.65 51.7,42.88 50.5,42.88 49.94,42.32 49.94,40.47 v1(49.69,40.22) 49.94,39.96 49.94,37.98 50.25,37.68 50.25,36.87 50.64,36.48
GH2: length 8.7
  TOP w0.178: U41.1 51.59,31.65 51.4,31.47
  TOP w0.508: 49.18,29.24 51.4,31.47
  TOP w0.635: v2(49.66,26.09) 48.75,27.01 v1(48.75,28.05) 48.75,28.81 49.18,29.24
  BOTTOM w0.635: v2(49.66,26.09) 49.46,25.89 49.46,24.95 SR53.2
GL2: length 16.1
  TOP w0.178: 52.99,30.07 53.12,30.2 U41.4
  TOP w0.635: v2(46.72,21.88) 46.13,21.88 R910.2 ; v2(53.5,28.35) 52.99,28.86 52.99,30.07
  BOTTOM w0.635: 46.72,23.35 47.53,24.16 47.53,25.94 49.18,27.59 51.09,27.59 51.85,28.35 v2(53.5,28.35) ; 46.72,23.35 v1(46.77,23.4) ; 46.72,23.35 v2(46.72,21.88)
GLAN_RX_N3: length 185.4
  TOP w0.102: R428.1 59.75,220.54 59.6,220.7 59.27,220.7 v2(58.83,220.25) 58.83,220.61 58.66,220.78 58.33,220.78 58.15,220.61 58.15,219.35 56.94,218.14 54.6,218.14 51.67,215.21 51.67,211.23 53.8,209.1 53.8,207.79 60.19,201.4 86.73,201.4 89.36,198.77 89.36,195.28 89.62,195.03 89.92,195.03 90.11,195.22 v2(90.11,195.69) ; v3(54.37,102.4) 53.97,102 PCH1.F11
  BOTTOM w0.102: v3(54.37,102.4) 54.81,102.4 55.04,102.63 55.52,102.63 56.8,103.92 56.8,105.32 61.5,110.01 67.73,110.01 68.92,111.21 69.77,111.21 71.89,113.32 v1(71.89,113.8) 72.36,113.8 74.18,115.61 74.18,135.26 75.62,136.71 75.62,148.42 73.59,150.45 73.59,154.67 76.41,157.49 76.41,167.21 75.78,167.84 75.78,169.89 77.17,171.29 77.17,180.1 77.7,180.63 78.99,180.63 79.33,180.96 79.33,183 79.96,183.62 83.13,183.62 83.83,184.32 83.83,186.95 85.94,189.06 85.94,189.82 89.11,193 89.11,194.55 89.51,194.95 90.25,194.95 90.43,195.13 90.43,195.51 90.25,195.69 v2(90.11,195.69) ; R428.1 59.75,220.54 59.6,220.7 59.28,220.7 58.83,220.25 v2(58.83,220.25)
GLAN_RX_P3: length 185.4
  TOP w0.102: v3(53.6,102.4) 53.26,102.06 PCH1.H11 ; R425.1 59.75,221.1 59.56,220.9 59.19,220.9 v2(58.83,221.27) 58.55,220.99 58.24,220.99 57.94,220.69 57.94,219.44 56.85,218.35 54.52,218.35 51.47,215.3 51.47,211.15 53.6,209.02 53.6,207.7 60.1,201.2 86.65,201.2 89.16,198.69 89.16,195.2 89.53,194.83 89.93,194.83 90.11,194.65 v2(90.11,194.49)
  BOTTOM w0.102: v2(58.83,221.27) 58.83,221.27 59.2,220.9 59.57,220.9 59.75,221.08 R425.1 ; v2(90.11,194.49) 89.86,194.75 89.59,194.75 89.31,194.47 89.31,192.91 86.14,189.74 86.14,188.97 84.03,186.87 84.03,184.24 83.22,183.42 80.04,183.42 79.53,182.91 79.53,180.88 79.08,180.42 77.78,180.42 77.38,180.02 77.38,171.2 75.98,169.81 75.98,167.93 76.61,167.29 76.61,157.4 73.79,154.58 73.79,150.54 75.83,148.5 75.83,136.63 74.38,135.18 74.38,115.53 73.59,114.74 v1(73.59,114.21) 73.06,114.21 69.86,111.01 69.01,111.01 67.81,109.81 61.58,109.81 57,105.23 57,103.83 55.6,102.43 55.12,102.43 54.69,101.99 54.21,101.99 53.8,102.4 v3(53.6,102.4)
GLAN_TX_N3: length 181.9
  TOP w0.102: R440.1 59.75,218.29 59.6,218.45 59.24,218.45 v2(58.83,218.04) 58.83,218.4 58.68,218.55 58.44,218.55 57.27,217.38 54.98,217.38 52.43,214.83 52.43,211.46 54.59,209.3 54.59,208.14 60.57,202.17 88,202.17 90.84,199.33 90.84,196.25 91.88,195.21 92.49,195.21 92.64,195.36 92.64,195.6 v2(92.57,195.66) ; v2(64.13,111.41) 64.4,111.14 64.4,110.64 60.65,106.9 60.65,106.54 57.72,103.61 56.88,103.61 56.68,103.41 56.36,103.41 PCH1.B9
  BOTTOM w0.102: R440.1 59.75,218.29 59.6,218.45 59.24,218.45 v2(58.83,218.04) ; v2(92.57,195.66) 92.22,195.31 91.94,195.31 90.59,196.65 89.43,196.65 89.16,196.38 89.16,195.6 88.35,194.78 88.35,193.41 85.55,190.61 84.45,190.61 83.44,189.59 79.99,189.59 77.25,186.85 77.25,181.68 76.41,180.84 76.41,174.11 73.49,171.19 73.49,167.72 74.89,166.32 74.89,158.08 72.22,155.41 72.22,136.06 72.73,135.55 72.73,119.36 70.29,116.92 v1(69.81,116.92) 69.81,116.44 68.36,114.99 66.83,114.99 64.35,112.51 64.35,111.63 v2(64.13,111.41)
GLAN_TX_P3: length 181.9
  TOP w0.102: R433.1 59.75,218.83 59.57,218.65 59.16,218.65 v2(58.83,218.98) 58.6,218.75 58.35,218.75 57.18,217.58 54.9,217.58 52.23,214.92 52.23,211.38 54.39,209.22 54.39,208.06 60.48,201.96 87.92,201.96 90.63,199.24 90.63,196.16 91.79,195 92.32,195 v2(92.57,194.75) ; v2(65.11,111.41) 65.11,111.54 65.03,111.61 64.75,111.61 64.6,111.46 64.6,110.56 60.85,106.81 60.85,106.46 57.8,103.4 57.17,103.4 PCH1.A9
  BOTTOM w0.102: v2(92.57,194.75) 92.22,195.1 91.85,195.1 90.51,196.45 89.52,196.45 89.36,196.3 89.36,195.51 88.55,194.7 88.55,193.33 85.63,190.41 84.54,190.41 83.52,189.39 80.08,189.39 77.45,186.77 77.45,181.59 76.61,180.75 76.61,174.02 73.69,171.1 73.69,167.8 75.09,166.4 75.09,158 72.42,155.33 72.42,136.15 72.93,135.64 72.93,119.28 71.51,117.85 v1(71.51,117.33) 70.98,117.33 68.44,114.79 66.91,114.79 64.55,112.43 64.55,111.67 64.8,111.41 v2(65.11,111.41) ; v2(58.83,218.98) 59.16,218.65 59.57,218.65 59.75,218.83 R433.1
GLED0: length 7.4
  TOP w0.254: F_PANEL.2 8.58,54.01 R393.1 10.23,55.66 10.45,55.66 12.1,57.31 QN41.C
GLED1: length 6.7
  TOP w0.254: QN42.C 11.06,52.23 9.8,52.23 R394.1 9.06,52.79 7.74,51.47 F_PANEL.4
GNT0_L: length 55.9
  TOP w0.127: v2(58.71,144.94) 59.21,144.43 59.21,143.92 58.96,143.67 58.45,143.67 56.84,142.06 U11.108 ; PCI.A17 44.92,181.43 52.36,173.99 52.36,173.39 53.74,172 60.27,172 v2(60.74,171.53)
  BOTTOM w0.127: v2(58.71,144.94) 58.03,145.61 58.03,153.24 59.23,154.43 59.23,155.17 58.43,155.97 58.43,156.59 57.77,157.25 57.77,168.56 v2(60.74,171.53)
GPIO8_PCH: length 5.1
  TOP w0.102: R241.1 v2(234.6,111.44) ; R241.1 R246.1 ; R241.1 234.79,112.33 R245.2 R996.1
GPIO8_PCH_B: length 10.9
  TOP w0.102: v2(224.67,111.54) QN29.B 226.73,110.78 230.28,110.78 230.51,111.01 232.44,111.01 232.95,111.51 232.95,112.78 R246.2
GPIO8_PCH_C: length 11.5
  TOP w0.102: R242.1 230.19,115.09 228.25,115.09 228.12,115.22 227.49,115.22 226.98,114.71 QN29.C 227.11,113.7 230.41,113.7 230.89,113.21 v2(230.89,112.12) 231.22,111.79 QN28.B
GPIO39_CASE: length 296.5
  TOP w0.102: v2(81.57,48.55) 80.25,49.87 80.25,58.88 77.74,61.39 77.03,61.39 75.65,62.77 71.69,62.77 69.4,65.06 60.48,65.06 v2(58.33,67.22) ; v2(198.66,7.53) v2(198.66,5.11) ; v2(211.23,4.1) 212.63,2.7 v2(223.62,2.7) ; v2(159.06,19.97) 158.02,18.93 158.02,16.24 158.35,15.91 175.13,15.91 175.9,15.15 178.65,15.15 178.98,15.48 185.08,15.48 186.04,14.52 186.04,13.57 187.33,12.27 187.33,11.61 186.34,10.62 186.34,9.81 187.36,8.8 187.74,8.8 188.04,8.49 188.04,6.56 186.98,5.49 v2(186.98,5.37) ; THER_HD.6 237.52,36.1 238.79,34.83 240.32,34.83 241.21,33.94 241.21,25.62 v2(241.14,25.56) ; PCH1.R31 49.59,91.16 50.59,91.16 50.94,90.82 v3(50.94,89.75) ; v2(59.09,68.31) 60.56,68.31 60.74,68.49 RN46.7 60.05,68.8 59.94,68.92 58.73,68.92 58.58,69.07 58.58,70.27 57.9,70.95 56.67,70.95 55.37,72.25 55.37,78.81 54.24,79.94 54.24,81.85 51.75,84.34 v3(51.67,84.34)
  BOTTOM w0.102: v2(59.09,68.31) 58.33,67.55 v2(58.33,67.22) ; v2(186.98,5.37) 187.47,4.88 192.41,4.88 194.04,6.51 194.6,6.51 195.99,7.9 198.29,7.9 v2(198.66,7.53) ; v2(241.14,25.56) 241.14,24.48 240.51,23.85 240.51,18.42 231.26,9.17 231.26,6.1 229.55,4.39 226.45,4.39 224.76,2.7 v2(223.62,2.7) ; v2(159.06,19.97) 158.17,20.86 151.89,20.86 148.69,24.06 127.01,24.06 122.92,28.15 118.75,28.15 117.43,29.47 93.85,29.47 91.09,32.23 91.09,33.77 88.78,36.08 86.53,38.34 86.51,38.34 83.09,41.76 83.09,47.02 v2(81.57,48.55) ; v2(198.66,5.11) 198.66,4.22 199.25,3.63 210.77,3.63 v2(211.23,4.1) ; v3(50.94,89.75) 51.34,89.34 51.34,88.78 51.09,88.53 51.09,84.92 v3(51.67,84.34)
H_BPM0_L: length 62.6
  TOP w0.102: v2(202.98,142.4) 202.22,143.16 v2(202.09,143.16) ; CPU1.G39 v4(177.08,139.38)
  BOTTOM w0.102: v4(177.08,139.38) 177.72,140.01 188.3,140.01 191.52,143.24 v1(195.54,143.24) 197.14,143.24 197.67,143.77 201.48,143.77 v2(202.09,143.16) ; SJ1.21 219.58,124.91 219.31,125.18 217.79,125.18 217.56,125.41 211.47,125.41 207.11,129.77 207.11,133.06 207.94,133.89 207.94,137.31 206.53,138.72 206.53,142.15 205.77,142.91 203.49,142.91 v2(202.98,142.4)
H_BPM1_L: length 61.4
  TOP w0.102: CPU1.J39 v4(178,137.55)
  BOTTOM w0.102: v4(178,137.55) 178.32,137.55 180.09,139.33 189.41,139.33 v1(191.57,141.49) 192.21,142.12 201.94,142.12 202.98,143.16 205.84,143.16 206.76,142.24 206.76,138.81 208.29,137.29 208.29,133.91 207.34,132.96 207.34,129.86 211.54,125.66 217.69,125.66 217.94,125.41 SJ1.23
H_PRDY_L: length 65.7
  TOP w0.102: CPU1.L39 177.9,135.62 180.32,135.62 v4(180.75,136.05)
  BOTTOM w0.102: SJ1.5 222.95,120.91 223.43,120.43 223.43,119.54 223.04,119.16 213.71,119.16 206.51,126.36 206.51,133.1 207.4,133.99 207.4,137.15 207.05,137.5 205.34,137.5 204.93,137.09 200.82,137.09 v1(200.41,137.5) 200.13,137.22 196.53,137.22 195.41,136.1 180.8,136.1 v4(180.75,136.05)
H_PREQ_L: length 63.7
  TOP w0.102: CPU1.L37 v4(175.25,135.72)
  BOTTOM w0.102: v4(175.25,135.72) 175.69,135.29 178.19,135.29 181.03,138.13 198.13,138.13 v1(198.51,138.51) 198.58,138.59 200.46,138.59 201.73,137.32 204.84,137.32 205.25,137.73 207.14,137.73 207.63,137.24 207.63,133.9 206.74,133.01 206.74,126.45 212.79,120.41 SJ1.3
H_SKTOCC_L: length 32.3
  TOP w0.102: CPU1.D38 v4(176.17,142.12) ; v2(195.74,146.21) 196.98,146.21 R56.2 199.01,144.69 QN1.G 202.47,144.34 203.52,143.29 R53.1
  BOTTOM w0.102: v2(195.74,146.21) 195.49,146.46 v1(194.6,146.46) 192.29,146.46 187.29,141.47 176.82,141.47 v4(176.17,142.12)
H_TCK: length 58.3
  TOP w0.102: v2(194.98,147.99) 190.15,147.99 189.42,148.72 183.77,148.72 179.74,144.69 177.72,144.69 177.12,144.09 177.12,142.08
  TOP w0.508: CPU1.D39 177.12,142.08
  BOTTOM w0.102: v2(194.98,147.99) 195.64,147.99 v1(196.1,147.53) 196.81,146.82 197.42,146.82 198.15,146.08 201.16,146.08 202.07,145.17 202.07,145.16 202.09,145.13 202.09,144.63 202.57,144.15 202.92,143.8 206.1,143.8 208.69,141.21 208.69,136.56 210.73,134.53 218.09,134.53 218.31,134.3 SR38.2 218.44,133.76 219.11,133.76 219.26,133.92 SJ1.57
H_TDI: length 62.1
  TOP w0.102: v2(224.95,134.53) 224.95,135 R980.2 223.27,136.68 221.29,136.68 220.76,136.15 216.95,136.15 v1(216.49,136.61) 215.4,137.7 214.46,137.7 206.33,145.83 202.34,145.83 201.18,147 190.22,147 189.13,148.08 184.07,148.08 179.74,143.75 179.74,142.35 178.63,141.24 178.41,141.24 178.06,140.89 178.06,140.73 177.57,140.24 177.03,140.24 CPU1.F38
  BOTTOM w0.102: v2(224.95,134.53) 224.95,134.27 225.81,133.42 SJ1.56
H_TDO: length 66.3
  TOP w0.102: v2(224.19,134.53) 224.19,134.78 223.68,135.29 R985.2 221.23,135.92 215.81,135.92 214.92,136.81 v1(214.38,136.81) 214.38,137.34 206.15,145.57 202.22,145.57 201.1,146.69 191.52,146.69 186.72,141.89 181.53,141.89 179.13,139.49 177.88,139.49 CPU1.F39
  BOTTOM w0.102: v2(224.19,134.53) 224.19,133.38 225.16,132.41 SJ1.52 229.19,132.41 230.28,133.51 SR32.2 SR37.2 SR36.2
H_TMS: length 61.4
  TOP w0.102: CPU1.E39 177.96,141.17 177.96,143.4 178.61,144.05 179.71,144.05 183.98,148.31 189.23,148.31 190.26,147.28 201.4,147.28 202.6,146.08 206.47,146.08 214.22,138.33 215.81,138.33 v1(215.83,138.31) 217.76,136.38 220.66,136.38 221.2,136.91 224.24,136.91 R981.2 225.11,135.89 225.71,135.29 v2(225.71,134.53)
  BOTTOM w0.102: SJ1.58 226.07,133.92 225.71,134.27 v2(225.71,134.53)
H_TRST_L: length 62.1
  TOP w0.102: CPU1.E37 v4(175.25,141.21) ; v2(207.55,139.61) 208.69,139.61 214.81,133.48 221.51,133.48 R987.2 222.38,133.38 225.08,133.38 v2(225.2,133.26)
  BOTTOM w0.102: v2(225.2,133.26) 225.54,132.92 SJ1.54 ; v2(207.55,139.61) 207.55,141.78 205.94,143.39 202.75,143.39 201.68,144.46 201.68,144.96 200.97,145.68 197.19,145.68 v1(196.91,145.96) 196.63,145.68 192.07,145.68 187.57,141.18 175.28,141.18 v4(175.25,141.21)
HDA_BCLK: length 136.2
  TOP w0.102: R207.1 v2(24.58,96.87) ; R510.2 16.54,209.74 v2(16.54,208.38)
  BOTTOM w0.102: v2(24.58,96.87) 24.58,96.74 24.04,96.2 23.46,96.2 22.87,96.78 15.35,96.78 12.72,99.41 12.72,104.33 13.93,105.54 13.93,108.72 11.46,111.18 11.46,121.29 12.25,122.08 12.25,125.05 12.83,125.64 12.83,133.05 14.03,134.24 14.03,146.72 12.33,148.42 12.33,159.92 13.72,161.31 13.72,170.73 12.33,172.13 12.33,175.77 11.87,176.23 v1(11.87,177.07) 11.87,177.98 12.76,178.87 12.76,192.29 11.75,193.29 11.75,202.31 10.83,203.23 10.83,204.19 14.32,207.68 14.89,207.68 15.59,208.38 v2(16.54,208.38)
HDA_BCLK_R: length 15
  TOP w0.102: R207.2 27.71,98.32 28.1,97.92 28.1,97.54 28.4,97.24 29.9,97.24 arc(30.16,96.98) 29.9,96.73 28.89,96.73 arc(28.68,96.53) 28.89,96.32 29.9,96.32 30.35,95.87 C681.1 30.89,95.66 31.17,95.94 36.52,95.94 36.84,95.63 PCH1.AV23
HDA_RST_L: length 148.6
  TOP w0.102: v2(24.92,96.15) 26.02,97.24 R210.1 ; v2(19.84,208.69) 20.76,209.61 21.52,209.61 22.26,210.34 R479.2 21.62,211.14 21.62,212.92 R504.2
  BOTTOM w0.102: v2(24.92,96.15) 24.57,95.79 23.29,95.79 22.7,96.37 15.18,96.37 12.31,99.24 12.31,104.5 13.52,105.71 13.52,108.55 11.06,111.01 11.06,121.46 11.82,122.22 11.82,123.76 11.69,123.89 11.69,127.69 12.33,128.32 12.33,133.11 13.19,133.98 13.19,143.62 12.76,144.05 12.76,145.73 10.62,147.86 10.62,149.14 9.84,149.92 9.84,151.98 9.43,152.38 9.43,153.93 10.62,155.12 10.62,161.94 11.46,162.78 11.46,168.12 10.83,168.75 10.83,170.36 9.46,171.74 9.46,173.98 v1(10.51,175.04) 10.51,177.26 12.35,179.1 12.35,192.12 11.35,193.12 11.35,202.14 10.42,203.07 10.42,204.36 14.07,208 14.07,208.78 14.86,209.57 16.36,209.57 18.12,207.8 18.96,207.8 v2(19.84,208.69)
HDA_RST_L_R: length 14.2
  TOP w0.102: PCH1.AU24 37.47,94.95 37.09,95.33 36.12,95.33 35.74,95.71 34.03,95.71 arc(33.95,95.7) 33.88,95.65 arc(33.83,95.58) 33.81,95.5 33.81,95.21 arc(33.56,94.95) 33.31,95.21 33.31,95.46 arc(33.23,95.64) 33.05,95.71 31.45,95.71 30.87,95.13 28.25,95.13 28.1,95.28 28.1,96.88 27.74,97.24 R210.2
HDA_SDI0: length 155.1
  TOP w0.102: v2(18.32,208.69) 18.1,208.47 R509.2 ; v2(31.63,94.44) 31.68,94.39 34.04,94.39 34.83,95.18 35.52,95.18 35.83,94.87 36.5,94.87 36.74,94.63 37.72,94.63 PCH1.AT26
  BOTTOM w0.102: v2(31.63,94.44) 30.92,95.16 28.4,95.16 27.73,95.83 26.36,95.83 25.86,95.33 23.1,95.33 22.51,95.92 22.26,95.92 14.99,95.92 11.86,99.05 11.86,104.69 13.06,105.9 13.06,108.36 10.6,110.82 10.6,121.65 11.36,122.41 11.36,123.58 11.23,123.7 11.23,127.88 11.74,128.38 11.82,128.46 11.82,136.4 12.6,137.18 12.73,137.31 12.73,143.34 12.2,143.87 12.2,145.45 10.17,147.48 10.17,148.76 10.17,148.76 10.17,148.95 10.09,149.02 10.09,149.02 9.38,149.73 9.38,151.65 8.95,152.08 8.95,154.15 10.17,155.37 10.17,163.77 11.01,164.61 11.01,167.93 10.37,168.56 10.37,170.18 9,171.55 9,174.49 9.51,175 9.51,177.02 11.89,179.41 11.89,191.82 10.89,192.82 10.89,201.95 9.93,202.92 9.93,204.64 11.27,205.99 11.27,206.67 v1(13.14,208.54) 14.62,210.03 16.99,210.03 v2(18.32,208.69)
HDA_SDO: length 142.1
  TOP w0.102: v2(23.73,96.86) 23.73,97.11 26.02,99.4 R216.1 ; CODEC.5 17.69,216.88 17.69,216.06 16.77,215.15 16.77,211.51 v1(16.52,211.26) 15.84,210.59 15.84,207.68 v2(15.78,207.61)
  BOTTOM w0.102: v2(23.73,96.86) 23.4,97.19 15.52,97.19 13.13,99.58 13.13,102.79 13.55,103.21 14.56,103.21 14.89,103.54 14.89,104.16 14.33,104.72 14.33,109 11.87,111.46 11.87,121.12 12.66,121.91 12.66,124.88 13.24,125.47 13.24,132.88 14.43,134.07 14.43,147.15 12.85,148.73 12.85,159.86 14.13,161.14 14.13,170.9 12.85,172.18 12.85,178.39 13.16,178.71 13.16,192.46 12.16,193.46 12.16,202.48 11.23,203.4 11.23,204.02 14.45,207.23 15.4,207.23 v2(15.78,207.61)
HDA_SDO_R: length 24.4
  TOP w0.102: PCH1.AU22 37.41,96.07 36.71,96.07 36.58,96.2 31.48,96.2 30.28,97.39 30.28,97.8 29.8,98.28 28.47,98.28 27.36,99.4 R216.2 26.32,100.06 25.76,100.06 25.38,99.68 25.38,99.4 22.74,96.76 22.74,94.72 23.25,94.22 23.25,91.65 RJ12.2
HDA_SDO_R1: length 30.3
  TOP w0.102: v2(21.88,94.27) 22.79,93.35 RJ12.1
  BOTTOM w0.102: v2(21.88,94.27) 21.88,93.89 21.47,93.48 15.78,93.48 13.24,90.94 13.24,87.69 12.7,87.15 10.78,87.15 6.73,83.1 5.93,82.3 5.93,82.3 5.65,82.02 5.65,79.05 ME_DISABLE.2
HDA_SDO_R_P1: length 7.6
  TOP w0.102: v2(8.67,71.34) 9.11,70.9 R244.1
  BOTTOM w0.102: ME_DISABLE.3 5.37,75.47 8.8,72.04 8.8,71.47 v2(8.67,71.34)
HDA_SYNC: length 151.8
  TOP w0.102: R217.1 25.84,96.12 v2(25.81,96.1) ; v2(19.08,208.69) 20.23,209.84 20.99,209.84 21.37,210.22 21.37,211.61 20.63,212.35 20.63,214.89 20.2,215.33 CODEC.10
  BOTTOM w0.102: v2(19.08,208.69) 18.57,208.19 18.07,208.19 16.45,209.8 14.76,209.8 13.81,208.85 13.81,208.13 10.19,204.52 10.19,202.97 11.12,202.04 11.12,192.91 12.12,191.91 12.12,179.25 9.74,176.87 9.74,174.9 9.23,174.4 9.23,171.64 10.6,170.27 10.6,168.66 11.23,168.02 11.23,163.89 v1(10.76,163.42) 10.4,163.05 10.4,155.27 9.18,154.05 9.18,152.18 9.61,151.75 9.61,149.83 10.32,149.12 10.4,149.04 10.4,148.66 10.4,147.66 12.48,145.57 12.48,143.92 12.96,143.44 12.96,134.07 12.1,133.21 12.1,133.02 12.1,133.02 12.1,128.42 11.46,127.78 11.46,123.8 11.59,123.67 11.59,122.32 10.83,121.56 10.83,110.92 13.29,108.45 13.29,105.8 12.08,104.59 12.08,99.15 15.09,96.15 22.61,96.15 23.19,95.56 25.28,95.56 v2(25.81,96.1)
HDA_SYNC_R: length 12.9
  TOP w0.102: PCH1.AV24 36.71,95.1 35.93,95.1 35.52,95.51 34.81,95.51 33.97,94.67 32.29,94.67 arc(32.09,94.88) 32.29,95.08 32.6,95.08 arc(32.8,95.28) 32.6,95.49 31.62,95.49 31.03,94.9 28.07,94.9 27.59,95.38 R217.2
HDD_LED_N: length 5.5
  TOP w0.254: QN43.C 8.54,50.32 5.57,50.32 F_PANEL.3
HDD_LED_P: length 4.9
  TOP w0.254: F_PANEL.1 3.08,55.35 3.08,57.25 R391.1
HDMI_DET: length 37
  TOP w0.102: R795.1 R796.1 182.69,206.15 184.21,206.15 184.89,206.84 184.89,208.87 v1(185.4,209.38) 186.34,210.32 186.34,216.44 187.48,217.58 187.48,218.7 188.12,219.34 188.12,224.57 189.52,225.97 193.07,225.97 194.47,227.36 194.47,230.66 193.65,231.48 DP2.13
HDMI_DET2: length 30.7
  TOP w0.102: R86.1 R88.1 213.68,208.88 v1(214.23,209.43) 215.27,209.43 216.19,210.34 216.19,222.16 219.49,225.46 219.49,230.28 217.85,231.92 DP1.13
HDMI_DET2_R: length 2.8
  TOP w0.102: v1(214.63,205.06) R86.2 215.17,206.03 QN11.G
HDMI_DET_R: length 10.4
  TOP w0.102: QN74.G 188.75,202.34 182.2,202.34 v1(181.44,203.11) 181.01,203.54 R795.2
HDPANEL_DETECT: length 187.6
  TOP w0.102: v2(15.02,112.81) 15.76,112.07 18.9,112.07 21.06,109.91 21.06,106.79 19.62,105.34 19.62,99.69 16.11,96.19 16.11,91.04 v2(16.26,90.89) ; F_AUDIO.4 8.41,204.12 10.41,206.12 C722.2 10.54,206.79 D34.3 13.37,206.28 16.44,206.28 18.09,207.93 22.13,207.93 v2(22.51,208.31) ; v3(41.14,93.64) PCH1.AK26 ; R192.2 23.64,90.22 23.64,88.21 23.81,88.04 24.66,88.04 v2(24.92,87.78)
  BOTTOM w0.102: v2(16.26,90.89) 16.26,91.37 16.54,91.65 22,91.65 22.87,90.78 22.87,88.7 23.79,87.78 v2(24.92,87.78) 25.18,88.04 30.18,88.04 33.26,91.12 35.44,91.12 36.86,92.54 38.11,92.54 38.5,92.92 40.42,92.92 v3(41.14,93.64) ; v2(15.02,112.81) 14.46,113.37 14.46,115.15 16.82,117.51 16.82,172.38 15.62,173.58 15.62,174.22 15.83,174.43 15.85,174.43 16.14,174.71 16.14,187.92 16.26,188.05 16.26,188.45 16.21,188.5 16.21,192.11 16.72,192.62 16.72,192.64 16.8,192.72 16.8,195.08 14.75,197.13 14.75,204.53 15.04,204.82 20.49,204.82 22.51,206.84 v2(22.51,208.31)
HM_5VDUAL: length 6.5
  TOP w0.254: R329.2 219.01,10.95 219.49,11.43 219.49,11.75 R335.1 220,12.32 C374.1 218.92,13.83 217.98,14.76 U21.93
HM_12V: length 13.3
  TOP w0.254: U21.96 219.48,14.88 220.74,13.62 223.52,13.62 C378.1 224.25,12.89 224.25,10.54 R337.1 223.68,9.43 222.92,8.67 221.36,8.67 R333.2
HM_VCC: length 13.2
  TOP w0.254: R334.2 219.62,9.53 R338.1 223.11,10.1 223.11,12.51 C379.1 222.38,13.24 220.58,13.24 218.98,14.84 U21.95
HM_VCC3: length 14.6
  TOP w0.254: R330.2 215.04,8.92 215.62,9.49 218.98,9.49 219.43,9.94 220.16,9.94 R336.1 220.92,10.7 221.63,10.7 221.97,11.04 221.97,11.88 C375.1 220.98,12.86 220.42,12.86 218.48,14.8 U21.94
HM_VCORE: length 10.6
  TOP w0.254: R331.2 227.05,13.15 C376.1 226.54,14.07 226.22,14.38 221.05,14.38 220.48,14.96 U21.98
HM_VDIMM: length 10.3
  TOP w0.254: U21.97 219.98,14.92 220.9,14 224.79,14 C377.1 224.63,13.15 224.63,11.84 225.43,11.05 R332.2
HSODN4: length 7.1
  TOP w0.102: C292.1 55.66,179.46 55.25,179.86 55.25,180.23 57.49,182.47 58.71,182.47 59.15,182.91 59.83,182.91 PCIE1X.B15
HSODN5: length 9.3
  TOP w0.102: C291.1 25.34,182.4 23.49,182.4 22.41,183.49 19.02,183.49 18.7,183.18 18.7,182.79 18.93,182.55 PCIE16X_2.B15
HSODN6: length 9.2
  TOP w0.102: PCIE16X_2.B20 17.93,177.96 18.37,177.96 18.43,177.9 18.83,177.5 22.72,177.5 23.61,178.39 25.41,178.39 C294.1
HSODN7: length 10.3
  TOP w0.102: C296.1 25.41,174.73 23.23,174.73 22.34,175.62 18.87,175.62 18.2,174.95 18.2,173.95 17.8,173.55 PCIE16X_2.B24
HSODN8: length 9.3
  TOP w0.102: C298.1 25.31,170.36 23.33,170.36 22.47,169.5 18.83,169.5 18.37,169.96 17.93,169.96 PCIE16X_2.B28
HSODP4: length 7.1
  TOP w0.102: C290.1 54.64,179.46 55.05,179.86 55.05,180.32 57.4,182.67 58.62,182.67 58.87,182.92 58.87,183.32 58.63,183.56 PCIE1X.B14
HSODP5: length 9.3
  TOP w0.102: C289.1 25.46,182.66 23.53,182.66 22.49,183.7 18.93,183.7 18.4,183.17 17.92,183.17 PCIE16X_2.B14
HSODP6: length 9.2
  TOP w0.102: C293.1 25.34,178.59 23.53,178.59 22.64,177.71 18.91,177.71 18.65,177.97 18.65,178.29 18.92,178.55 PCIE16X_2.B19
HSODP7: length 10.3
  TOP w0.102: PCIE16X_2.B23 19.01,174.04 18.63,174.04 18.4,174.26 18.4,174.86 18.96,175.42 22.26,175.42 23.15,174.53 25.34,174.53 C295.1
HSODP8: length 9.2
  TOP w0.102: PCIE16X_2.B27 18.87,170.55 18.57,170.26 18.57,170.04 18.91,169.7 22.38,169.7 23.25,170.57 25.44,170.57 C297.1
HSW_STRAP_CFG13: length 30.9
  TOP w0.102: R50.1 205.52,124.75 205.8,125.03 206.03,125.25 207.61,125.25 208.12,124.75 209.07,124.75 209.71,125.38 v1(210.92,125.38) 212.12,125.38 220.12,117.38 221.52,117.38 226.09,112.81 QN28.C
I_MDI0N: length 12.5
  TOP w0.102: R767.2 84.38,213.57 84.63,213.57 84.69,213.51 84.69,212.83 83.56,211.7 83.38,211.7 v1(82.96,212.12) 82.54,211.7 77.41,211.7 76.63,212.49 76.09,212.49 75.41,213.17 75.26,213.17 75.22,213.22 ILAN.14
I_MDI0P: length 12.5
  TOP w0.102: R766.2 85.05,213.22 85.05,212.69 83.71,211.35 81.55,211.35 v1(81.19,210.98) 80.82,211.35 77.27,211.35 76.48,212.14 75.95,212.14 75.26,212.82 ILAN.13
I_MDI1N: length 9.2
  TOP w0.102: ILAN.18 75.42,214.82 75.72,214.51 76.13,214.51 77.78,212.86 81.93,212.86 82.13,213.06 82.13,213.51 82.03,213.6 81.87,213.6 R769.2
I_MDI1P: length 9.2
  TOP w0.102: ILAN.17 75.31,214.42 75.58,214.15 75.98,214.15 77.63,212.5 82.07,212.5 82.51,212.94 82.51,213.22 R768.2
I_MDI2N: length 2.1
  TOP w0.102: R771.2 76.33,215.62 75.72,215.62 75.32,216.02 ILAN.21
I_MDI2P: length 2.1
  TOP w0.102: R770.2 76.65,214.94 76.32,215.26 75.58,215.26 75.22,215.62 ILAN.20
I_MDI3N: length 16.9
  TOP w0.102: ILAN.24 75.23,217.22 75.25,217.2 78.01,217.2 78.39,216.82 82.79,216.82 83.12,217.15 v1(83.12,217.66) 83.62,217.66 84.26,218.29 86.32,218.29 87.08,217.53 87.08,214.58 R773.2
I_MDI3P: length 16.9
  TOP w0.102: R772.2 86.27,214.31 86.39,214.18 86.57,214.18 86.72,214.33 86.72,217.39 86.17,217.94 84.41,217.94 82.93,216.47 81.19,216.47 v1(80.83,216.11) 80.47,216.47 78.24,216.47 77.86,216.84 75.24,216.84 75.22,216.82 ILAN.23
I_VCC3P3: length 12.2
  TOP w0.102: R436.1 62.95,208.21 65.07,208.21 66.33,209.47 66.33,212.18 66.65,212.5 68.6,212.5 v2(68.99,212.12) ILAN.1
IDSEL1: length 14.9
  TOP w0.127: R291.1 48.29,162.59 v2(49.18,163.48)
  BOTTOM w0.127: v2(49.18,163.48) 49.18,169.45 47.67,170.96 PCI.A26
ILAN_CLK_REQ: length 12.6
  TOP w0.102: ILAN.48 66.64,212.82 66.07,212.25 66.07,209.54 64.98,208.44 62.21,208.44 v2(62.11,208.34) 61.31,207.53 61.14,207.53 R426.1
ILAN_CLKN: length 195.5
  TOP w0.102: v3(45.64,101.65) 45.2,102.1 PCH1.AC11 ; v2(92.55,196.78) 92.55,196.73 92.5,196.68 92.16,196.68 92.03,196.81 92.03,201.23 90.22,203.04 60.86,203.04 55.43,208.47 55.43,209.63 53.25,211.82 53.25,214.44 55.26,216.45 64.79,216.45 67.14,214.11 68.51,214.11 68.6,214.02 ILAN.45
  BOTTOM w0.102: v2(92.55,196.78) 92.3,197.03 92.3,197.4 92.01,197.7 87.48,197.7 86.14,196.35 86.14,196.35 85.94,196.15 85.94,195.16 85.5,194.72 84.38,194.72 83.34,193.68 79.91,193.68 78.92,192.69 77.65,192.69 77.12,192.16 77.12,191.68 73.69,188.25 73.69,184.94 70.29,181.54 70.29,181.21 v1(69.96,180.88) 70.29,180.55 70.29,178.42 70.57,178.14 70.57,176.82 60.26,166.5 60.26,156.73 60.99,155.99 60.99,153.81 60.26,153.07 60.26,141.64 56.04,137.42 56.04,136.59 49.74,130.29 49.74,124.42 47.4,122.08 47.4,117.18 46.36,116.14 46.36,113.33 44.28,111.25 44.28,105.99 44.66,105.61 44.66,104.59 43.99,103.92 43.99,102.72 44.85,101.87 45.43,101.87 v3(45.64,101.65)
ILAN_CLKP: length 195.5
  TOP w0.102: ILAN.44 68.56,214.42 68.51,214.36 67.24,214.36 64.9,216.71 55.15,216.71 52.99,214.55 52.99,211.71 53.88,210.83 53.88,210.83 55.18,209.53 55.18,208.36 60.75,202.79 90.11,202.79 91.78,201.12 91.78,196.97 v2(91.54,196.73) ; v3(45.64,102.42) 45.48,102.42 45.11,102.78 PCH1.AC10
  BOTTOM w0.102: v3(45.64,102.42) 45.64,102.34 45.38,102.07 44.93,102.07 44.2,102.81 44.2,103.84 44.86,104.5 44.86,105.69 44.48,106.07 44.48,111.09 46.62,113.22 46.62,116.03 47.66,117.08 47.66,121.97 49.99,124.31 49.99,130.18 56.29,136.48 56.29,137.32 60.51,141.54 60.51,152.97 61.25,153.7 61.25,156.09 60.51,156.83 60.51,166.4 70.82,176.71 70.82,178.24 70.54,178.52 70.54,179.03 v1(70.9,179.38) 70.54,179.74 70.54,181.44 73.95,184.84 73.95,188.14 77.38,191.57 77.38,192.06 77.76,192.44 79.03,192.44 80.02,193.43 83.45,193.43 84.49,194.47 85.61,194.47 86.19,195.05 86.19,196.04 86.32,196.17 87.59,197.44 91.9,197.44 92.04,197.3 92.04,196.45 91.94,196.35 91.62,196.35 91.54,196.44 v2(91.54,196.73)
ILAN_CTRL: length 1
  TOP w0.203: 71.91,211.23 71.91,211.36 72.11,211.56 ILAN.7
  vias: v1(71.79,210.22)
ILAN_RST: length 1.1
  TOP w0.102: R427.1 R457.2
ILAN_RST_R: length 8.1
  TOP w0.102: ILAN.36 67.26,217.92 66.9,218.28 66.9,219.81 67.09,220 C437.2 65.95,220.79 R427.2 65.95,219.84 v1(66.26,219.53)
ILAN_RXN: length 1.7
  TOP w0.102: R428.2 61.18,220.72 61.57,220.72 C439.1
ILAN_RXN_C: length 8.4
  TOP w0.102: ILAN.39 68.48,216.42 68.38,216.52 67.27,216.52 63.79,220 63.79,220.38 63.44,220.72 63.15,220.72 62.99,220.56 C439.2
ILAN_RXP: length 1.7
  TOP w0.102: C438.1 61.57,220.92 61.18,220.92 R425.2
ILAN_RXP_C: length 8.4
  TOP w0.102: C438.2 62.99,221.15 63.22,220.92 63.53,220.92 63.99,220.46 63.99,220.08 67.35,216.72 68.38,216.72 68.48,216.82 ILAN.38
ILAN_TEST_EN: length 5.7
  TOP w0.102: v1(70.97,222.89) 70.7,222.61 70.7,221.25 R445.2
  TOP w0.203: R445.2 71.15,220.25 72.11,219.29 ILAN.30
ILAN_TXN: length 1.7
  TOP w0.102: C441.1 61.57,218.43 61.1,218.43 R440.2
ILAN_TXN_C: length 7.5
  TOP w0.102: C441.2 63.46,218.43 64.17,218.43 67.29,215.32 68.38,215.32 68.48,215.22 ILAN.42
ILAN_TXP: length 1.7
  TOP w0.102: R433.2 61.18,218.64 61.57,218.64 C440.1
ILAN_TXP_C: length 7.5
  TOP w0.102: ILAN.41 68.48,215.62 68.38,215.52 67.37,215.52 64.26,218.64 63.46,218.64 C440.2
ILAN_WAKE_L: length 238.8
  TOP w0.102: v2(67.09,211.23) 66.83,210.98 66.83,209.33 65.18,207.68 63.79,207.68 63.41,207.3 63.41,206.13 63.2,205.93 R435.1 62.77,205.52 v2(63.15,205.14) ; PCH1.AU34 37.32,89.89 37.01,90.2 36.59,90.2 36.47,90.08 36.18,90.08 36.16,90.11 34.95,90.11 32.58,87.74 31.77,87.74 31.01,86.98 28.99,86.98 27.89,85.88 25.81,85.88 25.05,85.12 23.94,85.12 R234.1 20.13,83.31 16.92,86.52 16.16,86.52 15.42,87.26 15.42,89.01 15.63,89.21 15.63,93.61 15.81,93.78 15.81,96.21 19.39,99.79 19.39,105.49 20.81,106.92 20.81,109.76 18.75,111.82 15.25,111.82 v2(15.02,112.05) ; v2(15.65,174.91) 16.14,175.39 16.14,186.6 12.99,189.75 12.99,195.94 18.18,201.14 21.62,201.14 22.07,200.69 34.75,200.69 36.61,202.55 36.61,202.85 40.6,206.84 43.54,206.84 44.36,206.03 v2(45.45,206.03) ; R442.1 77.09,223.93 76.08,223.93 75.98,223.83 73.16,223.83 72.68,224.31 v2(72.68,224.57)
  BOTTOM w0.102: v2(67.09,211.23) 66.91,211.23 66.3,211.85 66.3,220.23 v1(65.95,220.58) 65.69,220.83 65.69,223.81 66.45,224.57 69.45,224.57 70.85,223.17 71.91,223.17 72.68,223.93 v2(72.68,224.57) ; v2(63.15,205.14) 55.38,205.14 54.92,204.68 47.3,204.68 45.96,206.03 v2(45.45,206.03) ; v2(15.65,174.91) 15.39,174.65 15.39,173.49 16.59,172.29 16.59,117.61 14.23,115.25 14.23,112.83 v2(15.02,112.05)
ILAN_WAKE_L_R: length 37.4
  TOP w0.102: ILAN.2 70.11,211.72 69.91,211.51 68.16,211.51 67.67,212 v2(66.83,212) 66.56,211.72 66.56,209.37 65.14,207.96 63.38,207.96 62.77,207.35 R435.2 ; v2(73.44,224.31) 74.58,224.31 75.22,224.95 77.09,224.95 R443.1
  BOTTOM w0.102: v2(66.83,212) 66.53,212.3 66.53,221.19 65.95,221.77 65.95,223.7 66.56,224.31 68.76,224.31 v1(69.22,223.86) 69.63,223.86 70.57,222.92 72.04,222.92 v2(73.44,224.31)
INT_DNOISE: length 5.1
  TOP w0.254: QN46.C 4.35,180.12 4.35,181.64 4.57,181.86 R517.2 4.99,183.67 4.86,183.8
INTA_L: length 65.5
  TOP w0.102: PCI.A6 42.29,196.45 39.03,196.45 37.91,195.33 36,195.33 v2(35.72,195.61) ; v2(48.42,157.82) 48.39,157.79 R967.1 48.39,156.88 50.33,154.94 U11.65 ; v2(30.35,180.83) 32.84,178.34 v2(35.08,178.34)
  BOTTOM w0.102: v2(48.42,157.82) 48.42,158.91 49.51,160 49.51,161.37 48.64,162.25 48.64,166.45 46.3,168.78 44.32,168.78 43.02,170.08 41.83,170.08 41.05,170.85 41.05,175.17 39.91,176.31 39.02,176.31 37.88,177.45 36.1,177.45 35.21,178.34 v2(35.08,178.34) ; v2(35.72,195.61) 35.72,195.6 32.62,192.5 31.75,192.5 30.13,190.89 30.13,181.05 v2(30.35,180.83)
INTB_L: length 59.7
  TOP w0.102: R972.1 51.75,158.53 52.08,158.53 v2(52.72,157.89) 52.84,157.77 U11.63 ; v2(56.22,186.7) 55.66,187.26 54.44,187.26 54.21,187.48 54.21,190.18 52.85,191.54 51.2,191.54 46.78,195.96 44.26,195.96 43.22,194.91 40.02,194.91 PCI.B7
  BOTTOM w0.102: v2(56.22,186.7) 54.64,185.12 54.64,183.83 49.05,178.25 49.05,173.01 51.85,170.21 51.85,158.76 v2(52.72,157.89)
INTC_L: length 52.9
  TOP w0.102: PCI.A7 47.32,195.09 51.11,191.31 52.76,191.31 53.98,190.08 53.98,187.15 54.44,186.7 v2(55.33,186.7) ; U11.64 52.39,157.39 v2(51.88,157.89) 51.25,157.89 R971.1
  BOTTOM w0.102: v2(55.33,186.7) 54.26,185.63 54.26,184.06 48.83,178.62 48.83,172.91 51.59,170.14 51.59,158.18 v2(51.88,157.89)
INTD_L: length 97
  TOP w0.102: PCI.B8 38.56,193.82 38.83,194.09 40.62,194.09 41.85,192.86 42.8,192.86 44.11,194.17 45.3,194.17 45.88,194.75 47.34,194.75 51.01,191.08 52.66,191.08 53.75,189.99 53.75,186.98 54.52,186.21 56.67,186.21 v2(57.87,187.41) ; v2(58.73,146.46) 59.47,146.46 60.04,145.89 U11.116 60.04,140.11 59.21,139.28 R970.1 ; v2(68.92,177.43) 65.56,177.43 63.58,179.41 60.54,179.41 59.11,177.98 58.1,177.98 v2(56.73,179.36)
  BOTTOM w0.102: v2(57.87,187.41) 57.87,186.44 57.18,185.76 57.18,179.81 v2(56.73,179.36) ; v2(68.92,177.43) 68.92,177.11 68.29,176.49 67.9,176.49 58.21,166.8 58.21,157.44 58.87,156.78 58.87,156.28 59.67,155.48 59.67,155.35 59.67,154.25 58.71,153.28 58.71,146.49 v2(58.73,146.46)
INTF_L: length 12.3
  TOP w0.102: PCH1.AV29 36.68,92.42 36.68,92.42 33.84,92.42 31.19,89.77 28.75,89.77 28.65,89.87 28.29,90.23 26.96,90.23 26.48,90.71 RN12.3
INTVRMEN: length 23.5
  TOP w0.102: PCH1.AV36 36.65,88.69 36.56,88.61 35.32,88.61 33.31,86.6 33.31,85.15 31.71,83.55 31.71,82.35 31.35,82 28.72,82 26.45,79.72 26.45,75.09 v2(26.07,74.71) 25.15,74.71 R248.1 R247.1
IRDY_L: length 19.6
  TOP w0.127: U11.70 50.13,152.89 49.6,153.41 49.11,153.41 48.84,153.14 48.84,153.11 48.67,152.94 48.67,152.59 R965.1 47.75,152.94 47.63,152.81 44.48,152.81 44.1,152.43 43.59,152.43 43.34,152.69 43.34,153.7 42.77,154.27 41.75,154.27 40.42,155.61 39.45,155.61 38.51,156.55 38.51,157.45 39.84,158.78 PCI.B35
ISEN1: length 45.3
  TOP w0.127: R833.2 R827.2 R826.2 C741.1 R832.1 v2(209.25,156.91) ; v2(209.58,158.66) R830.2 ; U39.13 231.6,149.53 v2(231.74,149.38)
  BOTTOM w0.127: v2(209.58,158.66) v1(209.58,157.79) 209.58,157.25 v2(209.25,156.91) 208.91,156.57 208.44,156.57 207.06,155.19 207.06,153.16 209.71,150.5 222.82,150.5 226.22,147.1 229.65,147.1 230.65,146.1 231.19,146.1 231.81,146.72 231.81,149.32 v2(231.74,149.38)
ISEN1_1: length 75.8
  TOP w0.127: P1.1 165.96,174.4 167.06,174.4 167.16,174.51 167.16,174.91 v2(166.83,175.24) ; R830.1 R823.1 211.11,160.78 211.11,161.07 211.78,161.74 v2(211.78,162.08)
  BOTTOM w0.127: v2(211.78,162.08) 212.24,162.08 213.27,163.1 213.27,169.1 206.77,175.6 201.53,175.6 v1(201.18,175.24) 200.82,175.6 199.75,175.6 199.12,176.23 193.1,176.23 191.69,174.82 185.85,174.82 183.29,172.27 183.29,168.2 181.79,166.69 173.8,166.69 172.77,167.73 172.77,170.96 169.58,174.15 167.55,174.15 167.16,174.53 167.16,174.91 v2(166.83,175.24)
ISEN1_2: length 47.5
  TOP w0.127: R848.1 R845.1 214.6,160.85 214.6,161.26 v2(214.28,161.58) ; v2(187.41,176.94) 187.74,176.61 187.74,174.91 187.19,174.37 186.32,174.37 P3.1
  BOTTOM w0.127: v2(187.41,176.94) 187.74,176.61 187.74,176.18 188.12,175.8 190.38,175.8 192.37,177.78 195.66,177.78 v1(195.99,177.45) 196.32,177.78 205.84,177.78 214.15,169.47 214.15,163.61 214.54,163.23 214.54,161.83 v2(214.28,161.58)
ISEN1_3: length 14.3
  TOP w0.127: P5.1 213.45,170.01 213.45,168.87 213.77,168.54 213.77,165.24 215.02,163.99 215.91,163.99 217.2,162.7 217.2,160.78 R876.1 R873.1 218.82,160.31 v1(219.87,160.31)
ISEN1_4: length 105.6
  TOP w0.127: R899.1 R898.1 207.74,160.85 207.74,161.81 208.14,162.21 208.49,162.21 v2(208.82,162.54) ; P7.1 146.78,174.28 148.26,174.28 148.5,174.51 148.5,174.93 v2(148.17,175.26)
  BOTTOM w0.127: v2(148.17,175.26) 148.5,174.93 148.5,174.04 150.91,171.63 150.91,168.2 152.45,166.66 161.81,166.66 163.1,167.95 163.1,171.76 164.48,173.13 169.32,173.13 171.88,170.58 171.88,167.36 173.43,165.81 182.15,165.81 184.18,167.83 184.18,171.9 186.22,173.93 193.22,173.93 193.94,174.66 195.36,174.66 v1(195.74,174.28) 196.12,174.66 198.61,174.66 199.24,174.02 207.09,174.02 212.38,168.73 212.38,164.24 210.34,162.21 209.15,162.21 v2(208.82,162.54)
ISEN2: length 46.4
  TOP w0.127: v2(213.01,158.66) R848.2 ; v2(213.01,156.91) R855.1 C755.1 R852.2 R853.2 R857.2 ; U39.12 231.24,149.13 231.81,148.56 231.81,147.67 231.41,147.27 231.41,147.09 v2(230.92,146.59)
  BOTTOM w0.127: v2(230.92,146.59) 230.16,147.35 226.35,147.35 222.89,150.81 209.77,150.81 207.31,153.27 207.31,154.97 208.58,156.24 209.33,156.24 210,156.91 v2(213.01,156.91) v1(213.01,157.77) v2(213.01,158.66)
ISEN3: length 48.1
  TOP w0.127: v2(217.2,158.66) 217.58,159.04 R876.2 ; v2(230.92,147.35) 231.55,147.99 231.55,148.37 231.19,148.73 U39.11 ; v2(216.57,156.91) R879.1 C767.1 R877.2 R878.2 R880.2
  BOTTOM w0.127: v2(230.92,147.35) 230.54,147.73 226.47,147.73 223.15,151.06 209.87,151.06 207.56,153.37 207.56,154.87 208.68,155.99 209.43,155.99 210.08,156.63 212.59,156.63 212.83,156.39 216.04,156.39 v2(216.57,156.91) 216.54,156.93 v1(216.54,157.94) 217.2,158.6 v2(217.2,158.66)
ISEN4: length 43.8
  TOP w0.127: v2(211.74,152.18) 210.99,151.43 207.54,151.43 205.26,153.7 205.26,155.23 205.74,155.7 R901.2 R903.2 R900.2 C775.1 R902.1 v2(205.65,156.91) ; R899.2 v2(206.15,158.66) ; R858.1 230.31,145.63 U39.10 v2(230.91,148.13)
  BOTTOM w0.127: v2(206.15,158.66) 206.15,157.42 v2(205.65,156.91) ; v2(211.74,152.18) 212.5,151.42 218.12,151.42 v1(218.42,151.72) 218.73,151.42 223.3,151.42 226.59,148.13 v2(230.91,148.13)
ISOLATEB: length 5.8
  TOP w0.102: RLAN.36 46.68,231.52 46.51,231.68 46.51,232.32 v1(46.01,232.82) 46.01,233.2 45.63,233.59 R460.2 43.82,233.97 R458.1
ISUMN: length 4.9
  TOP w0.203: U39.15 232.1,150.33 232.74,149.69 233.06,149.69 v2(233.18,149.56)
  TOP w0.254: R872.2 233.97,148.46 C763.1 233.39,149.04 233.39,149.35 v2(233.18,149.56)
ISUMN_RC: length 1.2
  TOP w0.254: C763.2 232.73,147.67 R874.2
ISUMP_RC: length 3.5
  TOP w0.254: C761.2 237.17,148.02 C762.2 v1(236.19,147.35) 235.46,147.35 R875.2
JDREF: length 5.2
  TOP w0.254: v2(16.42,221.39) 16.42,221.77 15.8,222.39 CODEC.40 13.09,222.39 12.35,221.65 R491.2
JP1: length 12.5
  TOP w0.102: R945.1 194.69,15.13 194.69,16.24 R944.1 194.16,17.19 194.6,17.62 v1(194.86,17.62) 195.03,17.46 199.4,17.46 200.39,18.45 200.39,19.1 200.92,19.64 200.92,19.74 201.1,19.91 U21.60
JTAG_PCH_RST: length 12.4
  TOP w0.102: R236.1 48.42,77.57 47.47,78.52 47.47,82.98 47.84,83.34 47.84,85.54 47.54,85.83 47.54,86.13 47.57,86.41 47.58,86.43 47.58,86.64 47.54,86.74 47.52,86.8 47.52,87.22 47.49,87.25 47.49,87.66 PCH1.W37
JTAG_PCH_TCK: length 11.9
  TOP w0.102: PCH1.Y40 46.59,86.75 46.56,86.72 46.56,86.34 46.37,86.15 46.37,85.32 46.31,85.26 46.31,84.73 46.41,84.63 46.41,77.78 45.5,76.87 45.5,75.95 R558.2
JTAG_PCH_TDI: length 20
  TOP w0.089: 47.38,86.51 47.36,86.3 47.34,86.07
  TOP w0.102: 47.34,86.07 47.34,85.75 47.63,85.45 47.63,84.3 47.1,83.76 47.1,77.42 46.18,76.51 46.18,73.16 46.46,72.88 v1(46.46,71.58) 46.17,71.29 46.17,70.13 R555.2 R551.2 ; PCH1.W39 47.13,87.15 47.31,86.77 47.38,86.6 47.38,86.51
JTAG_PCH_TDO: length 24.8
  TOP w0.102: v1(44.66,65.36) 44.99,65.69 R562.2 44.04,67.31 R561.2 43.8,67.49 43.8,69.45 45.12,70.77 45.12,72.88 45.73,73.49 45.73,76.78 46.64,77.69 46.64,84.18 47.2,84.74 47.2,85.24 46.93,85.51 46.93,86.15 46.77,86.31 46.77,86.63 46.9,86.75 46.9,87.12 46.82,87.2 46.82,87.44 PCH1.Y38
JTAG_PCH_TMS: length 23.9
  TOP w0.089: PCH1.W40 47.13,86.45 47.13,85.65 47.38,85.4
  TOP w0.102: 47.38,85.4 47.43,85.35 47.43,84.55 46.87,83.99 46.87,77.58 45.96,76.66 45.96,73.4 45.35,72.79 45.35,70.08 R554.2 44.99,69.69 45.44,69.25 45.44,67.77 45.9,67.3 v1(45.9,66.61) 45.9,65.18 R552.2
K2_PCH: length 7.2
  TOP w0.254: R153.2 53,112.88 51.92,111.81 51.92,110.09 51.51,109.68 51.51,107.43 51.72,107.22 51.72,106.81 PCH1.K2
KB_CLK: length 237.2
  TOP w0.102: v2(236.89,57.18) 237.78,57.18 241.46,60.87 241.46,69.76 v2(242.58,70.87) ; v2(218.12,30.13) 218.54,29.71 218.54,28.93 216.82,27.21 216.82,22.74 211.98,17.9 U21.81 ; v2(237.01,220.5) 237.62,221.11 239.07,221.11 239.3,220.88 RN27.6 239.3,219.62 239.17,219.49 236.88,219.49 236.37,218.98 235.68,218.98 FB8.1
  BOTTOM w0.102: v2(236.89,57.18) 236,56.29 236,55.66 233.1,52.76 233.1,46.93 231.8,45.63 231.8,40.16 230.72,39.08 230.72,34.12 229.31,32.71 226.09,32.71 223.34,29.95 220.72,29.95 220.14,29.37 218.88,29.37 v2(218.12,30.13) ; v2(242.58,70.87) 243.21,71.51 243.21,215.89 239.74,219.36 237.27,219.36 v1(237.01,219.62) v2(237.01,220.5)
KB_DATA: length 230
  TOP w0.102: v2(217.96,29.06) 216.57,27.67 216.57,22.81 211.48,17.73 U21.80 ; FB7.1 238.54,219.93 238.73,220.12 RN27.8 238.73,220.5 v2(237.9,220.5) ; v2(242.68,70.03) 241.97,69.32 241.97,60.48 237.9,56.42 v2(236.89,56.42)
  BOTTOM w0.102: v2(237.9,220.5) v1(238.92,220.5) 243.44,215.98 243.44,70.85 242.68,70.09 v2(242.68,70.03) ; v2(217.96,29.06) 218.02,29.12 220.21,29.12 220.82,29.73 223.43,29.73 226.19,32.48 229.4,32.48 230.95,34.03 230.95,38.98 232.03,40.06 232.03,45.53 233.33,46.83 233.33,52.61 236.25,55.53 236.25,56.04 236.63,56.42 v2(236.89,56.42)
KBCLK: length 14.5
  TOP w0.102: FB8.2 C414.2 233.97,223.46 233.97,230.77 PSKM.5
KBDATA: length 16.7
  TOP w0.102: PSKM.1 234.35,234.99 234.35,225.71 235.49,224.57 235.49,223.33 C415.2 FB7.2
KBRST_L: length 196.8
  TOP w0.102: R738.2 42.76,58.94 43.44,58.94 44.04,58.33 48.75,58.33 52.17,61.75 59.59,61.75 60.96,63.13 66.73,63.13 68.31,61.55 73.88,61.55 75.43,60 77,60 79.56,57.45 79.56,48.64 80.79,47.4 85.25,47.4 85.73,46.92 87.05,46.92 v2(87.54,47.4) ; v2(200.34,28.48) 200.47,28.48 200.91,28.04 200.91,27.5 201,27.41 U21.45
  BOTTOM w0.102: v2(200.34,28.48) 199.78,27.92 199.78,26.89 196.62,23.73 178.38,23.73 177.72,23.07 152.85,23.07 149.63,26.3 142.43,26.3 140.58,28.15 131.16,28.15 128.24,31.07 128.24,32.1 125.12,35.21 120.73,35.21 120.1,34.58 119.41,34.58 118.73,35.26 108.24,35.26 106.66,33.69 101.64,33.69 100.6,32.65 95.21,32.65 94.39,33.46 94.39,37.24 93.12,38.51 93.12,41.41 91.3,43.24 88.93,43.24 v1(87.84,44.33) 87.54,44.63 v2(87.54,47.4)
KBRST_L_R: length 39.4
  TOP w0.102: v3(50.93,89.04) 51,88.98 PCH1.K36 ; R738.1 41.68,60.97 C679.1 42.58,62.55 42.58,64.16 42.42,64.32 41.71,64.32 41.58,64.45 RN15.3 41.58,65.92 v2(41.43,66.07)
  BOTTOM w0.102: v3(50.93,89.04) 50.88,88.99 50.88,87 v1(50.45,86.57) 50.86,86.16 50.86,84.36 51.7,83.52 51.7,79.79 52.76,78.72 52.76,73.9 49.63,70.77 46.25,70.77 44.46,68.98 43.97,68.98 43.59,68.6 43.59,67.6 42.07,66.07 v2(41.43,66.07)
LAN_3P3_N1: length 7.7
  TOP w0.102: QN63.C 93.12,191.04 94.14,190.02 R633.1 R637.1 R650.2 R638.2 94.55,194.3 v1(94.83,194.57)
LAN_3P3_N2: length 2.8
  TOP w0.102: v1(96.98,191.88) 96.98,193.02 QN62.B 96.55,193.45 R638.1
LAN_3P3_N3: length 11.5
  TOP w0.102: QN63.B 91.73,192.31 91.73,187.23 92.36,186.6 93.73,186.6 94.53,185.8 R641.1 94.53,185.07 v1(95.28,184.31)
