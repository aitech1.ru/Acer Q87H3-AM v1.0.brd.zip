# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_MA_A2: length 57.1
  TOP w0.102: CPU1.AU16 156.1,110.85 156.1,110.32 156.36,110.07 156.66,110.07 156.87,109.86 156.87,109.46 156.77,109.37 156.77,109.03 156.87,108.94 156.87,108.55 156.69,108.37 156.69,107.11 156.36,106.79 156.36,106.41
  TOP w0.165: 157.37,75.69 157.37,75.69 157.37,75.24 157.22,75.08 157.22,73.4 156.93,73.12 DIMM4.61 156.93,72.07 156.75,71.89 156.75,70.49 156.01,69.76 156.01,68.43 156.73,67.72 156.73,65.33 DIMM2.61
  TOP w0.216: 156.36,106.41 156.36,101.72 161.09,96.98 161.09,83.5 158.64,81.05 arc(158.64,80.7) 158.99,80.7 160.48,82.19 arc(160.84,82.19) 160.84,81.84 157.37,78.38 157.37,75.69
M_MA_A3: length 54.8
  TOP w0.102: 157.28,106.41 157.28,106.76 157.88,107.36 157.88,108.34 157.78,108.44 157.78,108.94 157.42,109.3 CPU1.AW17
  TOP w0.165: 158.93,75.65 158.93,74.08 158.11,73.25 158.11,71.16 DIMM4.180 157.74,70.79 157.74,68.46 158.75,67.45 158.75,66.45 158.15,65.84 158.15,63.44 DIMM2.180
  TOP w0.216: 158.93,75.65 159.16,75.87 159.16,78.96 161.86,81.65 161.86,93.9 arc(162.1,94.15) 162.35,93.9 162.35,93.09 arc(162.6,92.84) 162.85,93.09 162.85,96.65 157.28,102.22 157.28,106.41
M_MA_A4: length 57.5
  TOP w0.102: 157.68,106.41 157.68,106.68 158.11,107.11 158.11,108.42 157.98,108.55 157.98,109.46 157.89,109.55 157.89,109.9 157.62,110.17 157.28,110.17 157.07,110.37 157.07,110.88 CPU1.AU17
  TOP w0.165: DIMM2.59 159.13,65.32 159.13,67.61 158.12,68.62 158.12,69.68 158.78,70.34 158.78,72.74 DIMM4.59 158.93,73.61 159.28,73.95 159.28,74.43 159.22,74.49 159.22,75.09 159.6,75.47
  TOP w0.216: 157.68,106.41 157.68,102.48 163.23,96.93 163.23,89.99 arc(162.98,89.75) 162.73,89.99 162.73,92.07 arc(162.48,92.32) 162.24,92.07 162.24,81.5 159.66,78.92 159.66,75.53 159.6,75.47
M_MA_A5: length 54.5
  TOP w0.102: CPU1.AW18 158.34,109.3 158.69,108.94 158.69,108.55 158.36,108.22 158.36,106.97 158.06,106.67 158.06,106.41
  TOP w0.165: DIMM2.58 159.75,67.21 159.75,69.68 159.16,70.26 159.16,71.61 159.75,72.2 159.75,73.71 159.93,73.9 DIMM4.58
  TOP w0.216: DIMM4.58 160.11,74.97 160.11,78.83 162.62,81.34 162.62,88.89 arc(162.87,89.14) 163.11,88.89 163.11,85.95 arc(163.36,85.71) 163.61,85.95 163.61,97.16 158.06,102.71 158.06,106.41
M_MA_A6: length 55.2
  TOP w0.102: CPU1.AV17 157.92,110.39 158.24,110.07 158.49,110.07 158.69,109.86 158.69,109.23 158.95,108.98 158.95,108.43 158.62,108.1 158.62,106.76 158.45,106.59 158.45,105.98
  TOP w0.165: DIMM2.178 159.93,65.65 160.74,66.45 160.74,67.77 160.13,68.38 160.13,70.79 DIMM4.178 160.13,71.19 160.13,73.47 160.7,74.04 160.7,75.06
  TOP w0.216: 158.45,105.98 158.45,102.94 163.99,97.39 163.99,84.48 arc(163.74,84.23) 163.49,84.48 163.49,84.85 arc(163.25,85.1) 163,84.85 163,81.01 160.51,78.52 160.51,76.05 160.7,75.86 160.7,75.06
M_MA_A7: length 58.2
  TOP w0.102: CPU1.AT18 158.34,112.04 158.69,111.69 158.69,111.13 158.9,110.93 158.9,110.3 159.14,110.05 159.14,109.35 159.46,109.04 159.46,108.2 159.14,107.88 159.14,106.52 159.21,106.45 159.21,106
  TOP w0.165: DIMM2.56 161.75,67.2 161.75,69.7 161.12,70.34 161.12,71.36 162.14,72.37 162.14,74.59 DIMM4.56
  TOP w0.216: DIMM4.56 161.75,74.97 161.75,78.44 164.75,81.44 164.75,88.38 arc(165,88.63) 165.25,88.38 165.25,85.5 arc(165.49,85.25) 165.74,85.5 165.74,88.81 164.75,89.8 164.75,97.82 159.21,103.37 159.21,106
M_MA_A8: length 56.2
  TOP w0.102: CPU1.AU18 158.34,111.13 158.69,110.77 158.69,110.22 158.93,109.98 158.93,109.28 159.2,109.01 159.2,108.33 158.87,108 158.87,106.51 158.83,106.47 158.83,106
  TOP w0.165: 161.19,75.16 161.19,73.88 161.75,73.31 161.75,72.53 160.74,71.52 160.74,69.28 DIMM4.177 161.12,68.9 161.12,66.35 161.65,65.82 161.65,64.46 160.93,63.74 DIMM2.177
  TOP w0.216: 158.83,106 158.83,103.16 164.37,97.62 164.37,84 163.66,83.29 163.66,82.86 164.32,82.2 164.32,81.72 161.19,78.59 161.19,75.16
M_MA_A9: length 57.8
  TOP w0.102: CPU1.AT19 159.25,112.04 158.9,111.69 158.9,111.22 159.13,110.98 159.4,110.98 159.62,110.76 159.62,110.3 159.62,110.29 159.62,110.29 159.63,110.28 159.63,109.48 159.96,109.15 159.96,107.94 159.7,107.68 159.7,106.81 159.98,106.53 159.98,105.98 159.97,105.98
  TOP w0.165: DIMM4.175 163.13,68.9 163.13,66.43 163.76,65.79 163.76,64.52 162.93,63.7 DIMM2.175
  TOP w0.216: 159.97,105.98 159.97,103.77 165.54,98.2 165.54,90.35 165.92,89.97 166.2,89.97 166.83,89.34 166.83,88.86 166.5,88.53 166.5,81.76 163.17,78.43 163.17,74.31 163.69,73.79 163.69,72.05 163.13,71.48 163.13,69.28 DIMM4.175
M_MA_A10: length 54
  TOP w0.102: CPU1.AW11 151.51,109.23 151.51,108.81 150.43,107.73 150.43,106.16 150.04,105.78 150.04,105.37
  TOP w0.165: DIMM2.70 147.55,67.4 147.55,68.72 147.65,68.82 147.65,69.68 147.15,70.19 147.15,71.64 147.93,72.42 DIMM4.70 147.93,75.62 147.94,75.62 147.94,75.85
  TOP w0.216: 147.94,75.85 147.94,79.36 151.98,83.4 151.98,88.47 arc(151.74,88.72) 151.49,88.47 151.49,85.37 arc(151.24,85.12) 150.99,85.37 150.99,91.64 150.04,92.59 150.04,105.37
M_MA_A11: length 55.5
  TOP w0.102: 159.59,105.97 159.59,106.52 159.42,106.69 159.42,107.78 159.71,108.07 159.71,109.08 159.38,109.41 159.38,110.19 159.25,110.31 CPU1.AV19
  TOP w0.165: DIMM4.55 162.72,72.67 162.72,70.26 162.14,69.68 162.14,68.38 162.74,67.77 162.74,65.31 DIMM2.55
  TOP w0.216: DIMM4.55 162.72,73.11 162.72,78.56 165.13,80.98 165.13,84.44 arc(165.38,84.69) 165.63,84.44 165.63,82.63 arc(165.88,82.38) 166.12,82.63 166.12,89.03 165.13,90.02 165.13,98 159.59,103.54 159.59,105.97
M_MA_A12: length 56.7
  TOP w0.102: 160.35,105.95 160.35,106.56 160,106.91 160,107.6 160.22,107.82 160.22,109.23 159.96,109.48 159.96,110.23 159.83,110.37 159.83,110.38 159.82,110.38 159.82,110.95 159.59,111.19 159.5,111.19 159.25,111.44 CPU1.AU19
  TOP w0.165: DIMM4.174 163.93,68.57 164.75,67.75 164.75,66.38 164.14,65.77 164.14,63.43 DIMM2.174
  TOP w0.216: DIMM4.174 164.18,71.23 164.18,73.58 164.73,74.12 164.73,79.36 166.89,81.52 166.89,88.02 arc(167.13,88.27) 167.38,88.02 167.38,87.43 arc(167.63,87.18) 167.88,87.43 167.88,89.03 166.1,90.81 166.1,98.23 160.35,103.98 160.35,105.95
M_MA_A13: length 51.5
  TOP w0.102: CPU1.AY10 148.07,108.91 148.07,107.65 146.66,106.23 146.66,105.88
  TOP w0.165: 143,75.85 143,75.52 142.93,75.46 142.93,74.35 142.37,73.79 142.27,73.79 141.93,73.45 DIMM4.196 141.93,70.47 142.12,70.28 142.12,68.61 143.12,67.61 143.12,66.55 142.12,65.54 142.12,63.41 DIMM2.196
  TOP w0.216: 146.66,105.88 146.66,89.89 145.86,89.09 145.86,84.8 145.36,84.3 145.03,84.3 144.69,83.96 144.69,83.62 arc(144.76,83.45) 144.93,83.37 145.12,83.37 arc(145.37,83.13) 145.12,82.88 144.93,82.88 arc(144.76,82.81) 144.69,82.63 144.69,81.24 143,79.55 143,75.85
M_MA_A14: length 57.1
  TOP w0.102: 161.07,105.87 161.07,106.76 160.73,107.11 160.73,109.36 160.4,109.69 160.4,110.27 160.51,110.38 160.51,110.38 160.52,110.4 160.52,110.77 160.43,110.87 160.43,111.19 160.52,111.29 160.52,111.69 160.17,112.04 CPU1.AT20
  TOP w0.165: DIMM4.172 165.74,70.8 165.74,68.38 165.13,67.77 165.13,66.43 165.93,65.63 DIMM2.172
  TOP w0.216: DIMM4.172 165.69,71.23 165.69,73.67 165.18,74.18 165.18,75.33 165.44,75.59 165.44,79.43 167.27,81.26 167.27,86.45 arc(167.51,86.7) 167.76,86.45 167.76,85.98 arc(168.01,85.73) 168.26,85.98 168.26,90.96 167.6,91.62 167.6,97.95 161.07,104.48 161.07,105.87
M_MA_A15: length 56.1
  TOP w0.102: 161.91,105.9 161.91,106.94 161.37,107.47 161.37,109.54 161.56,109.72 161.56,110.17 161.44,110.29 161.44,110.77 161.08,111.13 CPU1.AU21
  TOP w0.165: DIMM4.171 166.93,66.65 167.77,65.81 167.77,64.57 166.93,63.73 DIMM2.171
  TOP w0.216: 161.91,105.9 161.91,104.81 168.41,98.31 168.41,92.06 169.12,91.35 169.12,81.85 166.68,79.41 166.68,74.31 167.75,73.25 167.75,72.27 167.14,71.66 167.14,69.29 DIMM4.171
M_MA_B0: length 90.4
  TOP w0.102: CPU1.AL19 v4(158.8,117.43)
  GND w0.102: 158.38,107.25 158.38,107.54 158.6,107.76 158.6,109.78 158.82,110 158.82,114 158.36,114.46 158.36,115.78 158.64,116.06 158.99,116.06 159.26,116.33 159.26,116.64 v4(158.8,117.43)
  GND w0.152: DIMM1.188 149.93,43 149.13,43.8 149.13,47.62 148.22,48.53 148.22,49.59 149.65,51.02 DIMM3.188
  GND w0.178: 158.38,107.25 158.38,104.33 156.39,102.34 156.39,83.78 arc(156.17,83.55) 155.94,83.78 155.94,84.82 arc(155.71,85.05) 155.48,84.82 155.48,83.03 arc(155.46,82.95) 155.41,82.87 151.44,78.9 151.44,77.88 152.18,77.15 152.18,76.13 151.16,75.11 151.16,74.32 150.13,73.28 150.13,72.26 149.14,71.28 149.14,70.4 148.18,69.44 148.18,68.77 149.18,67.77 149.18,66.63 150.2,65.61 150.2,64.79 151.16,63.83 151.16,62.64 150.16,61.65 150.16,56.2 149.15,55.18 149.15,54.25 149.93,53.46 DIMM3.188
M_MA_B1: length 89.9
  TOP w0.102: CPU1.AK23 v4(163.37,118.35)
  GND w0.102: v4(163.37,118.35) 162.91,117.58 162.91,115.53 162.71,115.08 162.71,113.63 162.95,113.4 162.95,109.13 163.15,108.92 163.15,107.53 162.9,107.27 162.9,104.88 163.1,104.68
  GND w0.152: 158.43,55.4 158.63,55.21 158.63,54.54 157.74,53.65 157.74,52.37 157.13,51.77 157.13,49.32 DIMM3.181 156.93,47.52 157.56,46.89 157.56,45.63 157.07,45.13 157.07,44.25 157.74,43.58 157.74,42.02 156.93,41.22 DIMM1.181
  GND w0.178: 163.1,104.68 163.2,104.58 163.2,97.52 165.72,95 165.72,81.13 165.13,80.55 165.13,78.66 162.63,76.16 162.21,76.16 161.17,75.11 161.17,74.33 160.15,73.31 160.15,72.57 161.17,71.56 161.17,70.42 160.15,69.41 160.15,68.7 161.19,67.66 161.19,66.52 160.19,65.52 160.19,64.76 161.19,63.76 161.19,62.73 160.18,61.73 160.18,58.27 159.9,58 159.09,58 158.83,57.74 158.83,56.88 158.43,56.47 158.43,55.4
M_MA_B2: length 93.1
  TOP w0.102: CPU1.AM22 v4(162.45,116.52)
  GND w0.102: 162.59,104.43 162.47,104.55 162.47,107.65 162.26,107.86 162.26,108.85 162.64,109.22 162.64,113.19 162.45,113.38 162.45,114.99 161.99,115.45 161.99,115.68 v4(162.45,116.52)
  GND w0.152: DIMM1.61 156.93,43.6 156.67,43.86 156.67,46.84 156.17,47.35 156.17,49.85 156.74,50.42 156.74,52.72 DIMM3.61 157.25,53.24 157.25,55.14 157.44,55.33 157.44,55.33
  GND w0.178: 157.44,55.33 157.51,55.41 157.51,57.72 158.55,58.76 158.93,58.76 159.67,59.49 159.67,61.87 160.73,62.92 160.73,63.57 159.73,64.57 159.73,65.71 160.73,66.71 160.73,67.47 159.69,68.51 159.69,69.59 160.68,70.59 160.68,71.39 159.7,72.38 159.7,73.5 160.68,74.49 160.68,76.03 162.05,77.39 arc(162.21,77.46) 162.37,77.39 162.46,77.31 arc(162.78,77.31) 162.78,77.63 162.69,77.71 arc(162.63,77.88) 162.69,78.04 163.12,78.46 arc(163.12,78.78) 162.79,78.78 160.4,76.39 arc(160.07,76.39) 160.07,76.71 162.98,79.62 arc(163.14,79.69) 163.31,79.62 163.63,79.3 arc(163.95,79.3) 163.95,79.62 163.63,79.94 arc(163.56,80.11) 163.63,80.27 165.18,81.82 165.18,94.77 162.72,97.24 162.72,104.3 162.59,104.43
M_MA_B3: length 89.1
  TOP w0.102: CPU1.AM23 v4(163.37,115.6)
  GND w0.102: v4(163.37,115.6) 162.94,114.82 162.94,114.04 163.91,113.06 163.91,109.35 163.51,108.95 163.51,107.18 163.33,107 163.33,105.25 163.6,104.99
  GND w0.152: 158.91,55.4 158.91,55.4 158.91,54.24 158.13,53.46 158.13,51.22 DIMM3.180 157.74,50.83 157.74,47.86 158.74,46.87 158.74,43.85 158.13,43.25 158.13,40.9 DIMM1.180
  GND w0.178: 158.91,55.4 158.91,56.27 160.64,58 160.64,59.48 161.72,60.56 161.72,61.87 162.7,62.86 162.7,63.6 161.73,64.57 161.73,65.67 162.71,66.65 162.71,67.44 161.74,68.41 161.74,69.66 162.71,70.64 162.71,71.36 161.69,72.39 161.69,73.41 162.68,74.41 162.68,75.56 165.62,78.49 165.62,80.37 166.17,80.95 166.17,84.79 167.09,85.71 167.09,88 arc(166.86,88.23) 166.63,88 166.63,86.44 arc(166.4,86.21) 166.17,86.44 166.17,95.23 163.76,97.65 163.76,104.82 163.6,104.99
M_MA_B4: length 91.6
  TOP w0.102: CPU1.AP23 v4(163.39,114.69)
  GND w0.102: 164.13,105.19 163.76,105.56 163.76,106.71 163.86,106.81 163.86,108.59 164.24,108.97 164.24,113.42 163.39,114.27 v4(163.39,114.69)
  GND w0.152: DIMM1.59 159.13,42.8 159.13,47.33 158.13,48.33 158.13,49.75 158.74,50.35 158.74,52.73 DIMM3.59 159.21,53.2 159.21,55.14 159.47,55.4
  GND w0.178: 159.47,55.4 159.47,56.12 161.14,57.79 161.14,59.34 162.17,60.37 162.17,61.68 163.16,62.67 163.16,63.79 162.19,64.76 162.19,65.48 163.17,66.47 163.17,67.63 162.2,68.6 162.2,69.47 163.17,70.45 163.17,71.55 162.15,72.58 162.15,73.22 163.2,74.27 163.2,75.41 166.07,78.29 166.07,80.17 166.63,80.73 166.63,84.6 167.55,85.52 167.55,94.07 arc(167.32,94.3) 167.09,94.07 167.09,89.67 arc(166.86,89.44) 166.63,89.67 166.63,95.58 164.28,97.93 164.28,105.04 164.13,105.19
M_MA_B5: length 87.5
  TOP w0.102: CPU1.AL23 v4(163.37,117.43)
  GND w0.102: v4(163.37,117.43) 163.85,116.72 163.85,114.49 164.62,113.71 164.62,108.72 164.2,108.29 164.2,105.81 164.59,105.42
  GND w0.152: DIMM1.58 159.74,44.7 159.74,49.83 159.13,50.43 159.13,51.68 159.73,52.27 159.73,54.62 DIMM3.58 160.05,54.94 160.05,55.4
  GND w0.178: 160.05,55.4 160.05,55.96 161.65,57.56 161.65,59.2 162.58,60.13 163.25,60.13 163.68,60.56 163.68,61.83 164.7,62.84 164.7,63.58 163.68,64.59 163.68,65.66 164.68,66.66 164.68,67.49 163.7,68.47 163.7,69.63 164.7,70.63 164.7,71.35 163.7,72.35 163.7,73.41 164.7,74.41 164.7,76 166.58,77.88 166.58,79.79 167.11,80.32 167.11,84.21 arc(167.34,84.44) 167.57,84.21 167.57,82.35 arc(167.8,82.13) 168.03,82.35 168.03,94.83 164.8,98.06 164.8,105.21 164.59,105.42
M_MA_B6: length 84.1
  TOP w0.102: v4(165.31,104.83) 165.26,104.83 164.89,105.2 164.89,105.2 163.78,106.31 163.78,108.7 CPU1.AY24
  GND w0.152: DIMM3.178 160.13,50.82 160.13,47.47 160.74,46.87 160.74,43.77 159.93,42.97 DIMM1.178
  GND w0.178: DIMM3.178 160.14,51.22 160.14,53.54 160.71,54.11 160.71,55.66 162.16,57.12 162.16,59.06 162.77,59.67 163.44,59.67 164.14,60.37 164.14,61.64 165.15,62.65 165.15,63.77 164.14,64.78 164.14,65.47 165.14,66.47 165.14,67.67 164.15,68.66 164.15,69.44 165.15,70.44 165.15,71.54 164.15,72.54 164.15,73.22 165.15,74.22 165.15,75.52 167.09,77.45 167.09,79.19 168.56,80.66 168.56,88.99 169.4,89.83 169.4,93.3 arc(169.17,93.53) 168.94,93.3 168.94,90.74 arc(168.71,90.51) 168.49,90.74 168.49,95.26 165.41,98.33 165.41,104.74 v4(165.31,104.83)
M_MA_B7: length 86.2
  TOP w0.102: CPU1.AV25 164.74,110.32 164.38,109.96 164.38,108.32 164.19,108.12 164.19,107.3 v4(164.69,106.79)
  GND w0.152: DIMM1.56 161.74,44.7 161.74,49.8 161.15,50.39 161.15,51.4 162.15,52.4 162.15,54.61 DIMM3.56 162.16,55.05 162.16,55.4
  GND w0.178: v4(164.69,106.79) 164.93,106.79 166.35,105.37 166.35,99.19 170.31,95.23 170.31,89.69 arc(170.54,89.46) 170.77,89.69 170.77,93.86 arc(171,94.09) 171.23,93.86 171.23,81.8 168.1,78.66 168.1,76.68 167.17,75.75 167.17,74.25 166.16,73.24 166.16,72.53 167.17,71.52 167.17,70.43 166.15,69.41 166.15,68.73 167.19,67.7 167.19,66.48 166.17,65.47 166.17,64.77 167.16,63.78 167.16,62.66 166.19,61.68 166.19,60.01 165.77,59.6 165.26,59.6 163.99,58.33 163.99,57.5 162.16,55.67 162.16,55.4
M_MA_B8: length 86.7
  TOP w0.102: CPU1.AU26 165.15,110.98 164.59,110.98 164.38,110.77 164.38,110.25 164.18,110.05 164.18,108.55 163.98,108.35 163.98,106.72 v4(164.73,105.98)
  GND w0.152: DIMM3.177 161.13,48.93 161.13,43.86 161.85,43.15 161.85,42.07 160.93,41.16 DIMM1.177
  GND w0.178: DIMM3.177 160.75,49.31 160.75,51.57 161.74,52.57 161.74,53.52 161.16,54.1 161.16,55.45 163.51,57.79 163.51,58.49 165.12,60.1 165.39,60.1 165.73,60.44 165.73,61.87 166.7,62.85 166.7,63.59 165.72,64.58 165.72,65.66 166.73,66.67 166.73,67.47 165.7,68.5 165.7,69.6 166.71,70.62 166.71,71.34 165.7,72.34 165.7,73.43 166.71,74.44 166.71,76.06 167.62,76.97 167.62,79.08 169.93,81.39 169.93,83.19 arc(169.7,83.42) 169.48,83.19 169.48,82.76 arc(169.25,82.53) 169.02,82.76 169.02,88.81 169.86,89.64 169.86,94.72 165.89,98.69 165.89,105.1 165.02,105.98 v4(164.73,105.98)
M_MA_B9: length 85.2
  TOP w0.102: CPU1.AW25 165.09,108.89 165.09,107.18 v4(167.37,104.91)
  GND w0.152: DIMM1.175 162.93,41.16 163.74,41.96 163.74,43.34 163.13,43.94 163.13,48.93 DIMM3.175
  GND w0.178: DIMM3.175 163.13,49.31 163.13,51.72 163.73,52.33 163.73,53.63 163.14,54.22 163.14,55.32 164.12,56.29 164.47,56.29 167.01,58.83 167.8,58.83 168.18,59.21 168.18,61.69 169.19,62.7 169.19,63.75 168.2,64.74 168.2,65.5 169.17,66.47 169.17,67.68 168.17,68.68 168.17,69.42 169.17,70.42 169.17,71.53 168.17,72.53 168.17,73.3 169.17,74.29 169.17,77.73 173.06,81.62 173.06,87.27 arc(172.83,87.5) 172.6,87.27 172.6,86.54 arc(172.37,86.32) 172.14,86.54 172.14,95 167.37,99.77 v4(167.37,104.91)
M_MA_B10: length 93
  TOP w0.102: CPU1.AP18 158.31,114.23 v4(157.86,113.77)
  GND w0.102: v4(157.86,113.77) 158.31,113.32 158.31,110.5 157.94,110.12 157.94,107.85 157.54,107.46 157.54,105.14 157.3,104.9
  GND w0.152: DIMM1.70 147.93,46.65 147.32,47.26 147.32,48.33 147.64,48.65 147.64,49.77 147.13,50.28 147.13,51.67 147.73,52.27 147.73,54.61 DIMM3.70
  GND w0.178: DIMM3.70 147.93,54.83 147.93,55.43 149.21,56.72 149.21,59.93 148.99,60.15 148.5,60.15 148.2,60.45 148.2,61.63 149.18,62.61 149.18,63.79 148.18,64.79 148.18,65.68 147.18,66.68 147.18,67.71 146.17,68.72 146.17,69.38 147.17,70.38 147.17,71.28 148.18,72.29 148.18,73.24 149.2,74.26 149.2,75.7 149.99,76.49 149.99,78.95 154.54,83.5 154.54,95.49 arc(154.77,95.71) 155,95.49 155,89.01 arc(155.23,88.78) 155.46,89.01 155.46,102.96 arc(155.47,103.05) 155.52,103.12 157.3,104.9
M_MA_B11: length 83.1
  TOP w0.102: CPU1.AY25 164.74,108.28 164.65,108.19 v4(164.65,107.73)
  GND w0.152: DIMM3.55 162.72,52.71 162.72,50.35 162.13,49.76 162.13,48.63 162.73,48.02 162.73,42.8 DIMM1.55
  GND w0.178: DIMM3.55 162.72,53.13 162.72,55.58 164.5,57.36 164.5,58.15 165.44,59.09 166.02,59.09 167.72,60.79 167.72,61.88 168.73,62.89 168.73,63.55 167.73,64.56 167.73,65.72 168.71,66.7 168.71,67.49 167.71,68.49 167.71,69.61 168.71,70.61 168.71,71.34 167.71,72.34 167.71,73.49 168.68,74.45 168.68,78.28 172.6,82.2 172.6,85.27 arc(172.37,85.5) 172.14,85.27 172.14,82.81 arc(171.91,82.58) 171.69,82.81 171.69,94.75 166.81,99.63 166.81,105.57 v4(164.65,107.73)
M_MA_B12: length 85.6
  TOP w0.102: CPU1.AV26 165.62,110.57 v3(165.18,110.13)
  GND w0.152: DIMM1.174 164.13,40.9 164.13,43.2 164.74,43.81 164.74,47.6 163.98,48.36 163.98,50.98 DIMM3.174
  GND w0.178: DIMM3.174 164.15,51.24 164.15,53.49 164.73,54.06 164.73,55.9 167.15,58.33 168.8,58.33 169.69,59.21 169.69,77.36 173.51,81.19 173.51,91.09 arc(173.29,91.32) 173.06,91.09 173.06,88.4 arc(172.83,88.17) 172.6,88.4 172.6,95.36 167.93,100.03 167.93,105.1 166.6,106.42 166.6,107.26 165.99,107.87 165.99,109.33 v3(165.18,110.13)
M_MA_B13: length 90.7
  TOP w0.102: CPU1.AR15 155.16,113.75 v4(155.16,113.77)
  GND w0.102: v4(155.16,113.77) 155.34,113.4 155.6,113.13 155.6,110.82 154.58,109.8 154.58,108.92 154.16,108.49 154.16,107.41 153.91,107.15
  GND w0.152: 142.94,55.4 142.94,54.4 141.93,53.39 141.93,51.03 DIMM3.196 142.13,50.83 142.13,48.61 143.12,47.63 143.12,43.93 142.13,42.94 142.13,40.89 DIMM1.196
  GND w0.178: 142.94,55.4 142.94,56.07 141.84,57.17 141.84,58.82 140.19,60.47 140.19,61.7 141.15,62.67 141.15,63.77 140.15,64.77 140.15,65.68 139.17,66.66 139.17,67.62 138.16,68.64 138.16,69.39 139.15,70.38 139.15,71.33 140.17,72.35 140.17,73.23 141.17,74.23 141.17,75.54 141.92,76.28 141.92,79.03 arc(142.15,79.26) 142.37,79.03 142.37,76.84 arc(142.6,76.61) 142.83,76.84 142.83,80.32 150.4,87.89 150.4,103.65 153.91,107.15
M_MA_B14: length 85.8
  TOP w0.102: v3(166.11,111.07) 166.57,110.61 CPU1.AV27
  GND w0.152: DIMM1.172 165.93,43.02 165.13,43.82 165.13,47.68 165.73,48.28 165.73,50.81 DIMM3.172
  GND w0.178: DIMM3.172 165.74,51.21 165.74,53.52 165.15,54.12 165.15,55.25 165.26,55.36 165.26,55.78 165.44,55.96 165.44,55.97 167.29,57.82 168.94,57.82 170.77,59.64 170.77,62.15 170.17,62.75 170.17,64.99 170.69,65.52 170.69,69.93 170.17,70.45 170.17,76.95 173.97,80.75 173.97,94.06 arc(173.74,94.29) 173.51,94.06 173.51,92.12 arc(173.29,91.89) 173.06,92.12 173.06,95.82 168.41,100.46 168.41,105.27 167.14,106.53 167.14,110.04 v3(166.11,111.07)
M_MA_B15: length 82.9
  TOP w0.102: v4(169.4,103.28) 168.84,103.84 168.84,106.08 168.1,106.82 168.1,107.61 167.48,108.23 CPU1.AY28
  GND w0.152: DIMM1.171 166.93,41.05 167.75,41.87 167.75,43.21 166.93,44.03 DIMM3.171
  GND w0.178: v4(169.4,103.28) 169.4,101.12 174.89,95.64 174.89,85.91 arc(175.11,85.68) 175.34,85.91 175.34,86.77 arc(175.57,87) 175.8,86.77 175.8,80.89 172.09,77.19 172.09,74.16 173.19,73.07 173.19,70.64 172.93,70.38 172.93,65.76 173.19,65.51 173.19,62.22 172.63,61.65 172.63,59.85 169.59,56.81 168.45,56.81 168.07,56.43 168.07,56 167.04,54.97 167.04,54.26 167.75,53.55 167.75,52.34 167.15,51.74 167.15,49.33 DIMM3.171
M_ODT_A0: length 50.4
  TOP w0.102: 147.1,105.9 147.1,106.21 148.35,107.46 148.35,108.56 149.18,109.38 149.18,110.22 CPU1.AW10
  TOP w0.165: DIMM4.195 142.65,69.37 142.65,71.44 142.32,71.78 142.32,72.29 142.22,72.39 142.22,73.19 143.22,74.19 143.22,75.09 143.48,75.35 143.48,79.42 145.12,81.06 145.12,82.15 146.29,83.32 146.29,88.61 arc(146.49,88.82) 146.7,88.61 146.7,86.29 arc(146.9,86.09) 147.1,86.29 147.1,105.9
M_ODT_A1: length 48.3
  TOP w0.102: 145.4,105.72 145.4,106.34 147.15,108.09 147.15,109.24 146.99,109.39 CPU1.AY8
  TOP w0.165: 145.4,105.72 145.4,96.65 arc(145.19,96.45) 144.99,96.65 144.99,100.64 arc(144.79,100.85) 144.58,100.64 144.58,85.61 143.36,84.4 143.36,81.74 141.22,79.6 141.22,74.17 140.93,73.88 DIMM4.77
M_ODT_A2: length 55
  TOP w0.102: CPU1.AW9 147.55,109.86 147.55,109.46 147.77,109.25 147.77,107.79 146.21,106.23 146.21,105.72
  TOP w0.165: DIMM2.195 142.68,61.32 141.13,62.87 141.13,63.91 141.74,64.52 141.74,65.7 142.74,66.7 142.74,67.43 141.74,68.43 141.74,69.65 141.12,70.27 141.12,71.86 141.65,72.39 141.65,73.19 141.51,73.32 141.51,73.73 141.85,74.07 142.23,74.07 142.65,74.49 142.65,75.21 142.34,75.52 142.34,79.51 144.25,81.42 144.25,84.13 145.43,85.31 145.43,89.27 146.21,90.05 146.21,105.72
M_ODT_A3: length 57.2
  TOP w0.102: CPU1.AU8 146.54,111.95 146.54,110.38 146.44,110.28 146.44,109.3 146.59,109.15 146.59,108.39 144.58,106.39 144.58,105.72
  TOP w0.165: 144.58,105.72 144.58,102.22 143.67,101.3 143.67,85.9 141.54,83.77 arc(141.48,83.62) 141.54,83.48 141.64,83.38 arc(141.64,83.09) 141.35,83.09 141.25,83.19 arc(141.11,83.25) 140.96,83.19 140.85,83.08 arc(140.8,83.01) 140.79,82.93 140.79,80.55 arc(140.58,80.35) 140.38,80.55 140.38,81.6 arc(140.18,81.8) 139.97,81.6 139.97,79.08 arc(139.77,78.87) 139.57,79.08 139.57,79.38 arc(139.36,79.59) 139.16,79.38 139.16,74.22 139.74,73.64 139.74,72.25 139.1,71.61 139.1,70.35 139.75,69.7 139.75,68.42 140.93,67.23 DIMM2.77
M_ODT_B0: length 81.8
  TOP w0.102: v4(156.94,116.52) 157.4,116.06 CPU1.AM17
  GND w0.102: 154.61,107.12 154.8,107.42 155.16,107.89 155.16,108.43 154.95,108.64 154.95,109.7 155.88,110.62 155.88,113.3 155.62,113.56 155.62,114.9 155.87,115.15 156.23,115.15 156.49,115.41 156.49,116.06 v4(156.94,116.52)
  GND w0.14: DIMM3.195 142.52,49.54 142.52,50.59 142.64,50.72 142.64,51.84 142.22,52.25 142.22,53.22 142.63,53.63 142.93,53.63 143.25,53.94 143.25,55.16 143.59,55.51 143.59,56.15 142.42,57.32 142.42,59.49 141.68,60.23 141.68,61.85 142.68,62.85 142.68,63.56 141.68,64.55 141.68,65.48 140.68,66.48 140.68,67.43 139.67,68.44 139.67,69.64 140.69,70.66 140.69,71.55 141.69,72.55 141.69,73.44 142.68,74.43 142.68,75.78 143.52,76.61 143.52,78.89 144.98,80.35 arc(144.98,80.69) 144.63,80.69 144.19,80.25 arc(143.84,80.25) 143.84,80.6 150.91,87.66 150.91,103.42 154.61,107.12
M_ODT_B1: length 80.1
  TOP w0.102: CPU1.AL16 v4(156.05,117.43)
  GND w0.102: v4(156.05,117.43) 155.57,116.95 155.57,116.34 155.31,116.08 154.91,116.08 154.25,115.42 154.25,112.14 153.44,111.33 153.44,109.6 153.27,109.43
  GND w0.14: DIMM3.77 141.14,53.12 141.14,55.58 137.7,59.02 137.7,61.88 138.72,62.9 138.72,63.56 137.7,64.57 137.7,65.49 136.7,66.49 136.7,67.45 135.71,68.44 135.71,69.62 136.71,70.62 136.71,71.53 137.71,72.53 137.71,73.46 138.7,74.45 138.7,76.02 139.24,76.55 139.24,78.87 147.92,87.55 147.92,95.37 arc(148.16,95.61) 148.41,95.37 148.41,94.4 arc(148.65,94.15) 148.9,94.4 148.9,104.32 151.66,107.08 151.66,107.82 153.27,109.43
M_ODT_B2: length 91.6
  TOP w0.102: CPU1.AM16 156.48,116.06 v4(156.03,116.52)
  GND w0.102: v4(156.03,116.52) 155.63,115.79 155.57,115.38 155,114.39 154.7,113.9 154.7,110.92 154.17,109.73 154.17,109.12 153.75,108.69 153.75,107.74 153.1,107.09
  GND w0.14: DIMM1.195 142.57,38.8 141.15,40.22 141.15,41.38 141.74,41.97 141.74,43.1 142.73,44.09 142.73,47.15 141.74,48.14 141.74,49.66 141.12,50.28 141.12,51.79 141.63,52.3 141.63,53.72 142.02,54.11 142.21,54.11 142.62,54.52 142.62,55.13 142.42,55.33 142.42,55.77 140.27,57.92 140.27,59.65 139.68,60.23 139.68,61.87 140.68,62.87 140.68,63.57 139.68,64.57 139.68,65.48 138.69,66.46 138.69,67.43 137.68,68.44 137.68,69.59 138.67,70.58 138.67,71.53 139.69,72.55 139.69,73.42 140.7,74.43 140.7,76.16 141.31,76.77 141.31,79.52 149.89,88.1 149.89,103.88 151.59,105.57 153.1,107.09
M_ODT_B3: length 94.3
  TOP w0.102: CPU1.AK15 v4(155.14,118.35)
  GND w0.102: v4(155.14,118.35) 154.39,117.91 154.1,117.91 153.76,117.58 153.76,112.43 152.72,111.39 152.72,110.71
  GND w0.14: DIMM1.77 140.93,44.78 140.19,45.52 139.57,45.52 138.97,46.12 138.97,46.78 139.11,46.91 139.3,46.91 139.54,46.68 139.77,46.68 139.91,46.81 139.91,47.78 139.71,47.98 139.71,49.6 139.07,50.23 139.07,51.53 139.73,52.19 139.73,53.6 138.89,54.44 138.89,56.42 135.7,59.61 135.7,61.83 136.7,62.83 136.7,63.59 135.71,64.57 135.71,65.46 134.71,66.46 134.71,67.44 133.71,68.44 133.71,69.63 134.71,70.64 134.71,71.54 135.72,72.54 135.72,73.43 136.71,74.42 136.71,75.85 138.2,77.34 138.2,79.23 146.94,87.97 146.94,99.03 arc(147.18,99.27) 147.43,99.03 147.43,98.36 arc(147.67,98.11) 147.92,98.36 147.92,104.87 150.68,107.64 150.68,108.28 152.72,110.33 152.72,110.71
M_RAS_A_L: length 56.9
  TOP w0.102: 149.24,105.55 149.24,105.9 149.84,106.5 149.84,108.01 150.77,108.94 150.77,110.44 151.43,111.1 152.1,111.1 152.49,111.49 CPU1.AU12
  TOP w0.165: DIMM2.192 145.93,65.65 146.72,66.43 146.72,67.52 145.93,68.3 DIMM4.192
  TOP w0.216: 149.24,105.55 149.24,86.23 arc(149.48,85.99) 149.73,86.23 149.73,87.51 arc(149.98,87.76) 150.23,87.51 150.23,82.86 146.88,79.52 146.88,75.83 146.69,75.64 146.69,73.85 145.93,73.09 DIMM4.192
M_RAS_B_L: length 93.6
  TOP w0.102: v4(157.88,116.52) CPU1.AM18
  GND w0.102: 156.78,107.07 156.78,107.24 156.58,107.43 156.58,108.33 157.17,108.92 157.17,113.33 157.2,113.36 157.2,114.04 157.65,114.49 157.65,116.29 v4(157.88,116.52)
  GND w0.152: DIMM1.192 145.93,43.02 146.74,43.83 146.74,45.73 145.93,46.54 145.93,51.01 DIMM3.192 145.93,53.22 146.54,53.83
  GND w0.178: 156.78,107.07 156.78,105.73 154.54,103.49 154.54,99.02 arc(154.31,98.79) 154.08,99.02 154.08,102.47 arc(153.85,102.7) 153.63,102.47 153.63,84.01 148.11,78.5 148.11,78.06 148.47,77.71 148.47,77.1 147.14,75.77 147.14,74.25 146.16,73.27 146.16,72.28 145.17,71.29 145.17,70.41 144.18,69.43 144.18,68.76 145.19,67.75 145.19,66.62 146.2,65.61 146.2,64.7 147.15,63.74 147.15,62.6 146.2,61.64 146.2,60.5 146.92,59.77 146.92,54.21 146.54,53.83
M_WE_A_L: length 56.2
  TOP w0.102: CPU1.AU11 151.24,111.49 150.43,110.69 150.43,109 149.56,108.13 149.56,106.73 148.83,106 148.83,105.52
  TOP w0.165: DIMM2.73 145.16,65.35 145.16,67.97 145.65,68.46 145.65,69.75 145.17,70.24 145.17,72.65 DIMM4.73 145.44,73.4 145.44,74.27 145.22,74.49 145.22,75.29 145.37,75.44 145.37,75.85
  TOP w0.216: 148.83,105.52 148.83,83.34 arc(149.08,83.09) 149.32,83.34 149.32,85.24 arc(149.57,85.49) 149.82,85.24 149.82,82.99 145.37,78.54 145.37,75.85
M_WE_B_L: length 90.7
  TOP w0.102: CPU1.AK16 v4(156.97,118.35)
  GND w0.102: 156.34,107.17 156.31,107.2 156.31,108.44 156.92,109.05 156.92,113.37 156.97,113.42 156.97,114.1 157.43,114.56 157.43,117.53 v4(156.97,118.35)
  GND w0.152: DIMM1.73 145.13,42.8 145.13,48.17 145.64,48.68 145.64,49.52 145.19,49.97 145.19,52.66 DIMM3.73 144.93,52.93 146.08,54.08 146.19,54.08 146.62,54.51 146.62,55.12 146.34,55.4
  GND w0.178: 146.34,55.4 146.34,55.61 145.96,55.99 145.96,60.08 145.7,60.33 145.7,61.93 146.67,62.9 146.67,63.54 145.67,64.54 145.67,65.45 144.67,66.45 144.67,67.37 143.69,68.35 143.69,69.63 144.68,70.62 144.68,71.56 145.7,72.58 145.7,73.5 146.68,74.48 146.68,75.63 146.52,75.79 146.52,76.18 147.63,77.3 147.63,78.67 152.99,84.03 arc(152.99,84.36) 152.67,84.36 151.3,82.99 arc(150.98,82.99) 150.98,83.31 152.89,85.23 153.17,85.5 153.17,102.78 156.34,105.95 156.34,107.17
MDI0N: length 35
  TOP w0.102: v2(85.76,216.94) 85.54,216.72 85.03,216.72 84.44,216.13 84.44,214.58 R767.1
  BOTTOM w0.102: 93.47,218.29 93.2,218.02 87.71,218.02 86.37,216.67 86.02,216.67 v2(85.76,216.94) 85.76,216.87 85.55,216.67 85.27,216.67 85.17,216.77 85.17,217.15 84.81,217.51 84.44,217.51 84.2,217.74 SR7.1 ; 93.47,218.29 SC2.1 ; 93.47,218.29 93.47,218.28 93.68,218.07 95.47,218.07 SU1.3 95.64,218.07 96.4,218.07 96.93,218.6 100.37,218.6 102.15,220.39 105.31,220.39 108.65,223.73 109.78,223.73 USB3_LAN.21
MDI0P: length 34.9
  TOP w0.102: R766.1 85.15,214.28 84.87,214.28 84.79,214.36 84.79,215.98 85.17,216.36 85.61,216.36 85.76,216.21 v2(85.76,216.05)
  BOTTOM w0.102: 93.47,217.39 93.2,217.66 87.86,217.66 86.51,216.31 86.02,216.31 v2(85.76,216.05) 85.49,216.31 85.12,216.31 84.82,216.62 84.82,217 84.67,217.15 84.36,217.15 84.2,216.99 SR8.1 ; 93.47,217.39 93.47,217.4 93.78,217.71 96.62,217.71 97.13,218.22 97.99,218.22 SU1.4 98.15,218.24 100.51,218.24 102.3,220.03 105.45,220.03 108.78,223.35 109.68,223.35 109.83,223.2 109.83,222.52 USB3_LAN.20 ; 93.47,217.39 SC1.1
MDI1N: length 42
  TOP w0.102: R769.1 81.9,214.58 81.9,215.11 82.49,215.7 83.26,215.7 v2(83.47,215.92)
  BOTTOM w0.102: 89.79,216.49 89.79,216.44 89.55,216.2 87.68,216.2 86.11,214.64 85.14,214.64 84.13,215.65 83.74,215.65 v2(83.47,215.92) 83.18,215.63 82.54,215.63 SR9.1 ; 89.79,216.49 SC4.1 ; 89.79,216.49 90.08,216.2 90.82,216.2 90.96,216.06 95.36,216.06 SU1.1 95.75,216.06 96.43,216.06 97.06,216.69 102.22,216.69 102.88,217.35 109.02,217.35 110.52,218.85 110.52,223.04 110.73,223.25 111.16,223.68 112.27,223.68 USB3_LAN.23
MDI1P: length 42
  TOP w0.102: R768.1 82.63,214.3 82.35,214.3 82.25,214.4 82.25,214.97 82.63,215.35 83.34,215.35 83.47,215.22 v2(83.47,215.03)
  BOTTOM w0.102: 89.79,215.6 89.79,215.65 89.98,215.84 90.68,215.84 90.82,215.7 96.57,215.7 97.21,216.34 97.97,216.34 SU1.6 98.14,216.34 102.37,216.34 103.03,217 109.17,217 110.88,218.71 110.88,222.9 111.31,223.33 112.32,223.33 112.55,223.1 112.55,222.7 USB3_LAN.22 ; 89.79,215.6 SC3.1 ; 89.79,215.6 89.55,215.84 87.82,215.84 86.26,214.28 85,214.28 83.98,215.3 83.74,215.3 v2(83.47,215.03) 83.23,215.27 82.59,215.27 SR10.1
MDI2N: length 50.7
  TOP w0.102: R771.1 77.8,215.73 78.47,215.73 79.03,215.17 79.03,214.33 v2(79.33,214.03)
  BOTTOM w0.102: 86.23,213.06 86.23,213.04 86.41,212.87 86.54,212.87 86.8,213.13 86.8,213.8 87.51,214.51 90.44,214.51 90.94,215.02 94.42,215.02 94.77,214.66 96.55,214.66 97.21,214 97.97,214 SU2.1 98.14,214 100.1,214 101.63,215.53 102.53,215.53 103.4,216.39 109.43,216.39 113.32,220.28 113.32,223.04 113.88,223.61 115.4,223.61 115.83,224.03 USB3_LAN.25 ; 86.23,213.06 86.05,212.87 83.23,212.87 82.73,213.37 79.19,213.37 79.03,213.53 79.03,213.72 v2(79.33,214.03) 79.15,214.03 79.03,214.15 79.03,214.62 SR11.1 ; 86.23,213.06 SC6.1
MDI2P: length 50.7
  TOP w0.102: v2(78.37,214.03) 78.67,214.33 78.67,215.02 78.32,215.37 77.5,215.37 77.42,215.3 77.42,215.09 R770.1
  BOTTOM w0.102: SR12.1 78.67,214.62 78.67,214.15 78.54,214.03 v2(78.37,214.03) 78.67,213.72 78.67,213.38 79.04,213.01 82.59,213.01 83.08,212.52 86.05,212.52 86.23,212.33 86.23,212.32 ; 86.23,212.32 86.43,212.52 86.69,212.52 87.15,212.98 87.15,213.65 87.66,214.15 90.58,214.15 91.09,214.66 94.27,214.66 94.63,214.31 95.34,214.31 SU2.6 95.78,214.31 96.41,214.31 97.07,213.65 100.25,213.65 101.77,215.17 102.68,215.17 103.54,216.03 109.58,216.03 113.67,220.13 113.67,222.9 114.03,223.25 114.69,223.25 114.89,223.04 114.89,222.49 USB3_LAN.24 ; 86.23,212.32 SC5.1
MDI3N: length 45.2
  TOP w0.102: v2(88.04,212.76) 87.73,212.44 87.21,212.44 86.81,212.84 86.81,213.46 86.91,213.55 87.21,213.55 87.28,213.48 R773.1
  BOTTOM w0.102: 89.79,212.74 89.79,212.72 89.56,212.49 88.31,212.49 v2(88.04,212.76) 87.78,212.49 87.53,212.49 86.95,211.91 86.95,210.82 86.73,210.6 86.61,210.6 SR13.1 ; 89.79,212.74 90.04,212.49 90.72,212.49 91.09,212.12 94.01,212.12 94.52,212.63 96.68,212.63 97.21,212.1 97.97,212.1 SU2.3 98.15,212.1 99.58,212.1 101.93,214.45 102.95,214.45 103.87,215.37 111.39,215.37 113.14,217.12 113.14,217.91 115.86,220.63 115.86,223.09 116.5,223.73 117.87,223.73 118.37,224.24 USB3_LAN.27 ; 89.79,212.74 SC8.1
MDI3P: length 45.3
  TOP w0.102: v2(88.04,211.87) 87.83,212.08 87.07,212.08 86.46,212.69 86.46,213.23 R772.1
  BOTTOM w0.102: USB3_LAN.26 117.69,222.75 117.69,223.25 117.56,223.38 116.64,223.38 116.21,222.95 116.21,220.48 113.49,217.76 113.49,216.97 111.54,215.02 104.02,215.02 103.1,214.09 102.07,214.09 99.72,211.74 97.07,211.74 96.53,212.27 95.64,212.27 SU2.4 95.47,212.27 94.67,212.27 94.16,211.77 90.94,211.77 90.58,212.14 90,212.14 89.79,211.93 ; 89.79,211.93 89.79,211.96 89.61,212.14 88.31,212.14 v2(88.04,211.87) 88.04,211.93 87.84,212.14 87.68,212.14 87.31,211.77 87.31,210.67 86.88,210.24 86.51,210.24 SR14.1 ; 89.79,211.93 SC7.1
ME_1P05_N1: length 4.5
  TOP w0.508: QN60.B 83.01,51.32 v2(83.98,51.32) 83.98,50.32 84.11,50.2 R621.2 83.92,49.66 82.96,48.71 R614.1
ME_1P05_N2: length 5.1
  TOP w0.508: QN60.C 83.98,54.85 v2(84.21,55.07) 84.61,55.48 84.61,56.46 R615.1 85.25,57.1 R617.2
ME_1P05_N3: length 7.7
  TOP w0.508: R617.1 C583.2 86.39,60.59 v2(86.62,60.81) 86.39,61.04 86.39,63.79 85.5,64.68 QP8.B
ME_1P05_N4: length 1.1
  TOP w0.305: C592.1 R618.1
ME_EN: length 5.6
  TOP w0.305: U33.1 77.91,65.21 78.26,65.56 v2(79.59,65.56) 79.74,65.72 R619.2 81.79,65.72 81.82,65.69 QP8.C
MIC1_JD: length 95.9
  TOP w0.254: R502.2 v2(28.07,218.19) ; v2(89.57,237.65) 90.08,238.16 92.58,238.16 AUDIO.1Q ; v2(30.13,225.84) 30.13,226.22 29.37,226.98 29.37,230.67 28.66,231.38 28.66,239.86 31.66,242.86 72.68,242.86 v2(72.93,242.6)
  BOTTOM w0.254: v2(72.93,242.6) 73.62,243.29 85.58,243.29 88.3,240.57 88.3,238.92 v2(89.57,237.65) ; v2(30.13,225.84) 26.96,222.66 26.96,219.3 v2(28.07,218.19)
MIC1_L: length 78.3
  TOP w0.254: v2(68.23,241.59) 67.98,241.84 32.8,241.84 v2(31.78,240.82) ; v2(26.45,235.49) 26.32,235.62 R492.2 ; R477.2 v2(19.59,235.11) 19.59,236.72 20.21,237.34 Q3.C1 ; FB15.1 86.68,240.25 R530.1 86.52,240.95 85.88,241.59 v2(84.87,241.59)
  BOTTOM w0.254: v2(19.59,235.11) 19.59,235.36 20.35,236.13 v1(22.64,236.13) 23.15,236.13 23.78,235.49 v2(26.45,235.49) v2(31.78,240.82) ; v2(68.23,241.59) 68.23,241.33 68.74,240.82 74.16,240.82 74.92,241.59 v2(84.87,241.59)
MIC1_L1: length 14.7
  TOP w0.254: C516.2 25.31,231.13 25.9,230.54 26.63,230.54 27.27,229.89 27.27,224.42 25.51,222.66 v2(24.92,222.66) 24.8,222.66 24.52,222.39 CODEC.21
MIC1_L2: length 5.2
  TOP w0.254: v1(26.18,231.34) 26.52,231.68 26.52,233 C516.1 25.31,234.51 24.7,235.11 R492.1
MIC1_L_P: length 4.3
  TOP w0.254: Q3.B1 20.86,236.38 21.12,236.63 21.32,236.63 22.11,237.42 22.11,238.67 v2(22,238.77) 21.5,239.28 R496.2
MIC1_LL: length 28.5
  TOP w0.254: AUDIO.11 90.96,236.31 90.96,231.27 92.13,230.11 92.13,228.52 89.15,225.55 D24.2 87.98,234.54 87.54,234.98 87.54,237.27 87.76,237.49 C537.1 88.17,238.48 FB15.2
MIC1_R: length 68.1
  TOP w0.254: v2(68.87,239.17) 68.99,239.05 R531.1 69.66,240.09 FB16.1 ; v2(11.34,231.81) 10.86,231.33 R475.2 ; v2(21.75,235.21) 21.51,235.45 Q3.C2 22.27,236.01 R490.2
  BOTTOM w0.254: v2(68.87,239.17) 66.5,239.17 64.34,241.33 33.31,241.33 26.78,234.8 23.2,234.8 22.79,235.21 v2(21.75,235.21) 20.96,234.42 v1(16.47,234.42) 16.24,234.42 15.02,233.2 12.65,233.2 11.34,231.89 v2(11.34,231.81)
MIC1_R1: length 14.3
  TOP w0.254: CODEC.22 23.75,222.89 24.92,224.06 v2(25.94,224.06) 26.77,224.89 26.77,229.68 26.42,230.03 25.69,230.03 25.64,230.08 25.64,230.08 C515.2
MIC1_R2: length 5.5
  TOP w0.254: R490.1 23.62,235.33 23.27,234.98 C515.1 22.19,233.14 22.19,231.78 22.8,231.17 v1(23.02,231.17)
MIC1_R_P: length 1.7
  TOP w0.254: Q3.B2 20.86,238.95 R501.2
MIC1_RR: length 56.1
  TOP w0.254: AUDIO.14 101.45,235.31 99.85,233.71 92.11,233.71 91.47,233.08 91.47,231.48 92.63,230.32 92.63,228.31 88.76,224.44 87.19,224.44 D24.1 86.08,228.57 87.03,229.52 87.03,236.57 82.65,240.95 72.84,240.95 C538.1 70.74,240.28 70.77,240.32 FB16.2
MIC1_VREFO-L: length 8.1
  TOP w0.254: R477.1 19.59,231.93 19.34,231.68 v2(19.34,229.27) 19.34,227.4 19.59,227.14 19.59,226.47 19.7,226.37 CODEC.28
MIC1_VREFO-R: length 9.6
  TOP w0.254: R475.1 13.11,229.74 13.11,228.73 13.84,228 16.46,228 v2(16.65,227.8) 17.7,226.76 CODEC.32
MIC2-VREFO: length 6.9
  TOP w0.254: D18.3 14.89,228.51 16.92,228.51 17.56,227.87 v1(17.81,227.87) 18.19,227.49 18.19,226.85 18.7,226.35 CODEC.30
MIC2-VREFO_L: length 1.9
  TOP w0.254: R473.1 v2(13.11,232.44) 13.11,231.55 D18.2
MIC2-VREFO_R: length 3
  TOP w0.254: R472.1 15.27,232.73 D18.1 15.27,231.17 v2(14.38,230.28)
MIC2_JD: length 50.8
  TOP w0.254: F_AUDIO.6 7.4,198.53 6.13,197.26 6.13,196.25 5.24,195.36 2.83,195.36 1.3,196.88 1.3,224.31 3.84,226.85 7.58,226.85 10.47,229.74 R482.1
MIC2_L: length 85.2
  TOP w0.254: Q5.C1 7.41,229.75 6.96,229.3 C534.2 R524.1 2.48,229.3 v2(2.45,229.27) 1.18,230.54 1.18,240.7 3.33,242.86 24.07,242.86 24.83,242.09 R495.2 ; v2(4.73,210.22) 4.99,210.22 5.68,209.52 D28.2 5.68,207.48 4.86,206.66 ; v2(12.86,234.98) 13.11,234.73 R473.2
  BOTTOM w0.254: v2(4.73,210.22) 4.73,210.43 1.65,213.51 1.65,228.47 v2(2.45,229.27) 1.68,230.03 1.68,231.43 3.72,233.46 11.34,233.46 v2(12.86,234.98)
MIC2_L1: length 23.2
  TOP w0.254: C519.1 26.66,237.14 27.64,236.16 27.64,230.96 28.32,230.28 28.32,223.01 v2(25.56,220.25) 25.31,220 23.65,220 23.55,219.89 CODEC.16
MIC2_L2: length 2.6
  TOP w0.254: C519.2 25.78,239.52 R495.1 v1(26.7,240.32)
MIC2_L_P: length 2.6
  TOP w0.254: v1(5.62,234.02) 6.27,233.36 R511.2 6.76,233.11 Q5.B1
MIC2_R: length 82.3
  TOP w0.254: R472.2 v2(15.4,234.72) ; 4.86,204.12 3.46,205.52 3.46,208.97 D28.1 3.78,212.44 v2(3.46,212.76) ; R494.2 22.67,241.17 21.5,242.35 3.55,242.35 1.68,240.49 1.68,231.43 v2(2.45,230.66) 2.95,231.17 2.95,231.55 3.49,232.09 R523.1 C533.2 6.07,232.09 Q5.C2
  BOTTOM w0.254: v2(3.46,212.76) 2.16,214.06 2.16,227.97 3.21,229.01 3.21,229.9 v2(2.45,230.66) 2.45,231.17 4.22,232.95 11.55,232.95 12.56,233.97 14.65,233.97 v2(15.4,234.72)
MIC2_R1: length 23.6
  TOP w0.254: C518.1 24.04,236.25 26.83,236.25 27.13,235.95 27.13,230.75 27.81,230.07 27.81,224.03 25.31,221.52 24.37,221.52 24.04,221.19 v2(24.04,221.14) 24.04,220.76 23.67,220.39 CODEC.17
MIC2_R2: length 3
  TOP w0.254: v2(24.16,238.03) 24.04,238.03 C518.2 23.62,239.4 R494.1
MIC2_R_P: length 5.3
  TOP w0.254: v1(8.59,233.84) 8.39,233.64 7.93,233.64 R513.2 8.01,233.01 8.01,231.27 7.4,230.66 7.02,230.66 6.76,230.41 Q5.B2
MONO_L: length 62.7
  TOP w0.254: Q6.C1 12.59,237.34 11.97,236.72 R514.1 11.46,234.19 11.34,234.06 11.34,232.79 11.11,232.57 10.87,232.57 10.19,231.89 10.19,231.07 9.33,230.21 v2(9.07,230.21) ; C513.1 10.45,222.92 8.41,220.89 v2(8.41,220.12)
  BOTTOM w0.254: v2(9.07,230.21) 9.07,229.72 8.24,228.89 6.09,228.89 4.19,226.99 4.19,223.2 7.27,220.12 v2(8.41,220.12) 8.83,219.71 8.83,211.61 6.54,209.33 4.6,209.33 2.95,207.68 2.95,193.33 4.86,191.42
MONO_L_C: length 4.1
  TOP w0.254: C513.2 12.06,222.89 CODEC.39 15.5,222.89 v2(15.91,223.3)
MONO_L_P: length 4.2
  TOP w0.254: R515.2 14.51,239.01 v2(14.51,238.72) 14.51,237.44 13.7,236.63 13.57,236.63 13.24,236.31 Q6.B1
MONO_R: length 79.6
  TOP w0.254: Q6.C2 v2(13.89,234.98) 13.89,234.55 R519.1 ; C517.1 10.64,219.55 7.78,216.69 2.7,216.69 1.81,215.81 1.81,211.67 v2(1.99,211.49)
  BOTTOM w0.254: v2(13.89,234.98) 13.16,235.72 12.58,235.72 10.83,233.97 6.08,233.97 5.14,234.91 2.21,234.91 0.64,233.33 0.64,212.84 v2(1.99,211.49) 1.43,210.93 1.43,192.31 4.86,188.88
MONO_R_C: length 3.8
  TOP w0.254: CODEC.41 13.36,221.89 13.11,221.65 13.11,221.46 C517.2 v2(12.03,219.49)
MONO_R_P: length 2.5
  TOP w0.254: v1(12.15,239.83) 12.52,239.46 R520.2 13.24,239.21 Q6.B2
MS_CLK: length 233.5
  TOP w0.102: v2(219.64,30.13) 219.64,29.29 217.3,26.96 217.3,22.58 212.78,18.06 212.78,17.03 212.98,16.83 U21.83 ; v2(242.35,207.3) 242.98,207.93 242.98,218.37 240.85,220.5 RN27.2 240.38,219.43 239.99,219.03 237.07,219.03 236.56,218.52 233.34,218.52 FB10.1 ; v2(241.97,71.79) 240.82,70.64 240.82,62.39 237.27,58.83 v2(236.89,58.83)
  BOTTOM w0.102: v2(241.97,71.79) 242.98,72.8 242.98,206.66 v2(242.35,207.3) ; v2(219.64,30.13) 219.97,30.46 223.2,30.46 225.9,33.17 229.12,33.17 230.26,34.31 230.26,39.35 231.34,40.43 231.34,48.92 232.65,50.22 232.65,53.8 v1(233.56,54.72) 235.36,56.52 235.36,57.31 v2(236.89,58.83)
MS_DATA: length 235.5
  TOP w0.102: FB9.1 234.51,218.75 236.46,218.75 236.97,219.26 239.58,219.26 239.8,219.48 RN27.4 239.8,220.88 240.03,221.11 241.11,221.11 243.24,218.98 243.24,207.42 v2(242.35,206.53) ; v2(242.22,83.85) 243.44,82.63 243.44,72.52 241.21,70.29 241.21,61.5 237.65,57.94 v2(236.89,57.94) ; U21.82 212.48,18.08 217.08,22.67 217.08,27.08 218.85,28.86 v2(218.85,30.13)
  BOTTOM w0.102: v2(242.35,206.53) 242.73,206.15 242.73,84.36 v2(242.22,83.85) ; v2(218.85,30.13) 219.36,29.62 220.07,29.62 220.63,30.18 223.24,30.18 226,32.94 229.21,32.94 230.49,34.22 230.49,39.25 231.57,40.33 231.57,46.3 v1(232.09,46.81) 232.87,47.6 232.87,52.92 235.74,55.79 235.74,56.8 v2(236.89,57.94)
MSCLK: length 6.7
  TOP w0.102: FB10.2 C412.2 232.44,223.2 232.44,225.23 PSKM.11
MSDATA: length 8.5
  TOP w0.102: PSKM.7 232.82,229.45 232.82,223.2 C413.2 FB9.2
NAFD_L: length 14.3
  TOP w0.102: LPT.14 152.15,8.2 152.15,10.18 CN4.2 152.99,11.92 152.56,12.35 152.56,13.43 RN35.7 153.38,14.64 154.12,15.37 157.28,15.37 157.89,14.77 RN30.6
NPINIT_L: length 14.8
  TOP w0.102: RN34.8 165.58,14.7 164.83,15.45 161.37,15.45 160.62,14.7 RN33.7 159.93,13.56 159.93,12.22 160.23,11.92 CN2.2 159.29,10.08 159.29,8.18 LPT.16
NPRD0: length 18.5
  TOP w0.102: LPT.2 154.46,5.89 154.46,7.14 153.58,8.03 153.07,8.03 152.38,8.72 152.38,10.01 152.56,10.19 153.58,10.19 153.8,10.42 CN4.4 153.8,11.49 152.79,12.5 152.79,13.29 153.12,13.62 153.7,13.62 153.96,13.88 RN35.5 153.96,14.64 154.46,15.15 157.13,15.15 157.39,14.89 RN30.4
NPRD1: length 18.4
  TOP w0.102: RN30.2 156.81,14.73 156.62,14.92 154.62,14.92 154.46,14.76 RN35.3 154.46,13.88 154.72,13.62 155.35,13.62 155.61,13.37 155.61,12.48 154.62,11.49 CN4.6 154.62,10.42 154.85,10.19 155.73,10.19 155.91,10.01 155.91,8.59 154.87,7.55 154.87,6.1 155.48,5.49 157.4,5.49 LPT.3
NPRD2: length 17.7
  TOP w0.102: RN34.6 165,14.77 164.55,15.22 161.65,15.22 161.2,14.77 RN33.5 161.2,13.85 160.97,13.62 160.36,13.62 160.23,13.49 160.23,12.3 161.04,11.49 CN2.4 161.04,10.42 160.81,10.19 159.8,10.19 159.54,9.94 159.54,5.89 LPT.4
NPRD3: length 13.9
  TOP w0.102: RN34.2 163.93,14.57 163.74,14.76 162.47,14.76 162.28,14.57 RN33.1 162.9,13.64 162.9,12.15 162.67,11.92 CN2.8 164.75,8.94 164.75,6.02 LPT.5
NPRD4: length 18.2
  TOP w0.102: LPT.6 167.29,6.02 167.29,9.57 CN3.2 168.74,11.95 168.38,12.3 168.38,13.51 RN32.7 169.13,14.7 169.88,15.45 173.9,15.45 174.34,15.01 RN31.8
NPRD5: length 18.1
  TOP w0.102: RN31.6 173.76,14.84 173.39,15.22 170.16,15.22 169.71,14.77 RN32.5 169.71,13.88 169.45,13.62 168.87,13.62 168.64,13.39 168.64,12.37 169.55,11.46 CN3.4 169.55,10.42 169.32,10.19 168.31,10.19 167.55,9.43 167.55,5.51 LPT.7
NPRD6: length 16.6
  TOP w0.102: LPT.8 171.86,5.51 171.86,9.94 171.61,10.19 170.59,10.19 170.36,10.42 CN3.6 170.36,11.49 171.28,12.4 171.28,13.39 171.07,13.59 170.52,13.59 170.21,13.9 170.21,14.25 RN32.3 170.21,14.76 170.44,14.99 173.01,14.99 173.26,14.74 RN31.4
NPRD7: length 13.7
  TOP w0.102: RN31.2 172.69,14.57 172.5,14.76 171.01,14.76 170.78,14.54 RN32.1 171.51,13.54 171.51,12.17 171.18,11.84 CN3.8 172.24,9.95 172.24,5.89 LPT.9
NSLIN_L: length 18.6
  TOP w0.102: RN34.4 164.5,14.61 164.12,14.99 161.93,14.99 161.7,14.76 RN33.3 161.7,13.88 161.96,13.62 162.54,13.62 162.67,13.49 162.67,12.26 161.86,11.44 CN2.6 161.86,10.42 162.08,10.19 162.97,10.19 164.52,8.64 164.52,6.66 163.99,6.13 161.85,6.13 LPT.17
NSTB_L: length 39
  TOP w0.102: RN29.7 177.61,14.8 175.92,14.8 175.04,15.68 161.09,15.68 159.67,14.26 RN30.8 158.47,14.57 157.44,15.6 153.83,15.6 151.8,13.57 C419.2 152.31,12.19 152.31,10.66 151.92,10.27 151.92,5.89 LPT.1
P2BOOT: length 3.4
  TOP w0.508: R567.1 v1(175.04,19.72) U31.1
P2BTX: length 15.1
  TOP w0.508: 173.26,17.81 172.88,17.81 172.5,18.19 C552.1 171.42,17.62 170.77,16.97 v1(167.75,16.97) 160,16.97 D21.3
P2COM: length 3.5
  TOP w0.508: U31.7 166.45,20.99 C553.1 166.4,20.83 R570.1
P2COMR: length 2.2
  TOP w0.102: v1(164.24,18.23) 165.13,18.23 C557.1
  TOP w0.508: R570.2 C557.1
P2FB: length 8.1
  TOP w0.508: R577.1 161.96,19.84 162.24,19.56 C559.1 163.68,19.56 164.27,20.14 v1(164.27,20.3) 164.27,20.84 164.95,21.52 165.72,21.52 166.12,21.92 R578.1 166.19,22.26 U31.6
P2FB_C: length 2.2
  TOP w0.102: R579.1 161.91,18.68 v1(161.91,17.76)
  TOP w0.508: R579.1 162.02,18.61 C559.2
P2FB_R: length 8.6
  TOP w0.508: R576.1 156.15,22.26 159.7,22.26 160.31,21.65 160.31,20.33 v2(160.08,20.1) 160.2,19.97 160.85,19.97 R577.2 R579.2
P2LG: length 26.6
  TOP w0.508: R572.2 165.74,35.08 v2(165.26,34.6) ; U31.4 174.66,23.53 174.69,23.5 R574.1 175.34,23.5 178.19,26.35 v2(178.19,26.88)
  BOTTOM w0.508: v2(178.19,26.88) 178.19,26.85 178.47,27.13 178.47,30.51 176.18,32.8 169.43,32.8 167.62,34.6 v1(166.55,34.6) v2(165.26,34.6)
P2LGR: length 12.2
  TOP w0.508: R572.1 168.31,33.19 QML1.G v2(167.16,33.12) ; v2(159.1,33.12) QML2.G
  BOTTOM w0.508: v2(167.16,33.12) v1(160.43,33.12) v2(159.1,33.12)
P2PHASE: length 11.3
  TOP w0.508: U31.8 168.18,18.83 168.82,18.19 C552.2 170.02,18.89 170.85,19.72 v2(170.85,26.19)
  vias: v2(154.72,28.48) v2(154.85,29.62) v2(155.61,30.39) v2(156.5,31.15) v2(157.64,31.15) v2(157.77,26.7) v2(158.66,31.15) v2(159.16,26.7) v2(160.18,26.19) v2(161.45,26.19) v2(162.72,26.19) v2(163.99,26.19) v2(165.64,28.1) v2(166.66,28.1) v2(168.05,26.19) v2(169.45,26.19) v2(172.12,26.19) v2(173.26,29.37) v2(173.64,26.19) v2(174.91,26.19) v2(176.18,26.7)
P2SNX: length 1.6
  TOP w1.016: C558.1 166.12,32.09 166.12,31.02
P2UG: length 9.1
  TOP w0.508: U31.2 176.18,20.99 v1(177.58,22.38) 180.37,25.18 180.37,25.69
P2UGR: length 4.1
  TOP w0.508: QMH1.G 178.21,28.36 R571.2 179.64,28.2 R569.1
P_PWOK_R: length 7.8
  TOP w0.102: v4(145.62,125.69) 145.57,125.74 145.57,127.44 CPU1.Y7
  BOTTOM w0.102: v4(145.62,125.69) 145.83,125.48 147.79,125.48 SR19.1 149.1,124.18 SR18.1 149.1,123.2 v1(149.23,123.07)
PACK64_1_L: length 14.9
  TOP w0.102: v2(41.18,132.87) 41.18,133.51 41.69,134.02 43.47,134.02 44.48,133 45.47,133 46.36,132.11 R292.2
  BOTTOM w0.102: v2(41.18,132.87) 40.93,132.62 39.28,132.62 38.26,131.6 38.26,129.95 37.3,128.99 PCI.B60
PAR: length 34.4
  TOP w0.127: v2(43.59,163.23) 46.01,163.23 47.91,165.13 52.81,165.13 53.16,164.77 53.16,163.98 52.36,163.18 52.36,161.58 52.86,161.07 52.86,159.04 53.64,158.26 U11.61
  BOTTOM w0.127: v2(43.59,163.23) 43.34,162.97 43.34,151.42 44.23,150.53 44.23,150.07 PCI.A43
PC_BEEP: length 5.4
  TOP w0.102: TP23.1 22.77,213.01 22.77,215.04 22.26,215.55 21.88,215.55 21.27,216.15 CODEC.12
PCH_1P5_N1: length 3
  TOP w0.102: v1(98.24,124.11) R609.1 98.24,121.29 QN57.B
PCH_1P05_N1: length 9
  TOP w0.102: R598.1 105.73,105.54 v1(105.44,105.82)
  TOP w0.508: R598.1 R595.1 R600.2 C576.1 105.19,101.25 104.68,101.76 104.68,104.05 QN54.B
PCH_1P5_N2: length 2.3
  TOP w0.508: R612.1 v1(103.21,121.19) QN59.B
PCH_1P05_N2: length 6.1
  TOP w0.102: R593.1 106.24,100.62 107.32,100.62 v2(107.63,100.31)
  TOP w0.508: QN54.C 103.16,101.63 QN53.B 104.68,100.11 R593.1
PCH_1P5_N3: length 12.2
  TOP w0.102: v1(107.17,117.61) 107.17,118.9 106.44,119.63 R606.1
  TOP w0.508: QN57.C 98.58,120.17 101.98,120.17 102.52,119.63 R613.2 R607.2 R606.1
PCH_1P5_N4: length 3.2
  TOP w0.508: R604.2 v1(102.39,113.57) 102.39,114.21 101.89,114.71 QN56.D
PCH_1P05_N4: length 7.1
  TOP w0.508: U32.1 96.55,97.19 96.2,96.84 C574.2 R960.1
  TOP w0.762: C829.1 92.9,95.19 93.25,95.54 R960.1
  vias: v2(90.08,91.98)
PCH_1P5_N5: length 4.1
  TOP w0.102: R610.1 98.76,112.91 98.99,112.68 v1(98.99,111.74)
  TOP w0.508: QN58.D 98.03,114 R610.1
PCH_1P05_N5: length 1.2
  TOP w0.508: C830.2 98.3,95.54 R960.2
PCH_1P5_N8: length 24
  TOP w0.102: 100.51,107.98 v1(100.51,109.02)
  TOP w0.508: R961.1 R778.2 ; R961.1 100.51,107.98 ; R961.1 101.63,107.95 C832.2 ; R778.2 C580.1 98.93,109.16 QN55.G ; R778.2 98.93,107.95 98.46,107.47 98.46,105.47 97.82,104.84 U32.7 97.82,101.63 95.79,99.6 95.79,97.57 94.71,96.49 R603.1
PCH_1P5_N9: length 3.3
  TOP w0.508: R607.1 104.55,118.65 v2(103.21,117.3) 102.9,117 QN56.G
PCH_1P5_N10: length 5.8
  TOP w0.508: QN58.G 99.35,118.02 102.74,118.02 R613.1
PCH_1P5_N11: length 9.4
  TOP w0.102: v1(96.3,122.46) QN57.E
  TOP w0.508: QN57.E 96.3,118.27 96.55,118.02 98.08,118.02 98.97,118.9 QN59.C
PCH_1P5_N12: length 1.2
  TOP w0.508: R961.2 101.51,107 C833.2
PCH_AE30: length 1.6
  TOP w0.305: v3(43.39,91.96) 43.64,91.96 43.85,92.17 PCH1.AE30
  BOTTOM w0.254: v3(43.39,91.96) 43.72,91.62 STP16.1
PCH_AF2: length 8.2
  TOP w0.203: R257.1 39.82,112.45 40.39,112.45 42.39,110.46 42.39,109.67 43.35,108.7 43.35,107.44 PCH1.AF2
PCH_AF2_R: length 3.8
  TOP w0.508: PFB1.1 v2(40.42,115.63) 39.84,115.63 39.58,115.89 39.15,115.89 C252.1 R257.2
PCH_AF5: length 9.3
  TOP w0.102: R147.2 42.69,110.69 42.69,109.72 43.64,108.78 43.64,107.6 43.98,107.25 43.98,106.99 43.68,106.68 43.59,106.68 43.32,106.41 43.32,106.1 43.63,105.79 PCH1.AF5
PCH_AH28: length 1.4
  TOP w0.305: PCH1.AH28 v3(42.5,93.64)
  BOTTOM w0.305: v3(42.5,93.64) 42.5,93.27 SC34.1
PCH_AJ22: length 1.4
  TOP w0.305: v3(42.08,95.82) 41.85,96.05 PCH1.AJ22
  BOTTOM w0.305: STP15.1 42.54,95.36 v3(42.08,95.82)
PCH_AU40: length 9.8
  TOP w0.381: R259.2 32.16,81.21 v2(32.93,81.97) 32.93,83.57 34.25,84.89 34.88,84.89 35.16,85.17 36.76,85.17 37.45,85.87 PCH1.AU41 37.45,86.47 PCH1.AU40
PCH_AU40_R: length 2
  TOP w0.508: C283.1 v2(32.16,78.39) R259.1
PCH_AW35: length 12.8
  TOP w0.203: PCH1.AW35 35.22,89.15 32.8,86.74 32.8,85.29 31.24,83.73 31.24,82.77 30.97,82.51 27.76,82.51 C287.1
PCH_B19: length 7.7
  TOP w0.203: R129.2 61.78,97.7 v2(61.12,97.04) 60.16,97.99 58.17,97.99 57.82,97.65 56.39,97.65 PCH1.B19
PCH_C13: length 8.1
  TOP w0.127: PCH1.C13 56.28,101.53 58.22,101.53 58.84,102.14 59.44,102.14 59.93,102.32
  TOP w0.203: 59.93,102.32 60.65,103.04 61.04,103.15 R130.2
PCH_DSWODVREN: length 11.3
  TOP w0.102: PCH1.AM41 40.08,85.6 35.92,81.44 35.92,79.86 35.8,79.74 35.8,78.34 v2(36.41,77.73) 35.89,77.22 R233.2
PCH_F22: length 19.2
  TOP w0.102: v3(53.92,96.81) 53.92,96.73 54.28,96.37 PCH1.F22 ; R132.2 70.42,97.54 69.37,98.58 v2(69.37,98.84)
  BOTTOM w0.102: v2(69.37,98.84) 68.86,98.32 64.2,98.32 64.17,98.35 58.85,98.35 57.56,97.06 v1(55.66,97.06) 55.3,97.42 54.53,97.42 v3(53.92,96.81)
