# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DATA_A56: length 93.5
  TOP w0.102: 135.77,122.13 136.27,122.13 137.12,121.29 140.29,121.29 140.4,121.19 140.85,121.19 141,121.34 141,121.63 141.27,121.9 141.74,121.9 142.1,121.55 CPU1.AG3 ; DIMM2.108 109.81,67.61 109.68,68.28 109.68,69.47 109.39,69.77 109.25,70.09 109.25,71.32 109.59,71.66 109.68,71.66 109.93,71.92 109.93,73.34 110.14,73.55 110.14,73.68 110.04,73.77 109.56,73.77 109.49,73.84 109.49,74.02 109.57,74.1 109.86,74.1 109.93,74.17 DIMM4.108
  TOP w0.165: 135.77,122.13 132.32,122.13 119.9,109.71 119.9,101.68 111.59,93.38 111.59,86.47 arc(111.27,86.15) 110.95,86.47 110.95,91.92 arc(110.64,92.24) 110.32,91.92 110.32,76.19 109.22,75.09 109.22,74.23 109.07,74.08 109.07,73.77 109.65,73.19 109.65,72.59 109.44,72.37 109.44,72.05 109.25,71.86 109.25,71.6 109.39,71.47
M_DATA_A57: length 95.1
  TOP w0.102: DIMM2.109 108.72,66.84 108.52,67.68 108.37,68.26 108.23,69.02 108.23,69.19 108.25,69.59 108.25,69.63 108.47,69.84 108.86,69.84 108.97,69.95 108.97,71.71 108.83,71.84 108.68,71.84 108.58,71.94 108.58,72.05 108.68,72.16 109,72.16 109.08,72.24 109.08,72.74 DIMM4.109 ; CPU1.AG1 140.57,121.52 139.39,121.52 139.26,121.65 137.31,121.65 136.19,122.77 136,122.77
  TOP w0.165: 136,122.77 131.79,122.77 119.26,110.24 119.26,102.56 arc(118.94,102.25) 118.63,102.56 118.63,108.48 arc(118.31,108.8) 117.99,108.48 117.99,100.72 109.67,92.4 109.67,76.44 108.65,75.42 108.65,74.3 108.22,73.86 108.22,71.72 108.65,71.29 108.65,70.69 108.07,70.1 108.07,69.82 108.25,69.63
M_DATA_A58: length 94.9
  TOP w0.102: CPU1.AE3 142.42,123.37 141.64,123.73 139.96,123.73 138.71,124.03 137.84,124.91 ; DIMM4.114 103.93,74.14 103.84,74.05 103.66,74.05 103.59,73.97 103.59,73.87 103.69,73.77 103.86,73.77 103.93,73.69 103.93,72.24 104.17,72 104.17,71.81 104.03,71.67 103.53,71.67 103.25,71.4 103.25,70.73 103.35,70.01 103.62,69.25 103.62,68.16 DIMM2.114
  TOP w0.165: 137.84,124.91 136.08,126.66 130.65,126.66 112.43,108.44 112.43,103.24 arc(112.11,102.92) 111.79,103.24 111.79,105.42 arc(111.48,105.74) 111.16,105.42 111.16,98.91 106.13,93.89 106.13,80.27 103.44,77.59 103.44,75.65 103.22,75.42 103.22,73.62 103.65,73.19 103.65,72.33 103.16,71.84 103.16,71.69 103.35,71.5
M_DATA_A59: length 95.3
  TOP w0.102: DIMM2.115 102.94,65.13 102.94,67.12 102.19,68.73 102.19,69.37 102.62,69.81 102.75,69.81 102.97,70.02 102.97,71.45 102.57,71.84 102.57,72.04 102.7,72.17 103.01,72.17 103.12,72.29 103.12,72.7 DIMM4.115 ; 138.21,125.43 138.64,125 139.35,124.43 140.29,123.93 142.02,123.93 142.34,123.86 CPU1.AE4
  TOP w0.165: 102.27,69.45 102.06,69.65 102.06,69.91 102.65,70.5 102.65,71.29 102.12,71.82 102.12,73.57 102.65,74.1 102.65,77.71 105.49,80.55 105.49,94.16 110.52,99.19 110.52,100.76 arc(110.43,100.98) 110.21,101.07 109.65,101.07 arc(109.33,101.39) 109.65,101.71 110.21,101.71 arc(110.43,101.8) 110.52,102.03 110.52,105.88 111.79,107.15 111.79,108.7 130.39,127.3 136.35,127.3 138.21,125.43
M_DATA_A60: length 94.6
  TOP w0.102: DIMM4.227 110.89,69.04 110.89,66.53 111.05,66.09 111.61,65.41 111.61,65.31 111.7,65.23 111.62,65.16 111.62,64.46 110.93,63.77 DIMM2.227 ; 135.8,121.5 136.22,121.5 136.79,120.93 139.34,120.93 139.48,121.06 140.1,121.06 140.18,120.99 141.1,120.99 141.51,121.39 CPU1.AG2
  TOP w0.165: 111.7,65.23 111.85,65.23 111.97,65.35 111.97,65.96 111.2,66.73 111.2,67.61 111.65,68.06 111.65,69.39 111.02,70.03 111.02,70.03 110.7,70.34 110.7,71.25 110.47,71.48 110.47,72.24 110.22,72.5 110.22,73.19 110.65,73.62 110.65,75.6 110.95,75.9 110.95,85.11 arc(111.27,85.43) 111.59,85.11 111.59,84.65 arc(111.91,84.33) 112.22,84.65 112.22,93.1 120.53,101.4 120.53,105.69 122.36,107.52 arc(122.36,107.97) 121.91,107.97 121.1,107.15 arc(120.65,107.15) 120.65,107.6 122.36,109.31 arc(122.36,109.76) 121.91,109.76 121.09,108.94 arc(120.64,108.94) 120.64,109.39 132.75,121.5 135.8,121.5
M_DATA_A61: length 95.6
  TOP w0.102: DIMM2.228 109.25,63.22 109.15,63.32 109.15,63.61 110.2,64.66 110.2,65.53 110.62,65.95 110.62,66.43 110.5,66.55 110.49,66.55 110.62,66.86 110.62,67.72 110.6,68.05 110.54,68.14 110.19,68.49 110.19,69.58 110.06,70.36 DIMM4.228 ; CPU1.AG4 142.84,122.04 141.89,122.04 141.82,122.1 141.18,122.1 140.98,121.9 140.4,121.9 140.27,121.77 139.53,121.77 139.3,122 137.52,122 136.12,123.4 136,123.4
  TOP w0.165: 136,123.4 131.53,123.4 117.36,109.23 117.36,100.98 109.03,92.66 109.03,76.9 107.22,75.09 107.22,74.49 107.65,73.03 107.65,72.39 107.22,71.61 107.22,70.69 107.36,69.92 107.46,69.62 107.7,69.37 107.7,68.87 107.17,67.55 107.17,66.79 108.2,64.83 108.48,64.55 108.61,64.48 108.84,64.38 109.21,64.38 109.65,64.82 109.65,65.96 109.97,66.28 110.22,66.28 110.49,66.55
M_DATA_A62: length 95.2
  TOP w0.102: CPU1.AE2 141.37,123.37 140.75,123.02 140.4,123.02 140.24,123.17 137.95,123.17 136.11,125.02 135.84,125.02 ; DIMM2.233 104.86,61.4 104.86,63.35 105.8,64.29 105.8,65.26 105.62,65.44 105.62,65.58 104.9,66.3 104.9,67.47 105.02,67.59 105.02,69 DIMM4.233
  TOP w0.165: 105.8,65.26 106.08,65.26 106.15,65.34 106.15,65.78 105.22,66.71 105.22,67.33 105.65,67.77 105.65,69.74 105.22,70.18 105.22,71.66 105.68,72.12 105.68,73.31 105.22,73.77 105.22,75.42 104.71,75.92 104.71,77.03 107.4,79.71 107.4,93.29 113.72,99.61 113.72,106.13 115.36,107.78 arc(115.36,108.23) 114.91,108.23 114.47,107.79 arc(114.02,107.79) 114.02,108.23 130.43,124.64 130.8,125.02 135.84,125.02
M_DATA_A63: length 95.1
  TOP w0.102: CPU1.AE1 140.53,123.44 139.66,123.44 138.3,123.55 136.9,124.95 ; DIMM2.234 103.93,63.89 104.1,64.45 104.18,65.09 104.58,66.72 104.63,67 104.63,67.18 104.49,67.48 104.49,67.48 104.38,67.59 103.9,68.49 103.9,69.87 103.97,69.94 104.12,69.94 104.2,70.01 104.2,70.21 104.13,70.28 103.82,70.28 103.74,70.36 103.74,70.46 DIMM4.234
  TOP w0.165: 104.49,67.48 104.68,67.68 104.68,68.33 104.22,68.79 104.22,69.39 104.65,69.82 104.65,72.16 104.22,72.59 104.22,73.38 104.65,73.82 104.65,75.09 104.08,75.66 104.08,77.31 106.76,79.99 106.76,93.61 111.79,98.64 111.79,101.92 arc(112.11,102.24) 112.43,101.92 112.43,100.01 arc(112.75,99.7) 113.06,100.01 113.06,108.17 130.6,125.71 136.14,125.71 136.9,124.95
M_DATA_B0: length 125.8
  TOP w0.102: DIMM3.3 218.93,50.51 218.24,49.82 218.24,48.33 v4(218.64,47.94) 218.64,42.9 DIMM1.3 ; CPU1.AE34 v4(173.43,122.92)
  GND w0.102: v4(173.43,122.92) 173.47,122.92 173.93,123.38 174.63,123.38 174.91,123.65 178.41,123.65 178.51,123.76 179.46,123.76 181.11,125.15 181.32,125.15
  GND w0.14: 181.32,125.15 192.16,125.15 210.98,106.33 210.98,98.01 213.24,95.75 213.24,91.68 214.51,90.41 214.51,84.7 arc(214.83,84.38) 215.15,84.7 215.15,84.96 arc(215.46,85.27) 215.78,84.96 215.78,83.12 223.55,75.36 223.55,56.54 220.64,53.64 220.64,53.64 220.22,53.22 220.22,52.32 219.22,51.32 219.22,50.48 218.09,49.36 218.09,48.48 v4(218.64,47.94)
M_DATA_B1: length 127
  TOP w0.102: CPU1.AE35 v4(174.34,122.92) ; DIMM3.4 217.93,52.12 217.67,51.86 217.14,51.86 216.9,51.63 216.9,50.94 v4(217.72,50.12) 217.63,50.04 217.63,44.8 DIMM1.4
  GND w0.102: v4(174.34,122.92) 174.56,122.92 174.99,123.35 176.35,123.35 176.54,123.16 178.43,123.16 178.72,123.45 179.71,123.45 181.02,124.51 181.25,124.51
  GND w0.14: v4(217.72,50.12) 218.06,50.12 218.66,50.73 218.66,51.63 219.65,52.62 219.65,53.52 221.65,55.52 221.65,55.54 222.91,56.81 222.91,75.09 213.88,84.13 213.88,89.69 arc(213.56,90.01) 213.24,89.69 213.24,88.23 arc(212.92,87.92) 212.61,88.23 212.61,89.54 arc(212.52,89.74) 212.33,89.82 arc(212.13,89.91) 212.05,90.1 212.05,90.18 arc(212.13,90.38) 212.33,90.46 arc(212.52,90.54) 212.61,90.74 212.61,90.81 arc(212.52,91.01) 212.33,91.09 arc(212.13,91.18) 212.05,91.37 212.05,91.45 arc(212.13,91.65) 212.33,91.73 arc(212.52,91.81) 212.61,92.01 212.61,92.08 arc(212.52,92.28) 212.33,92.36 arc(212.13,92.45) 212.05,92.64 212.05,92.72 arc(212.13,92.92) 212.33,93 arc(212.52,93.08) 212.61,93.28 212.61,93.35 arc(212.52,93.55) 212.33,93.63 arc(212.13,93.72) 212.05,93.91 212.05,93.99 arc(212.13,94.19) 212.33,94.27 arc(212.52,94.35) 212.61,94.55 212.61,95.48 210.34,97.74 210.34,106.07 191.9,124.51 181.25,124.51
M_DATA_B2: length 127.4
  TOP w0.102: CPU1.AG35 v4(173.43,120.17) ; DIMM3.9 212.93,51.03 212.24,50.34 212.24,48.81 212.64,48.41 v4(212.64,47.81) 212.69,47.76 212.69,44.18 212.41,43.9 212.41,43.13 DIMM1.9
  GND w0.102: v4(173.43,120.17) 174.13,120.66 174.9,120.91 175.73,120.91 175.99,120.66 177.26,120.66 177.55,120.94 177.55,121.16 177.76,121.37 180.49,121.37 180.92,121.69
  GND w0.14: 180.92,121.69 190.73,121.69 204.99,107.44 204.99,104.82 arc(205.3,104.5) 205.62,104.82 205.62,105.71 arc(205.94,106.03) 206.26,105.71 206.26,98.04 arc(206.57,97.72) 206.89,98.04 206.89,99.21 arc(207.21,99.52) 207.53,99.21 207.53,96.57 209.23,94.87 209.23,84.45 217.22,76.46 217.22,74.49 218.22,73.49 218.22,72.59 219.22,71.59 219.22,70.4 218.21,69.39 218.21,68.73 219.21,67.73 219.21,66.47 218.22,65.47 218.22,64.75 219.21,63.75 219.21,62.64 218.21,61.64 218.21,59.87 217.3,58.96 217.3,57.95 215.53,56.18 215.53,55.43 215.22,55.12 215.22,54.22 214.22,53.22 214.22,52.32 213.22,51.32 213.22,50.5 212.17,49.45 212.17,48.28 v4(212.64,47.81)
M_DATA_B3: length 126.4
  TOP w0.102: CPU1.AH35 v4(174.34,120.17) ; DIMM1.10 211.76,44.67 211.76,48.23 211.68,48.32 211.68,49.88 v4(211.56,50) 210.95,50.62 210.95,51.63 211.23,51.91 211.65,51.91 211.93,52.19 DIMM3.10
  GND w0.102: 181.08,121.06 180.98,120.96 179.48,120.96 179.38,121.06 178.4,121.06 177.61,120.27 175.77,120.27 175.43,120.61 175.05,120.61 v4(174.34,120.17)
  GND w0.14: 181.08,121.06 190.47,121.06 204.35,107.18 204.35,99.21 arc(204.67,98.89) 204.99,99.21 204.99,103.46 arc(205.3,103.78) 205.62,103.46 205.62,97.58 208.59,94.61 208.59,84.17 216.19,76.57 216.19,75.72 216.66,75.25 216.66,74.2 217.65,73.2 217.65,72.3 218.65,71.3 218.65,70.69 217.65,69.69 217.65,68.5 218.65,67.5 218.65,66.7 217.66,65.71 217.66,64.51 218.65,63.52 218.65,62.87 217.65,61.87 217.65,60.27 216.67,59.29 216.67,58.22 214.64,56.2 214.64,55.13 214.65,55.12 214.65,54.44 213.65,53.44 213.65,52.62 212.66,51.63 212.66,50.73 211.85,49.92 211.64,49.92 v4(211.56,50)
M_DATA_B4: length 128.6
  TOP w0.102: DIMM3.122 219.72,50.81 219.72,46.34 v4(220.26,45.8) 220.63,45.43 220.63,43.85 220.2,43.43 220.2,40.96 DIMM1.122 ; CPU1.AD34 v4(173.43,123.83)
  GND w0.102: v4(173.43,123.83) 174.1,124.26 178.19,124.26 178.49,124.57 178.49,124.85 178.83,125.19 179.84,125.19 181.31,126.42 181.48,126.42 181.49,126.42
  GND w0.14: 181.49,126.42 181.49,126.42 192.69,126.42 212.25,106.86 212.25,98.53 214.51,96.27 214.51,92.2 216.14,90.58 216.14,88.68 215.78,88.32 215.78,86.96 217.05,85.69 217.05,83.65 224.82,75.88 224.82,54.02 220.22,49.42 220.22,47.67 220.7,47.18 220.7,46.24 v4(220.26,45.8)
M_DATA_B5: length 127.7
  TOP w0.102: DIMM3.123 219.2,48.86 v4(219.2,43.77) 219.65,43.32 219.65,42.1 218.93,41.38 DIMM1.123 ; CPU1.AD35 v4(174.34,123.83)
  GND w0.102: v4(174.34,123.83) 174.91,123.92 178.22,123.92 178.37,124.06 179.19,124.06 181.22,125.78 181.44,125.78
  GND w0.14: v4(219.2,43.77) 219.18,43.77 219.03,43.93 219.03,46.52 219.66,47.15 219.66,49.65 220.65,50.64 220.65,50.9 224.18,54.43 224.18,75.62 216.42,83.39 216.42,85.43 215.15,86.7 215.15,90.67 213.88,91.94 213.88,96.01 211.61,98.27 211.61,106.6 192.43,125.78 181.44,125.78
M_DATA_B6: length 128.1
  TOP w0.102: DIMM3.128 213.93,46.12 v4(214.33,45.73) 214.33,45.27 214.62,44.98 214.62,44.03 214.23,43.64 214.23,40.98 213.94,40.7 213.93,40.7 213.93,40.7 DIMM1.128 ; CPU1.AG34 v4(172.51,121.09)
  GND w0.102: v4(172.51,121.09) 174.52,121.57 175.83,121.86 176.6,121.86 177.63,122.03 179.77,122.03 180.94,122.96 181.14,122.96
  GND w0.14: v4(214.33,45.73) 214.22,45.84 214.22,49.42 215.22,50.42 215.22,51.32 216.22,52.32 216.22,53.22 217.22,54.22 217.22,55.24 218.6,56.62 218.6,58.45 220.22,60.07 220.22,61.62 221.24,62.64 221.24,63.8 220.22,64.83 220.22,65.45 221.22,66.45 221.22,67.79 220.22,68.79 220.22,69.42 221.24,70.44 221.24,71.57 220.22,72.59 220.22,73.45 219.21,74.46 219.21,76.28 210.5,85 210.5,95.4 208.8,97.1 208.8,104.61 arc(208.48,104.93) 208.16,104.61 208.16,103.79 arc(207.84,103.47) 207.53,103.79 207.53,106.7 191.26,122.96 181.14,122.96
M_DATA_B7: length 127
  TOP w0.102: DIMM1.129 212.93,41.38 213.67,42.12 213.67,43.3 v4(213.2,43.77) 213.21,43.79 213.21,48.84 DIMM3.129 ; CPU1.AH34 v4(172.51,120.17)
  GND w0.102: v4(172.51,120.17) 173.54,120.84 174.18,121.09 174.18,121.09 175.98,121.52 176.9,121.52 177.75,121.72 180.16,121.72 180.92,122.33
  GND w0.14: v4(213.2,43.77) 213.19,43.77 213.01,43.95 213.01,47.17 213.66,47.82 213.66,49.73 214.65,50.72 214.65,51.62 215.65,52.62 215.65,53.5 216.65,54.5 216.65,55.12 216.31,55.46 216.31,56.06 217.96,57.72 217.96,58.72 219.65,60.4 219.65,61.85 220.68,62.88 220.68,63.57 219.65,64.6 219.65,65.68 220.66,66.69 220.66,67.49 219.65,68.5 219.65,69.67 220.66,70.68 220.66,71.32 219.65,72.33 219.65,73.19 218.65,74.19 218.65,75.21 218.14,75.72 218.14,76.44 209.86,84.72 209.86,95.13 208.16,96.83 208.16,99.65 206.89,100.92 206.89,101.43 207.35,101.89 207.35,102.39 206.89,102.85 206.89,106.43 190.99,122.33 180.92,122.33
M_DATA_B8: length 120.6
  TOP w0.102: DIMM1.12 209.65,44.78 209.65,49.36 v4(209.29,50.11) 209.17,50.23 209.17,51.77 209.39,51.98 209.75,51.98 209.93,52.16 209.93,53.41 209.77,53.57 209.59,53.57 209.44,53.71 209.44,54.33 DIMM3.12 ; CPU1.AL34 172.97,117 v4(173.43,117.46)
  GND w0.102: v4(173.43,117.46) 173.47,117.46 173.92,117.91 174.52,117.91 175.08,118.47 176.37,118.47 176.74,118.84 178.54,118.84 178.94,119.23 179.37,119.23 179.44,119.16 180.33,119.16 180.34,119.15
  GND w0.14: 180.34,119.15 189.68,119.15 201.18,107.66 201.18,99.69 arc(201.49,99.37) 201.81,99.69 201.81,102.46 arc(202.13,102.78) 202.45,102.46 202.45,98.06 206.69,93.82 206.69,83.38 211.11,78.96 211.11,77.53 213.21,75.42 213.21,74.43 214.22,73.42 214.22,72.59 215.22,71.59 215.22,70.4 214.22,69.4 214.22,68.79 215.21,67.79 215.21,66.42 214.22,65.42 214.22,64.83 215.21,63.83 215.21,62.64 214.21,61.64 214.21,60.26 213.29,59.34 212.53,59.34 211.49,58.3 211.49,55.56 211.22,55.29 211.22,54.25 210.22,53.25 210.22,52.33 209.22,51.33 209.22,50.19 v4(209.29,50.11)
M_DATA_B9: length 121
  TOP w0.102: v4(174.35,117.46) 173.88,116.99 CPU1.AL35 ; DIMM1.13 208.93,43.29 209.02,43.37 209.02,47.64 v4(208.73,47.93) 208.24,48.42 208.24,49.71 208.65,50.12 208.65,52.64 DIMM3.13
  GND w0.102: 180.59,118.52 180.59,118.52 179.44,118.52 179.29,118.37 178.94,118.37 178.83,118.48 176.78,118.48 176.51,118.21 175.63,118.21 175.3,117.89 175.08,117.89 174.64,117.46 v4(174.35,117.46)
  GND w0.14: 180.59,118.52 180.59,118.52 189.42,118.52 199.27,108.67 199.27,103.78 arc(199.59,103.46) 199.91,103.78 199.91,106.82 arc(200.22,107.14) 200.54,106.82 200.54,99.07 206.05,93.55 206.05,83.11 210.47,78.69 210.47,77.27 212.66,75.08 212.66,74.19 213.65,73.2 213.65,72.29 214.65,71.29 214.65,70.69 213.65,69.69 213.65,68.55 214.65,67.55 214.65,66.7 213.65,65.7 213.65,64.57 214.65,63.57 214.65,62.91 213.65,61.91 213.65,60.82 213.38,60.55 212.65,60.55 210.65,58.55 210.65,54.47 209.66,53.48 209.66,52.56 208.65,51.56 208.65,50.31 207.98,49.64 207.98,48.68 v4(208.73,47.93)
M_DATA_B10: length 121.5
  TOP w0.102: DIMM3.18 203.61,54.82 203.38,54.59 203.38,53.79 204.07,53.1 204.07,52.3 203.21,51.43 203.21,50.22 v4(203.26,50.14) 203.68,49.28 203.68,45.33 DIMM1.18 ; CPU1.AK31 v4(169.77,118.35)
  GND w0.102: v4(169.77,118.35) 170.23,117.89 170.23,117.17 170.44,116.96 170.85,116.96 171.11,116.7 171.11,116.54 171.27,116.38 172.64,116.38 172.8,116.21 175,116.21 175.2,116.01 179.76,116.01 180.07,115.7 180.47,115.7
  GND w0.14: v4(203.26,50.14) 203.22,50.18 203.22,51.32 204.22,52.32 204.22,53.24 205.22,54.24 205.22,55.28 205.52,55.58 205.52,57.43 207.93,59.85 207.97,59.89 208.21,60.13 208.21,61.62 209.21,62.62 209.21,63.8 208.21,64.8 208.21,65.47 209.21,66.47 209.21,67.79 208.22,68.79 208.22,69.39 209.22,70.39 209.22,71.59 208.22,72.59 208.22,73.49 207.22,74.49 207.22,77.84 203.23,81.82 203.23,92.35 194.62,100.97 194.62,105.48 arc(194.3,105.8) 193.99,105.48 193.99,102.53 arc(193.67,102.22) 193.35,102.53 193.35,110.22 arc(193.03,110.54) 192.72,110.22 192.72,109.18 arc(192.4,108.86) 192.08,109.18 192.08,111.74 188.12,115.7 180.47,115.7 180.47,115.7
M_DATA_B11: length 121.9
  TOP w0.102: DIMM3.19 202.52,52.51 202.52,51.4 202.65,51.27 202.65,50.12 202.24,49.71 202.24,48.42 v4(202.73,47.93) 202.73,46.64 203.16,46.22 203.16,43.51 202.93,43.29 DIMM1.19 ; v4(169.76,117.44) CPU1.AL31
  GND w0.102: v4(169.76,117.44) 169.75,117.44 169.78,117.41 170.15,116.44 170.55,116.03 172.69,116.03 172.72,116.01 174.62,116.01 174.82,115.81 174.82,115.4 175.08,115.15 176.37,115.15 176.81,115.58 179.44,115.58 179.94,115.07 180.26,115.07 180.26,115.07
  GND w0.14: v4(202.73,47.93) 202.71,47.93 202.21,48.43 202.21,49.89 202.65,50.33 202.65,51.54 203.66,52.55 203.66,53.53 204.65,54.52 204.65,57.48 207.32,60.15 207.32,60.54 207.65,60.87 207.65,61.93 208.65,62.93 208.65,63.57 207.65,64.57 207.65,65.7 208.65,66.7 208.65,67.42 207.65,68.42 207.65,69.69 208.65,70.69 208.65,71.35 207.65,72.35 207.65,73.21 206.65,74.21 206.65,75.09 206.28,75.46 206.28,77.88 202.6,81.56 202.6,92.09 192.72,101.97 192.72,107.86 arc(192.4,108.17) 192.08,107.86 192.08,103.7 arc(191.76,103.39) 191.45,103.7 191.45,111.47 187.86,115.07 180.26,115.07 180.26,115.07
M_DATA_B12: length 123.1
  TOP w0.102: DIMM3.131 210.93,48.07 211.22,47.79 v4(211.22,43.77) 211.67,43.32 211.67,41.89 210.93,41.15 DIMM1.131 ; CPU1.AK34 v4(172.51,118.35)
  GND w0.102: 181.12,120.42 179.61,120.42 179.39,120.2 178.54,120.2 178.04,119.7 174.17,119.7 173.9,119.43 173.9,119.12 173.55,118.78 173.29,118.78 v4(172.51,118.35)
  GND w0.14: v4(211.22,43.77) 211.22,47.21 210.21,48.22 210.21,49.45 211.22,50.46 211.22,51.32 212.22,52.32 212.22,53.22 213.22,54.22 213.22,55.12 213.93,55.83 213.93,56.42 216.03,58.53 216.03,59.67 216.21,59.85 216.21,61.64 217.22,62.65 217.22,63.75 216.21,64.75 216.21,65.47 217.21,66.47 217.21,67.79 216.22,68.79 216.22,69.39 217.22,70.39 217.22,71.52 216.21,72.53 216.21,73.45 215.22,74.45 215.22,76.64 207.96,83.9 207.96,94.34 203.72,98.58 203.72,106.91 190.21,120.42 181.12,120.42
M_DATA_B13: length 122.5
  TOP w0.102: v4(174.34,118.37) 173.88,117.91 CPU1.AK35 ; DIMM3.132 210.24,50.71 210.24,47.94 210.66,47.52 v4(210.66,45.86) 210.66,43.73 210.31,43.39 210.31,43.39 209.93,43.01 DIMM1.132
  GND w0.102: 180.03,119.79 178.81,119.79 178.25,119.23 176.75,119.23 176.34,118.82 174.79,118.82 v4(174.34,118.37)
  GND w0.14: 180.03,119.79 180.04,119.79 189.94,119.79 201.81,107.92 201.81,103.75 arc(202.13,103.44) 202.45,103.75 202.45,105.02 arc(202.76,105.34) 203.08,105.02 203.08,98.45 arc(203.1,98.33) 203.17,98.23 207.32,94.08 207.32,83.64 214.43,76.53 214.43,75.34 214.65,75.13 214.65,74.22 215.65,73.22 215.65,72.3 216.65,71.3 216.65,70.69 215.65,69.69 215.65,68.5 216.65,67.5 216.65,66.7 215.65,65.7 215.65,64.52 216.65,63.52 216.65,62.91 215.65,61.91 215.65,60.41 214.94,59.7 214.94,58.45 213.34,56.85 212.61,56.85 212.22,56.47 212.22,55.89 212.65,55.46 212.65,54.52 211.66,53.53 211.66,52.63 210.66,51.63 210.66,50.69 209.65,49.68 209.65,49.2 209.65,47.98 210.66,46.98 v4(210.66,45.86)
M_DATA_B14: length 124.5
  TOP w0.102: v4(170.66,118.34) 171.12,117.89 CPU1.AK32 ; DIMM3.137 205.22,48.84 v4(205.22,43.77) 205.67,43.32 205.67,41.89 204.93,41.15 DIMM1.137
  GND w0.102: 180.47,116.97 180.28,116.97 179.85,117.41 178.94,117.41 178.56,117.03 177.16,117.03 176.45,116.62 173.03,116.62 172.69,116.96 171.42,116.96 171.14,117.24 171.14,117.86 v4(170.66,118.34)
  GND w0.14: 180.47,116.97 188.65,116.97 195.89,109.72 195.89,104.29 arc(196.21,103.97) 196.53,104.29 196.53,106.31 arc(196.84,106.63) 197.16,106.31 197.16,100.22 204.5,92.88 204.5,82.46 208.82,78.14 208.82,76.13 209.22,75.73 209.22,74.49 210.22,73.49 210.22,72.59 211.21,71.6 211.21,70.46 210.22,69.46 210.22,68.79 211.21,67.79 211.21,66.46 210.21,65.46 210.21,64.81 211.21,63.81 211.21,62.69 210.22,61.7 210.22,60.31 207.42,57.51 207.42,55.51 207.22,55.3 207.22,54.23 206.22,53.23 206.22,52.32 205.22,51.32 205.22,51.32 205.22,50.48 204.21,49.47 204.21,48.35 205.42,47.14 205.42,45.47 205.01,45.07 205.01,43.98 v4(205.22,43.77)
M_DATA_B15: length 123.3
  TOP w0.102: CPU1.AL32 171.12,116.97 v4(170.69,117.41) ; DIMM3.138 204.2,50.75 204.2,48.72 204.66,48.26 v4(204.66,45.86) 204.66,43.73 204.31,43.38 204.31,43.38 203.93,43.01 DIMM1.138
  GND w0.102: v4(170.69,117.41) 170.69,117.4 170.7,117.39 170.71,117.39 171.44,116.66 172.68,116.66 172.93,116.42 175.37,116.42 175.47,116.31 176.49,116.31 176.96,116.54 179.83,116.54 180.04,116.34 180.45,116.34
  GND w0.14: v4(204.66,45.86) 203.65,46.87 203.65,49.7 204.66,50.71 204.66,51.63 205.65,52.62 205.65,53.5 205.64,53.51 206.65,54.52 206.65,55.29 206.48,55.46 206.48,57.49 209.66,60.66 209.66,61.93 210.65,62.93 210.65,63.57 209.65,64.57 209.65,65.69 210.65,66.69 210.65,67.42 209.65,68.42 209.65,69.69 210.65,70.69 210.65,71.35 209.65,72.35 209.65,73.2 208.65,74.2 208.65,75.13 208.15,75.64 208.15,77.81 203.87,82.09 203.87,92.62 196.53,99.96 196.53,102.1 arc(196.21,102.42) 195.89,102.1 195.89,101.52 arc(195.57,101.2) 195.26,101.52 195.26,109.09 arc(194.94,109.4) 194.62,109.09 194.62,106.8 arc(194.3,106.48) 193.99,106.8 193.99,110.73 188.38,116.34 180.45,116.34 180.45,116.34
M_DATA_B16: length 108.5
  TOP w0.102: v4(174.34,114.66) 173.91,114.23 CPU1.AP35 ; DIMM3.21 200.93,50.7 200.21,49.98 200.21,48.36 v4(200.64,47.94) 200.64,42.87 200.9,42.6 DIMM1.21
  GND w0.102: v4(174.34,114.66) 174.8,114.66 174.92,114.54 178.14,114.54 178.45,114.22 179.4,114.22 179.41,114.21 180.05,113.8
  GND w0.14: v4(200.64,47.94) 201.09,47.48 201.09,46.69 200.69,46.29 200.39,46.29 199.07,47.61 199.07,47.91 199.96,48.8 199.96,49.43 200.65,50.13 200.65,51.58 201.66,52.59 201.66,53.45 202.65,54.44 202.65,55.17 202.27,55.56 202.27,56.92 205.39,60.04 205.39,60.51 205.65,60.77 205.65,61.93 206.65,62.93 206.65,63.6 205.66,64.59 205.66,65.68 206.65,66.68 206.65,67.56 205.66,68.56 205.66,69.7 206.65,70.69 206.65,71.35 205.65,72.35 205.65,73.2 204.65,74.2 204.65,75.32 204.22,75.75 204.22,76.92 204.43,77.12 204.43,77.93 201.33,81.03 201.33,91.55 190.18,102.7 190.18,110.95 187.33,113.8 180.05,113.8
M_DATA_B17: length 110.8
  TOP w0.102: DIMM3.22 199.47,54.35 199.47,53.66 199.92,53.2 199.92,52.49 198.94,51.51 198.94,50.62 v4(199.48,50.08) 199.65,49.91 199.65,44.78 DIMM1.22 ; CPU1.AN34 172.99,115.15 v4(173.43,115.58)
  GND w0.102: 179.75,113.16 179.17,113.75 178.23,113.75 177.69,114.28 174.79,114.28 174.71,114.21 174.13,114.21 173.88,114.46 173.88,115.12 v4(173.43,115.58)
  GND w0.14: v4(199.48,50.08) 199.22,50.34 199.22,51.32 200.21,52.31 200.21,53.27 201.22,54.28 201.22,55.24 201.45,55.48 201.45,57 204.38,59.93 204.38,60.36 204.21,60.52 204.21,61.67 205.21,62.67 205.21,63.78 204.21,64.78 204.21,65.47 205.21,66.47 205.21,67.79 204.22,68.79 204.22,69.45 205.22,70.45 205.22,71.59 204.22,72.59 204.22,73.42 203.21,74.43 203.21,78.17 199.42,81.96 199.42,85.93 arc(199.74,86.25) 200.06,85.93 200.06,82.89 arc(200.38,82.58) 200.69,82.89 200.69,91.28 189.49,102.49 189.49,110.74 187.07,113.16 179.75,113.16
M_DATA_B18: length 109.1
  TOP w0.102: CPU1.AN32 v4(171.6,114.69) ; DIMM1.27 194.64,42.89 194.64,46.89 194.36,47.17 v4(194.36,48.13) 194.36,48.58 194.21,48.73 194.21,49.84 194.93,50.55 194.93,51.26 195.61,51.95 195.61,52.36 195.05,52.92 DIMM3.27
  GND w0.102: 180.13,109.85 179.49,110.49 179.09,110.49 178.03,111.56 177.71,111.56 177.59,111.44 176.92,111.44 175.7,112.66 172.98,112.66 172.05,113.58 172.05,114.23 v4(171.6,114.69)
  GND w0.14: v4(194.36,48.13) 194.36,48.22 194.22,48.36 194.22,49.44 195.22,50.44 195.22,51.35 196.22,52.35 196.22,53.24 197.22,54.24 197.22,56.24 200.36,59.38 200.36,60.55 200.21,60.7 200.21,61.68 201.22,62.68 201.22,63.82 200.21,64.83 200.21,65.44 201.21,66.44 201.21,67.79 200.22,68.79 200.22,69.46 201.21,70.46 201.21,71.6 200.22,72.59 200.22,73.49 199.22,74.49 199.22,75.29 199.61,75.68 199.61,78.59 191.39,86.8 arc(190.94,86.8) 190.94,86.35 191.84,85.46 arc(191.84,85.01) 191.39,85.01 190.16,86.24 190.16,89.64 arc(190.47,89.96) 190.79,89.64 190.79,88.23 arc(191.11,87.92) 191.43,88.23 191.43,90.33 190.16,91.6 190.16,97.74 180.81,107.09 180.81,109.17 180.13,109.85
M_DATA_B19: length 112.8
  TOP w0.102: CPU1.AN31 v4(170.68,114.69) ; DIMM3.28 193.45,54.34 193.45,53.64 193.93,53.17 193.93,52.06 193.73,51.86 193.19,51.86 192.98,51.65 192.98,50.53 v4(193.32,50.2) 193.65,49.23 193.65,47.12 193.93,46.84 DIMM1.28
  GND w0.102: 179.37,109 177.74,110.62 176.86,110.62 175.98,111.5 175.03,111.5 174.35,112.17 172.58,112.17 172.13,112.62 172.13,112.91 171.75,113.29 171.42,113.29 171.14,113.57 171.14,114.23 v4(170.68,114.69)
  GND w0.14: v4(193.32,50.2) 193.22,50.3 193.22,51.4 194.22,52.4 194.22,53.22 195.22,54.22 195.22,56.14 198.41,59.33 198.41,60.84 198.22,61.03 198.22,61.65 199.21,62.65 199.21,63.83 198.21,64.83 198.21,65.42 199.21,66.42 199.21,67.79 198.22,68.79 198.22,69.46 199.21,70.46 199.21,71.6 198.22,72.59 198.22,73.49 197.22,74.49 197.22,75.27 197.5,75.56 197.5,78.22 195.53,80.2 arc(195.08,80.2) 195.08,79.75 196.49,78.34 arc(196.49,77.89) 196.04,77.89 188.89,85.04 188.89,96.87 arc(188.57,97.19) 188.25,96.87 188.25,92.25 arc(187.93,91.93) 187.62,92.25 187.62,98.34 179.51,106.45 179.51,108.86 179.37,109
M_DATA_B20: length 106.7
  TOP w0.102: CPU1.AN35 173.91,115.15 v4(174.34,115.58) ; DIMM1.140 202.21,40.98 202.21,43.43 202.64,43.86 202.64,45.42 v4(202.26,45.8) 201.72,46.34 201.72,50.81 DIMM3.140
  GND w0.102: v4(174.34,115.58) 175.13,114.79 178.48,114.79 178.56,114.71 179.31,114.71 179.83,114.43 180.22,114.43
  GND w0.14: v4(202.26,45.8) 201.65,46.41 201.65,49.83 201.21,50.27 201.21,51.35 202.22,52.36 202.22,53.22 203.22,54.22 203.22,56.97 206.21,59.97 206.21,61.64 207.21,62.63 207.21,63.83 206.22,64.83 206.22,65.45 207.22,66.45 207.22,67.79 206.22,68.79 206.22,69.44 207.22,70.44 207.22,71.59 206.21,72.59 206.21,73.43 205.22,74.43 205.22,78.04 201.96,81.3 201.96,91.83 190.81,102.98 190.81,111.21 187.59,114.43 180.22,114.43
M_DATA_B21: length 109.5
  TOP w0.102: DIMM3.141 201.2,48.86 v4(201.2,43.77) 201.65,43.32 201.65,42.1 200.93,41.38 DIMM1.141 ; CPU1.AP34 172.99,114.23 v4(173.43,114.66)
  GND w0.102: v4(173.43,114.66) 173.43,114.38 173.89,113.92 173.89,113.62 174.16,113.34 176.45,113.34 176.79,113.01 177.42,113.01 177.76,113.34 178.21,113.34 179.03,112.53 179.45,112.53
  GND w0.14: 179.45,112.53 186.8,112.53 188.82,110.51 188.82,102.26 200.06,91.02 200.06,88.02 198.64,86.6 198.64,81.85 202.14,78.34 202.14,75.6 202.65,75.09 202.65,74.2 203.65,73.2 203.65,72.35 204.65,71.35 204.65,70.69 203.66,69.7 203.66,68.56 204.65,67.56 204.65,66.7 203.65,65.7 203.65,64.54 204.65,63.55 204.65,62.91 203.65,61.91 203.65,60.22 200.66,57.22 200.66,54.53 199.65,53.52 199.65,52.56 198.65,51.56 198.65,50.3 198.2,49.84 198.2,48.38 198.41,48.17 198.41,47.12 199.69,45.84 199.92,45.84 200.97,44.79 200.97,44 v4(201.2,43.77)
M_DATA_B22: length 110.8
  TOP w0.102: DIMM1.146 196.53,41.29 196.53,41.82 196.22,42.12 196.22,42.12 196.22,42.12 196.22,43.56 196.62,43.97 196.62,45 196.3,45.32 196.3,45.7 v4(196.33,45.73) 196.33,46.75 195.62,47.46 195.62,50.71 DIMM3.146 ; CPU1.AP32 v4(171.6,113.77)
  GND w0.102: v4(171.6,113.77) 171.6,113.76 172.44,112.9 172.44,112.79 172.78,112.45 175.45,112.45 176.87,111.03 177.97,111.03 179.99,109
  GND w0.14: v4(196.33,45.73) 195.91,45.73 193.66,47.98 193.66,49.69 194.66,50.69 194.66,51.58 195.66,52.58 195.66,53.53 196.66,54.53 196.66,55.17 196.3,55.53 196.3,56.22 199.65,59.57 199.65,61.91 200.66,62.91 200.66,63.59 199.65,64.6 199.65,65.7 200.65,66.7 200.65,67.56 199.66,68.56 199.66,69.7 200.65,70.69 200.65,71.35 199.65,72.35 199.65,73.2 198.65,74.2 198.65,77.97 192.35,84.28 arc(191.9,84.28) 191.9,83.83 194.62,81.1 arc(194.62,80.65) 194.17,80.65 189.52,85.31 189.52,97.34 180.16,106.7 180.16,108.84 179.99,109
M_DATA_B23: length 111.6
  TOP w0.102: DIMM1.147 194.93,41.38 195.66,42.11 195.66,43.31 v4(195.2,43.77) 195.2,47.14 194.93,47.41 DIMM3.147 ; CPU1.AP31 v4(170.68,113.77)
  GND w0.102: v4(170.68,113.77) 170.68,113.51 171.12,113.07 171.12,112.7 171.44,112.38 171.75,112.38 172.18,111.95 174.23,111.95 174.88,111.3 175.74,111.3 176.83,110.2 177.44,110.2 178.87,108.77 178.87,108.26
  GND w0.14: 178.87,108.26 178.87,106.19 186.98,98.08 186.98,86.46 arc(187.3,86.14) 187.62,86.46 187.62,90.94 arc(187.93,91.26) 188.25,90.94 188.25,84.72 196.25,76.73 196.25,76.16 196.65,75.75 196.65,74.2 197.65,73.2 197.65,72.35 198.65,71.35 198.65,70.69 197.66,69.7 197.66,68.56 198.65,67.56 198.65,66.7 197.65,65.7 197.65,64.6 198.65,63.6 198.65,62.87 197.66,61.88 197.66,59.48 194.42,56.24 194.42,55.51 194.66,55.27 194.66,54.53 193.66,53.53 193.66,52.63 192.66,51.63 192.66,50.07 192.22,49.63 192.22,48.63 195,45.85 195,43.98 v4(195.2,43.77)
M_DATA_B24: length 105.8
  TOP w0.102: DIMM1.30 191.72,44.72 191.72,50.1 v4(191.7,50.12) 191.7,50.13 191.18,50.65 191.18,51.46 191.98,52.26 191.98,53.25 191.4,53.83 191.4,54.29 DIMM3.30 ; CPU1.AL29 v4(167.94,117.43)
  GND w0.102: 175.92,110.24 175.54,110.63 174.57,110.63 173.73,111.46 171.44,111.46 170.25,112.65 170.25,115.4 169.55,116.32 169.28,116.7 168.98,117 168.68,117 v4(167.94,117.43)
  GND w0.14: 175.92,110.24 176.63,109.53 176.63,109 177.87,107.76 177.87,106.29 184.56,99.6 184.56,93.16 arc(184.88,92.84) 185.2,93.16 185.2,96.19 arc(185.52,96.51) 185.83,96.19 185.83,91.62 186.35,91.11 186.35,85.73 195.41,76.67 195.41,75.5 195.22,75.3 195.22,74.49 196.21,73.5 196.21,72.58 197.21,71.58 197.21,70.46 196.22,69.46 196.22,68.79 197.21,67.79 197.21,66.43 196.21,65.43 196.21,64.81 197.21,63.81 197.21,62.69 196.22,61.7 196.22,61.03 196.37,60.87 196.37,59.71 193.53,56.87 193.53,55.53 193.22,55.22 193.22,54.3 192.21,53.29 192.21,52.38 191.22,51.39 191.22,50.68 191.7,50.2 v4(191.7,50.12)
M_DATA_B25: length 104.8
  TOP w0.102: DIMM3.31 190.65,52.64 190.65,50.12 190.24,49.71 190.24,48.47 v4(190.78,47.93) 190.78,46.9 191.07,46.61 191.07,42.74 DIMM1.31 ; CPU1.AM29 v4(168.85,115.6)
  GND w0.102: v4(168.85,115.6) 169.1,115.6 169.57,115.04 169.74,114.48 169.74,112.52 170.81,111.45 170.81,111.29 171.15,110.95 172.3,110.95 173.21,110.04 174.02,110.04 174.16,109.91 174.46,109.91 174.74,109.62
  GND w0.14: v4(190.78,47.93) 190.21,48.5 190.21,49.73 189.22,50.72 189.22,51.38 190.21,52.37 190.21,53.29 191.21,54.29 191.21,55.32 191.55,55.66 191.55,56.8 194.52,59.77 194.52,60.46 194.22,60.76 194.22,61.63 195.21,62.62 195.21,63.78 194.21,64.78 194.21,65.43 195.21,66.43 195.21,67.64 194.22,68.64 194.22,69.39 195.22,70.39 195.22,71.58 194.21,72.58 194.21,73.43 193.22,74.42 193.22,75.09 193.38,75.25 193.38,75.95 191.51,77.81 190.67,77.81 187.85,80.63 arc(187.85,81.08) 188.3,81.08 190.43,78.95 arc(190.88,78.95) 190.88,79.4 185.08,85.2 185.08,90.58 183.29,92.36 183.29,99.07 176.6,105.77 176.6,107.24 175.36,108.48 175.36,109 174.74,109.62
M_DATA_B26: length 100.1
  TOP w0.102: DIMM3.36 185.37,54.25 185.37,53.68 185.95,53.09 185.95,52.18 185.21,51.43 185.21,50.66 v4(185.75,50.12) 185.72,50.09 185.72,44.71 DIMM1.36 ; v4(167.97,113.77) 168.4,114.21 CPU1.AP29
  GND w0.102: v4(167.97,113.77) 167.98,113.77 168.83,112.92 168.83,111.89 169.34,111.38 169.34,110.84 169.79,110.38 170.15,110.38 170.76,109.78 171.52,109.78 172.4,108.9 172.4,108.21 172.87,107.74
  GND w0.14: 172.87,107.74 174.42,106.19 174.42,104.57 181.06,97.92 181.06,86.1 184.84,82.31 arc(184.84,81.87) 184.39,81.87 181.61,84.64 arc(181.16,84.64) 181.16,84.2 189.47,75.9 189.47,75.45 189.21,75.19 189.21,74.48 190.22,73.47 190.22,72.59 191.22,71.59 191.22,70.43 190.22,69.43 190.22,68.79 191.21,67.79 191.21,66.42 190.21,65.42 190.21,64.8 191.21,63.8 191.21,62.62 190.22,61.62 190.22,60.42 190.46,60.18 190.46,59.28 187.22,56.05 187.22,54.22 186.22,53.22 186.22,52.33 185.22,51.33 185.22,50.65 v4(185.75,50.12)
M_DATA_B27: length 102.7
  TOP w0.102: v4(167.97,112.86) 168.4,113.29 CPU1.AR29 ; DIMM3.37 184.68,52.66 184.68,50.29 184.18,49.79 184.18,48.51 v4(184.78,47.92) 185.14,47.55 185.14,42.81 DIMM1.37
  GND w0.102: 173.14,105.52 173.14,105.64 171.3,107.47 171.3,108.06 168.71,110.66 168.71,111.27 168.37,111.6 168.37,112.11 167.97,112.52 v4(167.97,112.86)
  GND w0.14: v4(184.78,47.92) 184.21,48.49 184.21,49.73 183.22,50.72 183.22,51.4 184.21,52.39 184.21,53.24 185.22,54.24 185.22,58.19 185.71,58.68 187.64,58.68 187.97,59.01 187.97,61.65 188.98,62.67 188.98,63.66 188.22,64.43 188.22,65.79 189.01,66.58 189.01,67.65 188.22,68.44 188.22,69.78 188.92,70.48 188.92,71.42 187.93,72.41 187.93,73.43 187.22,74.14 187.22,76.35 184.44,79.13 arc(183.99,79.13) 183.99,78.68 185.51,77.16 arc(185.51,76.71) 185.06,76.71 181.1,80.67 arc(180.65,80.67) 180.65,80.22 181.56,79.31 arc(181.56,78.86) 181.11,78.86 179.79,80.18 179.79,97.37 173.14,104.02 173.14,105.52
M_DATA_B28: length 103.7
  TOP w0.102: DIMM3.149 192.93,47 193.41,46.52 193.41,45.74 193.22,45.54 v4(193.22,43.77) 193.86,43.13 193.86,42.08 192.93,41.15 DIMM1.149 ; CPU1.AM28 v4(167.94,116.52)
  GND w0.102: 173.98,109.46 173.7,109.73 173.01,109.73 172.04,110.7 170.98,110.7 170.61,111.07 170.61,111.37 170.12,111.86 170.02,111.86 169.54,112.34 169.54,114.19 169.29,114.45 169.29,114.87 169.01,115.14 168.65,115.14 168.4,115.4 168.4,115.82 167.94,116.28 v4(167.94,116.52)
  GND w0.14: 173.98,109.46 174.32,109.12 174.32,108.62 175.97,106.97 175.97,105.5 182.66,98.81 182.66,92.04 184.44,90.25 184.44,84.94 186.92,82.46 186.92,80.66 190.68,76.9 191.52,76.9 192.65,75.77 192.65,74.2 193.65,73.2 193.65,72.35 194.65,71.35 194.65,70.69 193.66,69.7 193.66,68.33 194.65,67.34 194.65,66.72 193.65,65.72 193.65,64.55 194.65,63.55 194.65,62.87 193.65,61.87 193.65,59.86 190.46,56.66 190.46,55.61 190.65,55.41 190.65,54.52 189.65,53.52 189.65,52.61 188.65,51.61 188.65,50.42 189.65,49.42 189.65,48.06 192.94,44.78 192.94,44.05 v4(193.22,43.77)
M_DATA_B29: length 106.2
  TOP w0.102: CPU1.AL28 v4(167.03,117.43) ; DIMM1.150 191.93,43.01 192.3,43.38 192.31,43.38 192.66,43.73 v4(192.66,45.86) 192.24,46.28 192.24,50.71 DIMM3.150
  GND w0.102: v4(167.03,117.43) 167.48,116.98 168.2,116.98 168.4,116.78 168.4,116.36 168.68,116.09 169.16,116.09 169.9,115.27 170,114.57 170,112.6 171.39,111.21 172.62,111.21 173.51,110.32 174.94,110.32 175.34,109.93
  GND w0.14: v4(192.66,45.86) 193.21,45.31 193.75,45.31 194.01,45.57 194.01,46.05 192.88,47.17 192.27,47.17 191.88,47.56 191.88,48.13 191.65,48.36 191.65,49.42 190.66,50.41 190.66,51.62 191.65,52.61 191.65,53.52 192.65,54.52 192.65,55.44 192.34,55.76 192.34,56.57 195.65,59.89 195.65,61.93 196.65,62.93 196.65,63.52 195.65,64.52 195.65,65.72 196.65,66.72 196.65,67.56 195.66,68.56 195.66,69.7 196.65,70.69 196.65,71.35 195.65,72.35 195.65,73.2 194.65,74.2 194.65,75.8 194.22,76.23 194.22,76.9 193.46,77.65 192.67,77.65 191.93,78.39 191.93,79.25 185.71,85.47 185.71,90.84 183.93,92.62 183.93,99.34 177.24,106.03 177.24,107.5 176,108.74 176,109.26 175.34,109.93
M_DATA_B30: length 101.4
  TOP w0.102: DIMM1.155 186.93,41.15 187.69,41.91 187.69,43.31 v4(187.23,43.77) 187.23,46.76 186.93,47.05 DIMM3.155 ; v4(167.05,112.86) 167.48,113.29 CPU1.AR28
  GND w0.102: v4(167.05,112.86) 167.51,112.4 167.51,111.76 167.8,111.46 168.14,111.46 168.4,111.21 168.4,110.59 170.85,108.13 170.85,107.32 172.5,105.67 172.5,105.49
  GND w0.14: 172.5,105.49 172.5,103.75 172.8,103.46 179.15,97.1 179.15,79.66 182.27,76.54 arc(182.72,76.54) 182.72,76.99 181.89,77.82 arc(181.89,78.27) 182.34,78.27 184.96,75.65 186.17,75.65 186.65,75.16 186.65,74.24 186.11,73.7 186.11,72.37 187.05,71.43 187.05,70.72 187.65,70.12 187.65,68.51 187.22,68.08 187.22,66.01 187.65,65.58 187.65,64.16 186.87,63.38 186.87,62.57 185.81,61.5 185.81,60.15 184.16,58.5 184.16,55.66 184.66,55.16 184.66,54.48 183.65,53.47 183.65,53.47 183.65,53.01 183.65,52.62 182.66,51.63 182.66,50.49 183.65,49.5 183.65,47.1 185.05,45.7 185.05,44.13 185.55,43.62 187.08,43.62 v4(187.23,43.77)
M_DATA_B31: length 104
  TOP w0.102: DIMM3.156 186.27,50.68 186.27,49.82 186.24,49.79 186.24,46.28 v4(186.66,45.86) 186.69,45.83 186.69,43.77 185.93,43.01 DIMM1.156 ; v4(167.05,113.77) 167.48,114.21 CPU1.AP28
  GND w0.102: v4(167.05,113.77) 167.51,113.32 168.14,113.32 168.57,112.89 168.57,111.77 169.03,111.31 169.03,110.79 169.69,110.13 169.96,110.13 170.66,109.43 171.29,109.43 171.79,108.94 171.79,107.93 172.16,107.55
  GND w0.14: v4(186.66,45.86) 185.86,46.66 185.86,49.22 184.66,50.42 184.66,51.6 184.65,51.61 185.66,52.61 185.66,53.48 186.66,54.48 186.66,55.21 186.44,55.43 186.44,57 187.36,57.92 187.84,57.92 189.65,59.73 189.65,61.87 190.65,62.87 190.65,63.57 189.65,64.57 189.65,65.7 190.65,66.7 190.65,67.56 189.66,68.56 189.66,69.7 190.65,70.69 190.65,71.3 189.65,72.3 189.65,73.2 188.65,74.2 188.65,75.81 181.93,82.54 arc(181.48,82.54) 181.48,82.09 183.53,80.04 arc(183.53,79.59) 183.08,79.59 180.42,82.24 180.42,97.64 173.78,104.28 173.78,105.93 172.16,107.55
M_DATA_B32: length 100
  TOP w0.102: DIMM3.81 136.93,52.08 137.09,51.92 137.09,50.61 136.72,50.24 136.54,50.24 136.17,49.87 v4(136.17,47.92) 136.68,47.41 136.68,43.56 DIMM1.81 ; v4(152.39,113.77) 152.39,113.77 CPU1.AR12
  GND w0.102: v4(152.39,113.77) 152.39,113.77 152.19,113.27 151.96,113.04 151.68,111.75 150.53,110.6 150.53,109.67 146.52,105.67 146.34,105.67
  GND w0.14: v4(136.17,47.92) 136.17,49.7 135.21,50.66 135.21,51.39 136.21,52.39 136.21,53.53 135.22,54.52 135.22,55.91 135.33,56.03 135.33,56.88 132.42,59.8 132.42,60.31 132.21,60.51 132.21,61.65 133.21,62.64 133.21,63.76 132.22,64.75 132.22,65.69 131.22,66.69 131.22,67.79 130.22,68.79 130.22,69.41 131.22,70.41 131.22,71.32 132.21,72.32 132.21,73.2 133.22,74.21 133.22,75.18 133.89,75.85 133.89,76.56 134.69,77.36 134.69,78.88 143.26,87.46 143.26,97.09 arc(143.58,97.4) 143.9,97.09 143.9,93.5 arc(144.22,93.19) 144.53,93.5 144.53,104.43 145.77,105.67 146.34,105.67
M_DATA_B33: length 98.8
  TOP w0.102: v4(152.37,114.69) 152.37,114.68 152.39,114.69 152.85,114.23 CPU1.AP12 ; DIMM3.82 135.93,53.99 136.18,53.74 136.18,52.62 135.67,52.1 135.22,52.1 134.75,51.63 134.75,50.33 v4(135.02,50.06) 135.65,49.43 135.65,47.61 DIMM1.82
  GND w0.102: v4(152.37,114.69) 152.37,114.4 151.93,113.97 151.93,113.58 151.64,113.29 151.38,112.01 150.18,110.81 150.18,109.7 146.78,106.3 146.21,106.3
  GND w0.14: 146.21,106.3 145.51,106.3 143.9,104.69 143.9,98.78 arc(143.58,98.46) 143.26,98.78 143.26,101.66 arc(142.95,101.97) 142.63,101.66 142.63,87.72 133.81,78.9 133.81,77.38 132.65,76.22 132.65,74.49 131.65,73.49 131.65,72.55 130.66,71.56 130.66,70.7 129.65,69.69 129.65,68.47 130.65,67.47 130.65,66.44 131.66,65.43 131.66,64.52 132.65,63.53 132.65,62.88 131.65,61.87 131.65,58.85 133.78,56.73 134.46,56.73 134.68,56.51 134.68,56.27 134.34,55.94 134.34,55.57 134.65,55.26 134.65,54.27 135.65,53.27 135.65,52.62 134.65,51.62 134.65,50.43 v4(135.02,50.06)
M_DATA_B34: length 103.2
  TOP w0.102: DIMM3.87 130.93,50.28 130.21,49.56 130.21,48.84 130.64,48.41 v4(130.64,47.94) 130.64,47.94 130.64,42.9 DIMM1.87 ; CPU1.AL13 v4(153.31,117.43)
  GND w0.102: 147.25,110.52 147.25,110.57 149.58,112.9 149.58,114.4 149.92,115.89 150.2,116.85 150.92,117.57 151.83,117.57 151.93,117.47 151.93,117.23 152.19,116.97 152.85,116.97 v4(153.31,117.43)
  GND w0.14: v4(130.64,47.94) 130.06,48.52 130.06,49.24 130.22,49.4 130.22,50.01 129.92,50.3 129.64,50.3 129.22,50.72 129.22,51.32 130.21,52.31 130.21,53.45 129.68,53.99 129.22,54.45 129.22,56.39 126.22,59.39 126.22,61.67 127.22,62.67 127.22,63.81 126.22,64.81 126.22,65.65 125.22,66.65 125.22,67.65 124.22,68.65 124.22,69.39 125.22,70.39 125.22,71.32 126.21,72.32 126.21,73.25 127.22,74.26 127.22,75.38 127.94,76.11 127.94,77.08 137.98,87.12 137.98,91.98 138.54,92.54 138.54,94.43 arc(138.86,94.75) 139.17,94.43 139.17,94 arc(139.49,93.68) 139.81,94 139.81,104.59 143.78,108.55 143.78,109.2 144.14,109.56 146.28,109.56 147.25,110.52
M_DATA_B35: length 103.5
  TOP w0.102: DIMM3.88 129.93,52.51 129.21,51.79 129.21,50.18 v4(129.65,49.74) 129.64,49.73 129.64,48.38 129.96,48.06 129.96,47.93 129.7,47.66 129.7,47.33 129.93,47.09 DIMM1.88 ; CPU1.AL12 v4(152.39,117.43)
  GND w0.102: 146.55,110.99 146.63,111.07 147.24,111.07 149.17,113 149.17,114.92 149.72,116.42 149.9,117.12 150.69,117.91 151.91,117.91 v4(152.39,117.43)
  GND w0.14: 146.55,110.99 145.75,110.19 143.87,110.19 143.14,109.46 143.14,108.82 139.27,104.94 arc(139.2,104.84) 139.17,104.72 139.17,95.72 arc(138.86,95.4) 138.54,95.72 138.54,97.37 arc(138.22,97.69) 137.9,97.37 137.9,92.82 137.34,92.26 137.34,87.39 126.66,76.7 126.66,74.49 125.65,73.48 125.65,72.59 124.66,71.6 124.66,70.7 123.66,69.7 123.66,68.42 124.65,67.42 124.65,66.42 125.66,65.42 125.66,64.57 126.65,63.58 126.65,62.9 125.66,61.9 125.66,60.44 125.58,60.37 125.58,59.02 128.25,56.34 128.25,55.61 128.66,55.2 128.66,54.22 129.65,53.22 129.65,52.62 128.65,51.62 128.65,50.32 129.13,49.84 129.31,49.84 129.41,49.74 129.64,49.74 v4(129.65,49.74)
M_DATA_B36: length 101.2
  TOP w0.102: DIMM3.200 137.93,46.12 v4(138.33,45.73) 138.65,45.4 138.65,43.75 138.21,43.31 138.21,40.98 DIMM1.200 ; CPU1.AR13 v4(153.31,112.86)
  GND w0.102: 149.23,107.08 149.44,107.29 149.44,107.71 152.28,110.55 152.28,111.61 153.31,112.64 v4(153.31,112.86)
  GND w0.14: 149.23,107.08 148.88,106.73 148.88,106.73 147.07,104.92 147.07,100.4 arc(146.76,100.08) 146.44,100.4 146.44,102.9 arc(146.12,103.22) 145.8,102.9 145.8,88.2 137.4,79.79 137.4,77.68 arc(137.08,77.36) 136.76,77.68 136.76,78.38 arc(136.44,78.7) 136.13,78.38 136.13,76.17 135.22,75.26 135.22,74.21 134.21,73.2 134.21,72.36 133.22,71.36 133.22,70.46 132.21,69.46 132.21,68.7 133.21,67.71 133.21,66.65 134.22,65.65 134.22,64.78 135.21,63.79 135.21,62.62 134.22,61.62 134.22,60.79 134.65,60.36 134.65,59.47 136.71,57.41 136.71,55.97 137.22,55.47 137.22,54.52 138.22,53.52 138.22,52.36 137.21,51.36 137.21,50.66 138.22,49.66 138.22,47.18 137.95,46.92 137.95,46.1 v4(138.33,45.73)
M_DATA_B37: length 102.5
  TOP w0.102: v4(153.31,113.78) 153.76,114.23 CPU1.AP13 ; DIMM1.201 136.93,41.38 137.65,42.1 137.65,43.32 v4(137.2,43.77) 137.2,48.86 DIMM3.201
  GND w0.102: v4(153.31,113.78) 152.85,113.32 152.85,112.66 152.01,111.82 152.01,111.58 150.85,110.42 150.85,109.6 146.28,105.03
  GND w0.14: v4(137.2,43.77) 137.19,43.77 137.01,43.95 137.01,47.25 137.66,47.89 137.66,49.43 136.65,50.43 136.65,51.59 137.66,52.59 137.66,53.28 136.66,54.28 136.66,55.13 136.05,55.73 136.05,57.11 133.65,59.5 133.65,61.93 134.65,62.93 134.65,63.56 133.65,64.56 133.65,65.42 132.65,66.42 132.65,67.47 131.66,68.47 131.66,69.69 132.65,70.69 132.65,71.59 133.65,72.59 133.65,73.49 134.65,74.49 134.65,76.01 135.47,76.83 135.47,78.76 143.9,87.19 143.9,92.01 arc(144.22,92.33) 144.53,92.01 144.53,89 arc(144.85,88.68) 145.17,89 145.17,103.92 146.28,105.03
M_DATA_B38: length 102.6
  TOP w0.102: DIMM3.206 131.74,50.83 131.74,49.05 132.26,48.54 v4(132.26,45.8) 132.26,45.37 132.62,45.01 132.62,44.02 132.21,43.61 132.21,40.98 DIMM1.206 ; v4(153.28,116.52) 153.28,116.52 153.75,116.06 CPU1.AM13
  GND w0.102: v4(153.28,116.52) 153.28,116.52 152.82,116.06 150.9,116.06 150.59,115.75 150.43,115.12 150.43,112.28 149.38,111.23 149.38,110.49 148.44,109.56
  GND w0.14: 148.44,109.56 146.77,107.89 144.9,107.89 141.08,104.06 141.08,93.25 140.63,92.8 arc(140.53,92.57) 140.63,92.35 140.77,92.21 arc(140.77,91.76) 140.32,91.76 140.18,91.9 arc(139.95,91.99) 139.73,91.9 139.25,91.42 139.25,86.6 131.35,78.69 arc(131.25,78.47) 131.35,78.24 131.6,77.99 arc(131.6,77.54) 131.15,77.54 130.9,77.79 arc(130.67,77.89) 130.45,77.79 130.08,77.43 130.08,75.95 129.22,75.09 129.22,74.26 128.21,73.25 128.21,72.36 127.22,71.36 127.22,70.39 126.22,69.39 126.22,68.79 127.22,67.79 127.22,66.65 128.22,65.65 128.22,64.83 129.22,63.83 129.22,62.67 128.22,61.67 128.22,59.39 131.22,56.39 131.22,54.52 132.22,53.52 132.22,52.39 132.21,52.39 131.21,51.39 131.21,50.71 132.21,49.7 132.21,45.84 v4(132.26,45.8)
M_DATA_B39: length 103.3
  TOP w0.102: DIMM1.207 130.79,38.94 130.79,41.24 131.65,42.1 131.65,43.67 131.55,43.77 v4(131.2,43.77) 131.17,43.8 131.17,46.39 131.58,46.79 131.58,48.48 DIMM3.207 ; v4(152.36,116.52) 152.82,116.06 CPU1.AM12
  GND w0.102: v4(152.36,116.52) 152.35,116.52 151.67,117.19 151.1,117.19 150.42,116.51 150.06,115.08 150.06,112.45 148.9,111.3 148.9,110.9 148.56,110.56 148.14,110.56 147.89,110.3 147.89,110.17 147.33,109.61
  GND w0.14: 147.33,109.61 146.53,108.81 146.27,108.55 144.67,108.55 140.44,104.32 140.44,93.53 138.61,91.7 138.61,86.86 129.14,77.38 129.14,76.16 128.65,75.67 128.65,74.49 127.65,73.49 127.65,72.59 126.65,71.59 126.65,70.65 125.66,69.65 125.66,68.56 126.65,67.56 126.65,66.42 127.66,65.42 127.66,64.59 128.66,63.59 128.66,62.9 127.66,61.9 127.66,60.44 127.58,60.37 127.58,59.05 130.13,56.5 130.13,55.76 130.65,55.24 130.65,54.22 131.66,53.22 131.66,52.63 130.65,51.62 130.65,50.47 131.65,49.47 131.65,46.06 131.07,45.47 131.07,43.9 v4(131.2,43.77)
M_DATA_B40: length 106.1
  TOP w0.102: DIMM1.90 127.41,45.02 127.41,48.39 127.64,48.62 v4(127.64,49.74) 127.22,50.17 127.22,51.44 127.93,52.16 DIMM3.90 ; CPU1.AP10 v4(148.37,114.69)
  GND w0.102: v4(148.37,114.69) 147.91,114.23 147.91,113.55 147.65,113.29 147.27,113.29 147.02,113.04 147.02,112.68 146.2,111.86 145.23,111.86 144.41,111.04 142.97,111.04 141.77,109.85 141.64,109.85
  GND w0.14: v4(127.64,49.74) 127.38,49.74 126.66,50.47 126.66,51.63 127.65,52.62 127.65,53.24 126.65,54.24 126.65,55.12 125.94,55.83 125.94,56.77 123.66,59.05 123.66,61.9 124.66,62.9 124.66,63.57 123.66,64.57 123.66,65.42 122.65,66.42 122.65,67.56 121.66,68.56 121.66,69.7 122.65,70.69 122.65,71.59 123.65,72.59 123.65,73.49 124.65,74.49 124.65,76.49 135.97,87.81 135.97,93.35 136.63,94.01 136.63,94.88 arc(136.54,95.1) 136.32,95.2 136.29,95.2 arc(135.97,95.51) 136.29,95.83 136.32,95.83 arc(136.63,96.15) 136.32,96.47 136.29,96.47 arc(135.97,96.78) 136.29,97.1 136.32,97.1 arc(136.63,97.42) 136.32,97.74 136.29,97.74 arc(135.97,98.05) 136.29,98.37 136.32,98.37 arc(136.63,98.69) 136.32,99.01 136.29,99.01 arc(135.97,99.32) 136.29,99.64 136.32,99.64 arc(136.63,99.96) 136.32,100.28 136.29,100.28 arc(135.97,100.59) 136.29,100.91 136.32,100.91 arc(136.54,101) 136.63,101.23 136.63,103.83 arc(136.95,104.15) 137.27,103.83 137.27,100.32 arc(137.59,100) 137.9,100.32 137.9,105.67 141.31,109.08 141.31,109.52 141.64,109.85
M_DATA_B41: length 102.4
  TOP w0.102: CPU1.AP9 v4(147.45,114.69) ; DIMM3.91 126.19,52.18 126.19,51.88 126.65,51.42 126.65,50.67 126.2,50.22 v4(126.2,47.95) 126.88,47.27 126.88,42.66 DIMM1.91
  GND w0.102: v4(147.45,114.69) 146.99,114.23 146.99,113.59 146.58,113.18 146.58,113.04 146,112.45 143.15,112.45 142.04,111.35 140.7,111.35 139.95,110.6 139.95,110.31
  GND w0.14: 139.95,110.31 139.94,110.3 139.94,109.66 134.7,104.43 134.7,88.34 122.65,76.28 122.65,74.49 121.65,73.49 121.65,72.59 120.65,71.59 120.65,70.69 119.66,69.7 119.66,68.56 120.65,67.56 120.65,66.42 121.66,65.42 121.66,64.56 122.66,63.56 122.66,62.9 121.66,61.9 121.66,60.44 121.42,60.21 121.42,58.99 124.04,56.38 124.04,55.84 124.65,55.22 124.65,54.25 125.65,53.25 125.65,52.62 124.66,51.63 124.66,50.48 124.96,50.18 125.66,49.48 125.66,48.59 125.25,48.19 125.25,45.78 125.41,45.63 125.74,45.63 125.92,45.8 125.92,47.66 v4(126.2,47.95)
M_DATA_B42: length 104.3
  TOP w0.102: DIMM1.96 121.71,44.73 121.71,47.42 121.23,47.89 121.23,48.27 121.71,48.75 v4(121.71,49.7) 121.16,50.25 121.16,51.63 121.93,52.4 DIMM3.96 ; CPU1.AP7 v4(145.62,114.69)
  GND w0.102: v4(145.62,114.69) 144.85,114.21 141.61,114.21 141.08,113.67 139.68,113.67 138.9,112.89 138.9,112.49 138.74,112.32
  GND w0.14: 138.74,112.32 132.52,106.1 132.52,94.43 arc(132.2,94.11) 131.88,94.43 131.88,97.51 arc(131.57,97.83) 131.25,97.51 131.25,94.02 130.69,93.46 130.69,88.15 118.65,76.11 118.65,74.49 117.65,73.49 117.65,72.59 116.65,71.59 116.65,70.69 115.65,69.69 115.65,68.5 116.65,67.5 116.65,66.47 117.66,65.47 117.66,64.52 118.66,63.52 118.66,62.85 117.66,61.85 117.66,60.51 117.51,60.36 117.51,59.47 120.43,56.55 120.43,55.53 120.65,55.31 120.65,54.25 121.65,53.26 121.65,53.22 121.65,53.22 121.65,52.62 120.65,51.62 120.65,50.45 121.4,49.7 v4(121.71,49.7)
M_DATA_B43: length 100.5
  TOP w0.102: CPU1.AP6 145.13,115.15 144.73,115.54 144.73,115.58 v4(144.71,115.58) ; DIMM1.97 121.51,43.18 121.51,43.79 121.14,44.16 121.14,46.97 v4(120.48,47.63) 120.24,47.87 120.24,50.12 120.63,50.51 120.63,52.62 DIMM3.97
  GND w0.102: 137.95,113.04 139.46,114.55 140.19,114.55 140.72,115.08 144.21,115.08 v4(144.71,115.58)
  GND w0.14: v4(120.48,47.63) 119.66,48.46 119.66,49.49 118.66,50.49 118.66,51.58 119.66,52.58 119.66,53.29 118.66,54.29 118.66,56.4 115.4,59.66 115.4,60.35 115.66,60.61 115.66,61.85 116.66,62.85 116.66,63.52 115.66,64.52 115.66,65.49 114.66,66.49 114.66,67.49 113.65,68.5 113.65,69.61 114.66,70.62 114.66,71.6 115.65,72.59 115.65,73.49 116.65,74.49 116.65,75.94 129.42,88.7 129.42,93.99 129.98,94.55 129.98,98.33 131.25,99.6 131.25,107.11 137.18,113.04 137.95,113.04
M_DATA_B44: length 104.7
  TOP w0.102: CPU1.AR10 v4(148.37,113.77) ; DIMM3.209 128.93,47.17 129.22,46.89 v4(129.22,43.77) 129.67,43.32 129.67,41.89 128.93,41.15 DIMM1.209
  GND w0.102: v4(148.37,113.77) 148.37,113.5 147.88,113.01 147.88,112.68 147.63,112.43 147.29,112.43 146.35,111.49 145.33,111.49 144.57,110.73 143.44,110.73 142.51,109.79
  GND w0.14: 142.51,109.79 142.51,109.08 138.54,105.11 138.54,98.7 arc(138.22,98.38) 137.9,98.7 137.9,99.04 arc(137.59,99.35) 137.27,99.04 137.27,93.1 136.71,92.54 136.71,87.65 125.53,76.47 125.53,75.7 125.21,75.38 125.21,74.26 124.22,73.26 124.22,72.32 123.22,71.32 123.22,70.39 122.22,69.39 122.22,68.79 122.64,68.37 123.22,67.79 123.22,66.65 124.22,65.65 124.22,64.82 125.22,63.82 125.22,62.67 124.22,61.67 124.22,60.45 124.32,60.35 124.32,59.29 127.22,56.39 127.22,54.47 128.21,53.48 128.21,52.39 127.22,51.4 127.22,50.72 127.64,50.3 127.87,50.3 128.2,49.97 128.2,49.51 127.92,49.23 127.92,48.88 129.23,47.57 129.23,47.01 129.43,46.81 130.85,46.81 131.02,46.64 131.02,46.31 130.56,45.85 130.05,45.85 129.75,46.15 129.41,46.15 129.41,46.14 129.23,45.97 129.23,45.22 128.81,44.8 128.81,44.18 v4(129.22,43.77)
M_DATA_B45: length 103.6
  TOP w0.102: DIMM3.210 128.2,50.75 128.2,46.88 128.66,46.43 v4(128.66,45.86) 128.66,43.73 127.93,43.01 DIMM1.210 ; CPU1.AR9 v4(147.45,113.77)
  GND w0.102: v4(147.45,113.77) 147.45,113.76 146.81,113.12 146.81,112.89 146.07,112.15 144.91,112.15 144.27,111.51 142.83,111.51 141.99,110.67 141.01,110.67 140.58,110.24
  GND w0.14: 140.58,110.24 140.58,109.38 135.34,104.15 135.34,102.93 arc(135.43,102.7) 135.66,102.61 135.68,102.61 arc(136,102.29) 135.68,101.98 135.66,101.98 arc(135.43,101.88) 135.34,101.66 135.34,88.07 123.36,76.09 123.36,75.23 123.21,75.08 123.21,74.25 122.22,73.26 122.22,72.32 121.21,71.32 121.21,70.38 120.22,69.39 120.22,68.79 121.22,67.79 121.22,66.65 122.22,65.65 122.22,64.82 123.22,63.82 123.22,62.67 122.22,61.67 122.22,59.33 125.22,56.33 125.22,54.47 126.21,53.48 126.21,52.39 125.22,51.4 125.22,50.71 126.22,49.71 126.22,48.82 126.9,48.14 126.9,46.51 126.63,46.24 126.63,45.93 126.83,45.73 127.15,45.73 127.55,46.13 127.55,47.65 127.69,47.78 128.15,47.78 128.3,47.64 128.3,46.48 128.48,46.3 128.48,46.3 128.66,46.12 v4(128.66,45.86)
