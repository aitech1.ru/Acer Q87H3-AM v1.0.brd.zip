# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VGA_VCC: length 58.5
  TOP w0.356: U7.5 v2(160.56,221.14)
  TOP w0.381: U24.5 166.4,219.62 v2(167.04,220.25) ; R804.2 R805.2 160.15,207.2 158.91,208.44 158.91,209.36 158.54,209.73 158.54,210.45 159.55,211.46 C208.1
  TOP w0.508: U35.5 166.34,211.84 C210.1 165.04,211.84 v2(164.57,212.3) ; C705.2 168.18,218.92 168.18,219.92 168.63,220.38 v2(168.94,220.38) 169.32,220.38 169.67,220.73 C189.1 169.67,223.9 168.88,224.7 v2(168.88,228.95) ; v2(160.31,212.38) 160.31,211.51 C208.1 161.39,211.46 U36.5
  BOTTOM w0.508: v2(160.56,221.14) 158.75,221.14 SC49.1 158.5,220.66 158.91,220.25 v2(167.04,220.25) 168.82,220.25 v2(168.94,220.38) ; v2(168.88,228.95) 168.8,229.03 165.1,229.03 164.97,228.9 164.39,228.9 VGA.9 ; v2(160.31,212.38) 161.14,211.54 163.81,211.54 v2(164.57,212.3) 164.57,212.91 166.78,215.12 v2(167.67,215.12)
+VREF25: length 6.4
  TOP w0.102: R629.1 v1(105.75,112.65)
  TOP w0.508: D22.C D22.R 103.54,114.46 R602.2 R629.1
-ACTIVE_P: length 65.1
  TOP w0.102: v2(75.17,218.85) 77.06,218.85 R466.1 ; v2(81.82,210.09) 82.3,210.57 83.62,210.57 85.48,208.72 93.54,208.72 94.94,210.12 102.46,210.12 104.98,212.63 v2(105.32,212.63) ; USB3_LAN.31 118.58,215.98 D37.N 118.16,215.77 C491.1 v2(117.13,218.09)
  BOTTOM w0.102: v2(75.17,218.85) 75.34,218.68 75.34,217.54 76.36,216.52 76.36,213.01 78.16,211.21 80.7,211.21 v2(81.82,210.09) ; v2(117.13,218.09) 115.22,218.09 114.14,217.01 114.14,216.12 110.9,212.88 108.74,212.88 107.35,211.49 106.08,211.49 105.32,212.25 v2(105.32,212.63)
-LINK_1G: length 52.2
  TOP w0.102: R465.1 R462.1 79.98,220.38 80.93,220.38 81.71,219.6 82.32,219.6 82.81,219.11 87.17,219.11 89.14,217.14 89.14,211.72 88.75,211.34 88.75,209.5 88.78,209.48 89.08,209.18 93.35,209.18 94.75,210.57 102.25,210.57 104.69,213.01 105.02,213.34 105.68,213.34 106.71,214.38 C494.1 106.63,214.69 D36.N 105.95,216.09 105.95,218.6 105.57,218.98 105.57,219.87 106.84,221.14 107.44,221.14 USB3_LAN.30
-LINK_100: length 49
  TOP w0.102: R464.1 R463.1 79.9,217.66 81.77,217.66 82.99,218.88 87.08,218.88 88.91,217.05 88.91,211.82 88.53,211.44 88.53,209.4 88.98,208.95 93.45,208.95 94.84,210.34 102.35,210.34 105.12,213.11 105.77,213.11 106.86,214.21 107.37,214.21 107.86,214.69 C493.1 108.94,215.78 D35.N 109,215.81 109,218.22 107.9,219.32 USB3_LAN.29
A20GATE: length 239.1
  TOP w0.102: v2(41.82,67.09) 41.82,66.38 42.16,66.03 RN15.1 42.5,64.96 42.81,64.65 42.81,60 44.24,58.56 48.66,58.56 52.1,62.01 59.49,62.01 60.99,63.51 66.83,63.51 68.56,61.78 74,61.78 75.55,60.23 77.32,60.23 79.79,57.76 79.79,48.73 80.86,47.66 81.05,47.66 86.52,47.66 v2(86.77,47.4) ; v2(200.36,27.72) 200.36,27.67 201.12,26.91 U21.46 ; v3(49.14,92.75) 49.92,92.75 PCH1.N30
  BOTTOM w0.102: v3(49.14,92.75) 49.14,89.11 49.14,83.97 49.33,83.78 49.33,82.3 50.43,81.21 v1(50.43,79.92) 50.43,79.81 52.08,78.16 52.08,74.19 49.37,71.48 45.99,71.48 44.17,69.67 42.51,69.67 41.18,68.33 41.18,67.72 v2(41.82,67.09) ; v2(200.36,27.72) 200.36,27.13 196.73,23.5 178.47,23.5 177.07,22.11 170.31,22.11 169.58,22.84 152.76,22.84 149.53,26.07 142.34,26.07 140.48,27.92 131.06,27.92 128.01,30.98 128.01,32 125.03,34.98 122.79,34.98 121.87,34.07 115.81,34.07 115.23,34.65 109.71,34.65 109.33,34.27 107.8,34.27 106.97,33.43 101.75,33.43 100.73,32.42 95.12,32.42 94.16,33.37 94.16,37.15 91.53,39.78 90.01,39.78 88.42,41.36 88.42,42.45 86.77,44.1 v2(86.77,47.4)
AD0: length 35.3
  TOP w0.127: U11.30 65.44,154.09 54.82,143.47 v2(54.52,143.47)
  BOTTOM w0.127: PCI.A58 42.38,130.39 46.75,134.76 46.75,137.19 52.34,142.78 53.83,142.78 v2(54.52,143.47)
AD1: length 40.2
  TOP w0.127: v2(54.11,144.3) 55.15,144.3 65.33,154.49 U11.31
  BOTTOM w0.127: v2(54.11,144.3) 53.22,144.3 46.23,137.32 46.23,136.05 45.47,135.29 44.61,135.29 43.16,133.84 41.46,133.84 40.49,132.87 39.22,132.87 37.3,130.95 PCI.B58
AD2: length 35.8
  TOP w0.127: v2(54.46,142.65) 54.01,143.11 54.01,143.54 53.54,144.01 53.54,144.5 53.85,144.81 55.34,144.81 64.89,154.37 U11.33
  BOTTOM w0.127: v2(54.46,142.65) 54.21,142.4 52.28,142.4 46.98,137.09 46.98,134.67 44.92,132.61 PCI.A57
AD3: length 38.8
  TOP w0.127: v2(54.01,145.32) 55.4,145.32 64.44,154.36 U11.34
  BOTTOM w0.127: PCI.B56 37.56,133.13 40.42,133.13 41.36,134.07 43.07,134.07 44.51,135.52 45.37,135.52 45.94,136.09 45.94,137.35 53.91,145.32 v2(54.01,145.32)
AD4: length 31.6
  TOP w0.127: U11.37 63.24,153.51 55.56,145.83 53.85,145.83 53.27,145.25 53.27,143.84 53.5,143.61 53.5,143.29 v2(53.51,143.29)
  BOTTOM w0.127: v2(53.51,143.29) 52.52,143.29 46.52,137.28 46.52,135.74 PCI.A55
AD5: length 36
  TOP w0.127: U11.38 62.84,153.5 55.68,146.34 53.64,146.34 v2(53.57,146.27)
  BOTTOM w0.127: PCI.B55 40,134.3 42.98,134.3 43.69,135.01 43.69,136.9 44.49,137.7 44.49,138.58 47.36,141.46 49.57,141.46 51.34,143.23 51.34,144.04 v2(53.57,146.27)
AD6: length 31.9
  TOP w0.127: U11.39 62.44,153.5 55.77,146.83 v2(54.05,146.83)
  BOTTOM w0.127: PCI.A54 42.38,135.91 44.2,137.73 44.2,138.61 47.27,141.69 49.48,141.69 50.83,143.04 50.83,144.2 53.46,146.83 v2(54.05,146.83)
AD7: length 33.3
  TOP w0.127: U11.40 62.04,153.48 55.9,147.34 v2(53.51,147.34)
  BOTTOM w0.127: PCI.B53 42.82,136.67 43.85,137.7 43.85,138.59 47.17,141.92 49.38,141.92 50.6,143.14 50.6,144.43 v2(53.51,147.34)
AD8: length 35.7
  TOP w0.127: v2(54.09,147.84) 56.02,147.84 60.84,152.66 U11.43
  BOTTOM w0.127: v2(54.09,147.84) 53.35,147.84 52.97,147.45 52.97,147.11 50.38,144.52 50.38,143.23 49.29,142.15 47.02,142.15 43.47,138.59 43.47,137.65 42.73,136.91 41,136.91 39.97,137.94 PCI.B52
AD9: length 23.6
  TOP w0.127: v2(53.75,149.12) 55.9,149.12 60.44,153.66 U11.44
  BOTTOM w0.127: v2(53.75,149.12) 53.67,149.12 52.51,147.97 52.51,147.3 48.32,143.11 47.22,143.11 45.87,141.75 PCI.A49
AD10: length 31.1
  TOP w0.127: v2(54.11,149.77) 55.91,149.77 60.04,153.9 U11.45
  BOTTOM w0.127: v2(54.11,149.77) 53.58,149.77 52.28,148.47 52.28,147.4 48.72,143.84 46.19,143.84 45.52,143.16 44.28,143.16 43.36,144.08 41.54,144.08 40.48,143.02 PCI.B48
AD11: length 20.8
  TOP w0.127: v2(54.01,151.42) 55.66,151.42 57.87,153.63 57.87,155.23 58.04,155.4 U11.50
  BOTTOM w0.127: v2(54.01,151.42) 53.51,150.92 53.18,150.92 51.82,149.57 51.82,147.59 48.53,144.29 PCI.A47
AD12: length 25.9
  TOP w0.127: v2(53.25,151.39) 53.25,151.42 53.98,152.15 55.76,152.15 57.64,154.04 U11.51
  BOTTOM w0.127: PCI.B47 40.1,144.56 43.09,144.56 43.75,145.22 45.37,145.22 45.92,144.67 48.59,144.67 51.59,147.68 51.59,149.77 53.25,151.42 v2(53.25,151.39)
AD13: length 22.7
  TOP w0.127: U11.52 57.24,154.14 55.66,152.56 53.68,152.56 v2(53.25,152.13)
  BOTTOM w0.127: v2(53.25,152.13) 51.37,150.24 51.37,147.78 48.49,144.9 46.04,144.9 45.78,145.16 45.48,145.46 42.48,145.46 PCI.A46
AD14: length 25.3
  TOP w0.127: U11.53 56.84,154.19 55.72,153.07 v2(54.13,153.07)
  BOTTOM w0.127: PCI.B45 42.71,146.83 43.86,145.69 45.57,145.69 46.13,145.13 48.4,145.13 51.14,147.87 51.14,150.68 53.05,152.6 53.66,152.6 v2(54.13,153.07)
AD15: length 23
  TOP w0.127: v2(53.37,153.07) 53.88,153.58 55.66,153.58 56.44,154.36 U11.54
  BOTTOM w0.127: v2(53.37,153.07) 53.04,153.07 50.91,150.93 50.91,147.97 48.3,145.36 46.23,145.36 45.67,145.92 44.01,145.92 42.38,147.55 PCI.A44
AD16: length 30.1
  TOP w0.127: R291.2 46.13,162.59 v2(46.01,162.47) ; U11.74 50.07,151.29 49.56,150.78 48.78,150.78 48.65,150.65 47.78,150.65 45.65,148.52 44.23,148.52 v2(43.97,148.77)
  BOTTOM w0.127: v2(46.01,162.47) 44.74,163.74 42.77,163.74 PCI.A32 41.31,162.27 41.31,152.56 42.07,151.8 42.63,151.8 43.88,150.56 43.97,150.46 v2(43.97,148.77)
AD17: length 27.2
  TOP w0.127: v2(49.05,161.09) 43.72,161.09 42.73,162.08 41.43,162.08 40.55,162.97 37.67,162.97 PCI.B32 ; v2(48.29,150.15) 48.67,150.15 49.08,150.55 49.66,150.55 49.99,150.89 U11.75
  BOTTOM w0.127: v2(48.29,150.15) 47.91,150.53 47.91,158.84 48.93,159.86 48.93,160.97 v2(49.05,161.09)
AD18: length 24.9
  TOP w0.127: U11.76 49.91,150.49 49.75,150.32 49.28,150.32 48.6,149.64 47.09,149.64 45.44,147.99 v2(44.99,147.99)
  BOTTOM w0.127: PCI.A31 46.48,163.06 46.48,160.42 45.8,159.74 45.8,148.79 v2(44.99,147.99)
AD19: length 34.4
  TOP w0.127: v2(45.75,147.61) 45.75,147.84 47.3,149.38 48.67,149.38 49.37,150.09 U11.77
  BOTTOM w0.127: v2(45.75,147.61) 46.02,147.88 46.02,159.65 46.71,160.33 46.71,164.42 46.57,164.56 45.61,165.51 44.32,165.51 42.91,166.93 41.32,166.93 40.28,165.88 PCI.B30
AD20: length 24.4
  TOP w0.127: v2(47.28,148.55) 47.28,148.7 47.62,149.04 49.22,149.04 49.24,149.02 50,149.02 50.14,148.89 U11.80
  BOTTOM w0.127: v2(47.28,148.55) 47,148.83 47,159.32 47.64,159.97 47.64,164.78 45.94,166.48 45.6,166.48 PCI.A29
AD21: length 32.2
  TOP w0.127: U11.81 50.13,148.49 49.83,148.79 49.15,148.79 49.12,148.81 48.23,148.81 47.4,147.99 46.9,147.99 46.06,147.15 v2(46.06,146.84)
  BOTTOM w0.127: PCI.B29 43,167.15 43.23,166.93 44.41,165.74 45.71,165.74 46.1,165.35 46.93,164.52 46.93,160.23 46.25,159.55 46.25,147.04 v2(46.06,146.84)
AD22: length 28.7
  TOP w0.127: v2(47.15,147.48) 47.3,147.48 48.41,148.58 49.03,148.58 49.05,148.56 49.65,148.56 50.12,148.09 U11.82
  BOTTOM w0.127: v2(47.15,147.48) 46.77,147.86 46.77,159.41 47.42,160.06 47.42,164.68 46.23,165.87 46.23,165.87 45.9,166.2 44.6,166.2 PCI.A28
AD23: length 31.1
  TOP w0.127: U11.83 50.12,147.69 49.71,148.09 v2(49.44,148.09)
  BOTTOM w0.127: PCI.B27 40,169.86 42.93,169.86 44.23,168.56 46.21,168.56 48.42,166.36 48.42,159.67 47.68,158.93 47.68,149.94 49.44,148.19 v2(49.44,148.09)
AD24: length 31.3
  TOP w0.127: U11.85 49.11,146.89 v2(48.93,147.07)
  BOTTOM w0.127: PCI.A25 45.96,171.19 47.79,171.19 50.2,168.79 50.2,147.9 49.37,147.07 v2(48.93,147.07)
AD25: length 39.3
  TOP w0.127: U11.86 49.45,146.49 49.38,146.42 48.47,146.42 47.91,146.97 v2(47.91,147.23)
  BOTTOM w0.127: v2(47.91,147.23) 47.91,148.62 47.23,149.31 47.23,159.23 47.89,159.89 47.89,166.24 46.03,168.1 43.99,168.1 42.69,169.4 41.58,169.4 40.67,168.49 39.26,168.49 38.67,169.09 38.67,172.14 PCI.B24
AD26: length 36.4
  TOP w0.127: v2(47.56,146.05) 47.78,145.83 49.82,145.83 49.96,145.69 U11.88
  BOTTOM w0.127: PCI.A23 44.92,174.47 50.45,168.94 50.45,147.83 48.67,146.05 v2(47.56,146.05)
AD27: length 44.2
  TOP w0.127: U11.89 49.91,145.29 49.71,145.49 47.02,145.49 46.55,145.96 v2(46.51,145.96)
  BOTTOM w0.127: PCI.B23 38.89,173.83 38.89,169.18 39.36,168.72 40.57,168.72 41.49,169.63 42.79,169.63 44.09,168.33 46.12,168.33 48.12,166.33 48.12,159.8 47.45,159.13 47.45,149.46 48.17,148.75 48.17,147.91 48.42,147.66 48.42,147.07 48.11,146.76 47.6,146.76 46.8,145.96 v2(46.51,145.96)
AD28: length 41.4
  TOP w0.127: v2(51.72,156.12) 51.72,155.73 52.15,155.31 52.15,153.24 51.92,153.01 51.92,150.25 52.36,149.82 52.36,142.39 52.84,141.91 U11.98
  BOTTOM w0.127: PCI.A22 45.51,176.04 47.66,173.9 47.66,172.5 50.91,169.25 50.91,156.93 v2(51.72,156.12)
AD29: length 45.7
  TOP w0.127: v2(52.74,154.09) 52.38,153.73 52.38,153.15 52.15,152.92 52.15,150.36 52.59,149.93 52.59,142.49 53.24,141.83 U11.99
  BOTTOM w0.127: PCI.B21 39.84,177.01 41.94,174.91 43.21,174.91 44.12,175.82 45.41,175.82 47.25,173.98 47.25,172.47 50.68,169.04 50.68,156.15 v2(52.74,154.09)
AD30: length 45
  TOP w0.102: U11.100 53.64,141.26
  TOP w0.127: 53.64,141.26 53.64,141.88 52.81,142.7 52.81,150.02 52.38,150.46 52.38,152.78 52.61,153 52.61,153.29 53.31,153.99 v2(53.31,155.1)
  BOTTOM w0.127: PCI.A20 45.76,178.58 48.55,175.8 48.55,172.82 51.37,170 51.37,157.68 52.97,156.08 52.97,155.44 v2(53.31,155.1)
AD31: length 50
  TOP w0.102: U11.101 54.04,141.26
  TOP w0.127: 54.04,141.26 54.04,141.83 53.04,142.83 53.04,150.11 52.61,150.55 52.61,152.68 52.84,152.91 52.84,153.2 53.98,154.34 v2(54.13,154.34)
  BOTTOM w0.127: v2(54.13,154.34) 53.3,154.34 52.38,155.25 52.38,156.34 51.14,157.59 51.14,169.78 48.04,172.88 48.04,174.02 45.79,176.27 43.89,176.27 42.72,177.45 41.82,177.45 40.68,178.58 PCI.B20
ANTI_POP_L: length 5
  TOP w0.102: R480.2 12.61,217.55 12.61,218.09 13.4,218.89 CODEC.47 v2(15.81,218.89)
ATX_3VSB_EN: length 1
  TOP w0.102: U34.4 120.15,21.35 v2(120.15,22.21)
ATX_PSON_L: length 163.3
  TOP w0.102: v2(121.95,4.48) 121.32,3.84 C724.1 ; C724.1 119.76,6.38 ATX_POWER.8 ; C724.1 119.25,4.35 116.88,4.35 116.12,3.59 111.54,3.59 QN47.G ; v2(226.16,15.95) 226.71,15.95 229.53,13.13 230.66,13.13 231.87,11.92 231.87,9.31 231.26,8.7 231.26,5.84 229.27,3.84 QN82.G ; v2(187.56,8.03) 187.56,6.46 187.1,6 186.72,6 186.47,5.75 186.47,4.63 186.85,4.25 190.54,4.25 191.02,4.72 191.02,6.85 191.48,7.31 193.16,7.31 193.63,7.79 195.85,7.79 196.91,8.85 201.08,8.85 201.56,9.33 207.72,9.33 208.12,9.74 v2(208.12,9.86) 208.12,10.83 207.36,11.59 207.36,11.96 207.61,12.21 207.61,12.99 208.22,13.59 R344.1 208.41,13.59 209.48,14.66 U21.76 ; v2(138.59,11.21) v2(138.59,4.91)
  BOTTOM w0.102: v2(138.59,4.91) 138.49,4.81 125.58,4.81 125.25,4.48 v2(121.95,4.48) ; v2(226.16,15.95) 226,16.1 225.08,16.1 224.38,15.4 223.68,15.4 221.99,13.71 213.29,13.71 209.84,10.26 208.52,10.26 v2(208.12,9.86) ; v2(187.56,8.03) 187.43,7.91 183.42,7.91 182.02,9.3 161.1,9.3 160.75,9.66 141.76,9.66 140.22,11.21 v2(138.59,11.21)
ATX_PSON_L_D: length 2.7
  TOP w0.508: QN82.D 229.14,6.7 227.65,6.7 R956.2
ATX_PSON_LOAD: length 3.7
  TOP w0.508: R575.2 108.74,7.19 QN47.D
ATX_PWRGD: length 347.9
  TOP w0.102: v2(86.14,91.22) 86.29,91.37 86.29,109.28 88.04,111.03 90.99,111.03 94.98,115.02 94.98,130.01 96.68,131.71 96.68,151.8 97.85,152.97 97.85,182.89 95.48,185.26 R641.2 ; R582.1 129.32,31.66 v2(129.95,32.29) 130.21,32.54 130.21,35.43 R309.2 129.16,36.07 v2(128.3,35.21) ; ATX_POWER.9 123.54,4.13 R808.2 C725.1 v2(125.29,5.49) ; R343.1 209.79,36.02 209.79,34.88 210.6,34.07 v2(210.98,34.07) ; v2(90.2,54.01) 91.68,54.01 92.74,52.94 92.74,51.18 91.65,50.09 91.65,46.06 v2(91.22,45.63) ; v2(143.16,28.99) 144.81,27.34 144.81,22.64 144.3,22.13 144.3,20.23 144.06,19.98 144.06,16.55 142.15,14.63 v2(142.15,7.65)
  BOTTOM w0.102: v2(125.29,5.49) 138.21,5.49 140.37,7.65 v2(142.15,7.65) ; v2(210.98,34.07) 210.6,34.45 205.75,34.45 203.54,32.24 200.03,32.24 199.35,32.93 197.8,32.93 197.03,32.16 197.03,29.27 196.17,28.4 196.17,27.02 194.28,25.13 177.83,25.13 177.14,24.44 153.51,24.44 150.28,27.67 144.48,27.67 v2(143.16,28.99) 142.63,29.52 131.86,29.52 129.95,31.43 v2(129.95,32.29) ; v2(86.14,91.22) 87.54,91.22 89.44,89.31 89.44,86.9 89.03,86.49 89.03,74.71 87.66,73.34 87.66,62.7 90.58,59.78 90.58,54.39 v2(90.2,54.01) ; v2(91.22,45.63) 91.85,45.63 94.77,42.7 94.77,39.58 98.46,35.9 100.64,35.9 101.48,35.06 106.09,35.06 107.67,36.63 126.88,36.63 v2(128.3,35.21)
ATX_PWRGD_3VSB_1: length 4.1
  TOP w0.102: R309.1 129.55,35.12 v2(128.94,34.5) 128.89,34.45 127.03,34.45 QN39.B
ATX_PWRGD_3VSB_2: length 8.8
  TOP w0.102: R307.1 126.73,31.12 v1(125.71,32.14) 125.2,32.65 125.2,33.23 124.49,33.94 124.49,35.85 125,36.35 126.65,36.35 QN39.C
ATX_PWRGD_3VSB_3: length 23.9
  TOP w0.102: QN37.C 121.32,33.56 121.06,33.81 v2(121.06,34.7) ; QN37.C 123.48,36.61 123.1,36.99 121.19,36.99 120.81,36.61 QN38.G ; QN37.C 124.24,33.56 124.92,32.87 124.92,31.83 R306.1 ; QN37.C 123.48,32.29 v1(123.71,32.06) ; v2(116.62,34.7) 116.11,34.2 115.45,34.2 114.21,35.44 QN36.G
  BOTTOM w0.102: v2(116.62,34.7) 117,34.32 120.68,34.32 v2(121.06,34.7)
ATX_PWRGD_R: length 6.6
  TOP w0.102: U21.19 213.48,33.43 213.23,33.69 212.88,33.69 v1(212.5,34.07) 211.74,34.83 210.85,34.83 210.34,35.34 C394.1 211.2,36.29 R343.2
AUGND: length 62.7
  TOP w0.254: CODEC.42 v2(15.52,221.39) ; C537.2 v2(89.06,236.54) ; C536.2 v2(84.23,224.95) ; CODEC.26 v2(20.7,224.06) ; D24.3 v2(87.03,226.35) ; v2(85.25,223.93) 85.85,223.33 D25.3 ; C535.2 71.44,236.79 v2(71.28,236.63) 71.15,236.51 R528.2 ; R530.2 v2(85.41,239.46) ; C538.2 71.57,239.33 v2(71.41,239.17) 71.28,239.05 R531.2
  TOP w0.381: Q5.E2 6.11,230.9 v2(6.38,231.17) 6.45,231.24 6.99,231.24 7.41,231.66 Q5.E1 ; Q6.E1 12.59,236.54 v2(12.96,236.91) 13.26,237.21 13.46,237.21 13.89,237.63 Q6.E2 ; Q2.E1 17.67,236.54 v2(18.04,236.91) 18.34,237.21 18.54,237.21 18.97,237.63 Q2.E2 ; Q1.E1 10.05,236.87 v2(10.19,237.01) 10.5,237.32 11.04,237.32 11.35,237.63 Q1.E2 ; Q4.E2 16.43,237.63 16,237.21 15.8,237.21 v2(15.5,236.91) 15.13,236.54 Q4.E1 ; Q3.E1 20.21,236.54 v2(20.58,236.91) 20.88,237.21 21.08,237.21 21.51,237.63 Q3.E2
  TOP w0.508: v2(2.83,176.05) 3.33,175.55 R508.1 4.35,175.55 v2(4.86,176.05) ; C510.2 v2(20.77,227.14) ; v2(14,232.44) 14.26,232.7 R519.2 ; v2(8.03,214.79) 8.16,214.66 R526.2 ; v2(12.22,231.81) 12.22,232.98 R514.2 ; C722.1 F_AUDIO.2 ; R525.2 v2(4.73,214.79) ; v2(15.53,230.41) 16.57,230.41 C506.2 ; v2(3.97,234.22) 3.72,233.97 R523.2 ; v2(4.73,234.22) 4.73,233.17 C533.1 ; v2(82.2,222.03) 82.58,221.65 R512.1 ; D28.3 4.82,211.39 5.24,210.98 5.37,210.98 v2(5.75,210.6) ; C531.1 9.3,214.54 v2(9.56,214.79) ; C527.1 6.38,181.77 v2(5.75,181.77) ; C534.1 v2(4.86,231.05) ; R529.2 81.69,223.1 v2(82,222.79) ; v2(20.61,235.23) 20.61,234.73 C507.2 ; v2(10.45,221.65) R491.1 ; C528.1 v2(9.3,185.83) ; R524.2 v2(3.72,231.05) ; v2(22.38,230.41) 21.88,230.92 21.24,230.92 ; C532.1 v2(5.87,214.79) ; D27.3 v2(7.05,211.39) ; QN46.E v2(4.99,177.2)
  BOTTOM w0.254: SC44.2 94.23,220.89 94.65,221.3 v2(94.65,221.65) 94.65,221.9 94.23,222.31 SC45.2 ; v2(89.31,222.28) SR46.2 ; v2(89.31,220.76) SR45.2 ; SD2.3 v2(96.55,221.39)
  BOTTOM w0.508: v2(19.08,220.5) SR15.1 v2(17.18,220.5)
  vias: v2(9.94,226.47) v2(9.94,225.71) v2(17.05,231.3) v2(92.49,239.17) v2(94.39,239.17) v2(95.03,243.11) v2(95.03,234.47) v2(97.31,243.11) v2(97.31,234.47) v2(98.58,239.17) v2(100.11,243.11) v2(100.49,239.17) v2(102.52,243.11)
BCLK: length 6.3
  TOP w0.102: R510.1 18.04,212.19 18.04,214.18 17.72,214.5 C525.1 17.43,214.87 v2(17.86,215.3) 18.2,215.63 CODEC.6
BRIDGE_100M_N: length 63.7
  TOP w0.102: v2(62.06,134.91) 62.44,134.53 71.15,134.53 v1(71.51,134.88) 71.86,134.53 73.44,134.53 75.47,136.56 75.47,141.65 74.71,142.41 74.71,143.06 74.58,143.19 R280.1 ; v3(47.66,103.94) 47.64,103.94 47.35,104.23 PCH1.W7
  BOTTOM w0.102: v3(47.66,103.94) 47.43,104.17 47.12,104.17 46.92,104.37 46.92,106.49 47.33,106.9 47.33,109.65 47.5,109.82 47.5,109.86 47.55,109.91 48.85,111.21 48.85,115.12 52.18,118.45 52.18,129.27 58.27,135.36 60.66,135.36 61.37,134.65 61.81,134.65 v2(62.06,134.91)
BRIDGE_100M_P: length 63.8
  TOP w0.102: PCH1.W6 47.38,104.94 v3(47.65,104.68) ; R281.1 74.96,142.94 74.96,142.51 75.72,141.75 75.72,136.45 73.54,134.27 70.37,134.27 v1(70.01,133.92) 69.65,134.27 62.29,134.27 62.06,134.04 v2(62.06,133.94)
  BOTTOM w0.102: v3(47.65,104.68) 47.65,104.47 47.56,104.38 47.2,104.38 47.12,104.45 47.12,106.41 47.53,106.81 47.53,109.57 47.64,109.68 47.68,109.68 49.11,111.11 49.11,115.01 52.43,118.34 52.43,129.16 58.38,135.11 60.56,135.11 61.27,134.4 62.19,134.4 62.29,134.3 62.29,134.09 62.14,133.94 v2(62.06,133.94)
BRIDGE_CLK_N: length 10.2
  TOP w0.102: R280.2 74.12,144.09 74.52,144.09 74.7,144.27 74.7,144.69 74.29,145.09 73.23,145.09 v1(72.88,144.74) 72.53,145.09 68.82,145.09 68.41,145.5 67.5,145.5 67.31,145.69 U11.9
BRIDGE_CLK_P: length 10.2
  TOP w0.102: U11.10 67.31,146.09 67.64,145.75 68.52,145.75 68.92,145.34 69.5,145.34 v1(69.86,145.7) 70.22,145.34 74.4,145.34 74.95,144.79 74.95,144.41 R281.2
BRIDGE_RX_N2: length 78.6
  TOP w0.102: PCH1.F14 v3(53.96,101.28) ; v2(75.85,154.41) 75.85,154.67 75.65,154.87 71.47,154.87 71,154.4 70.68,154.4 C343.1
  BOTTOM w0.102: v2(75.85,154.41) 76.03,154.59 76.03,154.82 75.95,154.9 75.24,154.9 74.53,154.19 74.53,150.78 76.66,148.65 76.66,123.07 75.9,122.31 75.9,120.43 v1(76.26,120.07) 75.9,119.72 75.9,117.89 75.11,117.1 75.11,114.05 71.2,110.14 69.27,110.14 67.85,108.72 61.48,108.72 57.94,105.19 57.94,103.81 55.6,101.47 54.14,101.47 v3(53.96,101.28)
BRIDGE_RX_N2_C: length 6.8
  TOP w0.102: U11.20 67.21,150.09 67.3,150.18 67.55,150.18 67.75,150.38 67.75,153.66 68.5,154.41 68.82,154.41 C343.2
BRIDGE_RX_P2: length 78.8
  TOP w0.102: C344.1 70.23,154.93 70.56,154.6 70.91,154.6 71.43,155.12 75.62,155.12 v2(75.85,155.35) ; PCH1.G14 v3(53.2,101.28)
  BOTTOM w0.102: v3(53.2,101.28) 53.77,101.7 54.06,101.7 54.1,101.67 55.52,101.67 57.74,103.89 57.74,105.27 61.39,108.92 67.77,108.92 69.19,110.34 71.12,110.34 74.91,114.14 74.91,117.19 75.7,117.97 75.7,121.22 v1(75.34,121.57) 75.7,121.93 75.7,122.39 76.46,123.15 76.46,148.56 74.33,150.7 74.33,154.27 75.16,155.1 75.6,155.1 v2(75.85,155.35)
BRIDGE_RX_P2_C: length 6.8
  TOP w0.102: C344.2 68.8,154.62 68.42,154.62 67.55,153.75 67.55,150.5 67.48,150.43 67.26,150.43 67.21,150.49 U11.21
BRIDGE_TX_N2: length 74.8
  TOP w0.089: 57.98,102.82 57.96,102.82 57.95,102.81 56.66,102.81 56.63,102.84 56.21,102.84 56.02,102.65 55.5,102.65 55.2,102.35 PCH1.D11
  TOP w0.102: 57.98,102.82 58.37,102.82 58.55,103 58.55,103.69 59.18,104.31 59.63,104.31 59.77,104.17 v3(60.08,104.17) ; C653.1 70.23,152.51 70.38,152.36 75.04,152.36 v2(75.39,152.71)
  BOTTOM w0.102: v2(75.39,152.71) 75.72,152.38 76.49,152.38 76.82,152.05 76.82,150.33 77.38,149.77 77.38,117.73 76,116.36 76,113.56 70.02,107.58 62.17,107.58 60.18,105.59 v1(60.18,105.09) 59.68,105.09 59.49,104.9 59.49,104.27 59.62,104.15 60.05,104.15 v3(60.08,104.17)
BRIDGE_TX_N2_C: length 5.9
  TOP w0.102: C653.2 69.28,152.54 69.07,152.33 68.81,152.33 68.41,151.93 68.41,149.85 67.74,149.18 67.37,149.18 67.26,149.29 U11.18
BRIDGE_TX_P2: length 74.9
  TOP w0.089: 57.98,102.62 57.96,102.62 57.95,102.62 56.58,102.62 56.55,102.65 56.29,102.65 56.1,102.46 55.73,102.46 PCH1.C11
  TOP w0.102: v2(75.39,151.85) 75.09,152.15 70.46,152.15 70.23,151.92 C652.1 ; v3(59.45,103.55) 59.45,103.54 59.44,103.53 59.44,103.49 59.67,103.26 59.85,103.26 60,103.41 60,103.66 59.55,104.11 59.26,104.11 58.76,103.61 58.76,102.92 58.45,102.62 57.98,102.62
  BOTTOM w0.102: v2(75.39,151.85) 75.72,152.18 76.4,152.18 76.61,151.97 76.61,150.25 77.17,149.69 77.17,117.81 75.8,116.44 75.8,113.65 69.93,107.78 62.08,107.78 61.09,106.79 v1(60.61,106.79) 60.61,106.31 59.29,104.99 59.29,104.19 59.44,104.04 59.44,103.54 59.45,103.54 v3(59.45,103.55)
BRIDGE_TX_P2_C: length 5.9
  TOP w0.102: U11.17 67.27,148.89 67.36,148.98 67.83,148.98 68.61,149.77 68.61,151.85 68.89,152.13 69.12,152.13 69.28,151.97 C652.2
BST1: length 4.5
  TOP w0.178: 51.85,37.12 51.85,36.61 52.32,36.14 U41.20
  TOP w0.635: R920.1 51.29,38.44 v1(51.47,38.26) 51.59,38.13 51.59,37.37 51.85,37.12
BST1_R: length 2.4
  TOP w0.102: v2(52.43,41.89) 52.69,41.64 C794.1
  TOP w0.635: R920.2 C794.1
BST2: length 3.4
  TOP w0.178: 50.83,29.75 51.98,30.89 52.1,30.89 52.32,31.11 U41.2
  TOP w0.508: 50.83,29.75 50.58,29.5 R907.1
BST2_R: length 2.3
  TOP w0.508: R907.2 50.58,26.96 50.93,26.6 v1(50.98,26.6) 51.45,26.6 51.49,26.64 C784.1
C_BE_L0: length 27.7
  TOP w0.127: v2(53.61,148.4) 53.61,148.41 53.28,148.74 53.28,149.6 53.95,150.27 55.91,150.27 59.64,154 U11.46
  BOTTOM w0.127: v2(53.61,148.4) 53.59,148.4 52.74,147.55 52.74,147.21 48.41,142.88 47.32,142.88 PCI.A52
C_BE_L1: length 33.6
  TOP w0.127: U11.49 58.44,155.47 58.1,155.13 58.1,153.22 55.79,150.91 53.83,150.91 v2(53.37,150.45)
  BOTTOM w0.127: PCI.B44 38.64,146.76 38.64,144.03 39.4,143.26 40.39,143.26 41.44,144.31 43.46,144.31 44.38,143.39 45.42,143.39 46.1,144.07 48.63,144.07 52.05,147.49 52.05,149.13 v2(53.37,150.45)
C_BE_L2: length 17.7
  TOP w0.127: U11.69 51.81,153.29 51.92,153.39 51.92,155.16 48.62,158.46 44.56,158.46 43.32,159.69 42.22,159.69 PCI.B33
C_BE_L3: length 35.7
  TOP w0.127: U11.87 48.29,146.09 47.66,146.72 46.95,146.72 v2(46.87,146.79)
  BOTTOM w0.127: PCI.B26 38.44,169.83 38.44,168.99 39.17,168.26 40.72,168.26 41.56,167.42 43.06,167.42 43.77,166.71 43.85,166.63 44.51,165.97 45.8,165.97 47.1,164.68 47.16,164.61 47.16,160.14 46.51,159.49 46.51,147.1 46.87,146.74 v2(46.87,146.79)
CASE_THERMDA: length 35.9
  TOP w0.254: U21.88 215.48,17.73 220.06,22.31 220.06,25.5 v2(220.38,25.81) ; v2(227.36,26.45) 228.12,26.45 229.17,27.5 C818.2 229.62,27.5 230.03,27.91 230.03,29.56 232.25,31.78 233.87,31.78 234.09,31.56 C819.2 235.78,31.56 v2(236.38,32.16) ; 239.5,31.02 239.5,31.27 238.11,32.67 v2(238.06,32.67)
  BOTTOM w0.254: v2(236.38,32.16) 236.89,32.67 v2(238.06,32.67) ; v2(220.38,25.81) 220.57,26 226.92,26 v2(227.36,26.45)
CASE_THERMDC: length 13.6
  TOP w0.254: 236.96,31.02 237.21,31.26 237.21,32.54 236.51,33.24 235.33,33.24 C819.1 234.51,32.42 231.99,32.42 229.39,29.82 229.39,28.64 C818.1 228.28,28.45 R941.2
CFG0: length 51.2
  TOP w0.102: v2(208.22,125.76) 208.1,125.89 206.08,125.89 205.65,126.32 204.19,126.32 204.12,126.4 202.57,126.4 201.89,127.08 201.89,127.41 201.71,127.59 201.37,127.59 200.94,128.02 198.43,128.02 197.9,128.56 R18.2 197.01,128.56 195.17,130.4 183.49,130.4 180.39,127.29 177.72,127.29 176.91,126.47 176.07,126.47 CPU1.AA37
  BOTTOM w0.102: SJ1.9 217.13,121.91 v1(217.15,121.93) 212.06,121.93 v2(208.22,125.76)
CFG1: length 50
  TOP w0.102: CPU1.Y38 177.43,127.84 179.94,127.84 183.15,131.05 195.28,131.05 196.37,129.95 R20.2 198.31,129.45 201.2,129.45 202.88,127.77 207.07,127.77 v2(207.42,127.41)
  BOTTOM w0.102: v2(207.42,127.41) 211.94,122.89 v1(215.5,122.89) 219.44,122.89 219.92,122.41 SJ1.11
CFG2: length 51.7
  TOP w0.102: v2(208.69,126.91) 208.44,126.65 206.53,126.65 205.65,127.54 202.31,127.54 R21.2 200.79,129.06 196.88,129.06 195.25,130.7 183.28,130.7 180.15,127.57 177.72,127.57 176.82,126.68 175.95,126.68 175.86,126.58 175.26,126.58 CPU1.AA36
  BOTTOM w0.102: v2(208.69,126.91) 212,123.6 v1(213.16,123.6) 219.49,123.6 219.68,123.41 SJ1.15
CFG3: length 49.1
  TOP w0.102: CPU1.W38 176.83,128.15 179.88,128.15 183,131.28 195.56,131.28 196.12,130.72 200.53,130.72 R22.2 202.18,129.06 206.03,129.06 206.41,128.68 v2(207.42,128.68)
  BOTTOM w0.102: SJ1.17 218.2,123.91 SR40.1 v1(215.91,124.75) 211.74,124.75 207.8,128.68 v2(207.42,128.68)
CFG4: length 48.2
  TOP w0.102: v2(207.93,130.72) 202.06,130.72 R23.2 200.66,132.11 182.93,132.11 180.47,129.65 179.42,129.65 178.99,129.22 178.25,129.22 177.9,128.86 CPU1.V39
  BOTTOM w0.102: v2(207.93,130.72) 207.93,129.59 211.13,126.4 v1(212.45,126.4) 212.47,126.41 SJ1.27
CFG5: length 52.4
  TOP w0.102: v2(208.57,133.26) 208.11,133.71 201.24,133.71 201.13,133.81 200.82,133.81 200.36,134.27 R25.2 199.78,134.83 183.86,134.83 180.2,131.16 179.48,131.16 178.65,130.33 178.1,130.33 CPU1.U39
  BOTTOM w0.102: v2(208.57,133.26) 208.31,133.26 207.68,132.62 207.68,131.73 208.44,130.97 208.44,129.41 210.33,127.52 215.55,127.52 v1(215.93,127.13) 216.16,126.91 SJ1.29
CFG6: length 47.9
  TOP w0.102: v2(208.44,131.99) 208.24,132.19 201.98,132.19 R28.2 200.81,133.36 183.23,133.36 180.21,130.34 179.38,130.34 178.81,129.78 CPU1.U40
  BOTTOM w0.102: SJ1.33 212.64,127.91 v1(212.3,128.25) 209.92,128.25 208.67,129.5 208.67,131.76 v2(208.44,131.99)
CFG7: length 47.5
  TOP w0.102: CPU1.V38 176.99,128.86 177.33,128.52 179.82,128.52 182.8,131.5 197.78,131.5 R30.2 198.34,130.94 200.63,130.94 200.91,130.66 201.71,130.66 202.37,130 202.37,129.75 202.83,129.29 209.61,129.29 v2(209.71,129.19)
  BOTTOM w0.102: SJ1.35 214.91,128.41 v1(214.51,128.81) 214.13,129.19 v2(209.71,129.19)
CFG8: length 65.4
  TOP w0.102: CPU1.T40 179.2,131.43 180.08,131.43 184.19,135.54 R32.2 197.92,135.54 198.41,135.06 203.08,135.06 203.16,134.98 206.45,134.98 206.65,134.78 208.99,134.78 216.56,127.21 222.21,127.21 222.71,127.72 223.86,127.72 225.03,128.89 226.03,128.89 v1(226.65,128.28) 226.65,126.88 227.81,125.72 229.69,125.72 230.03,125.38 230.03,123.48 229.27,122.71 v2(229.27,122.59)
  BOTTOM w0.102: SJ1.10 228.8,121.91 229.27,122.38 v2(229.27,122.59)
CFG9: length 60.6
  TOP w0.102: CPU1.Y35 v4(174.34,126.58) ; v2(225.58,122.33) 223.82,122.33 221.15,125 213.2,125 212.19,126.02 209.77,126.02 208.82,125.06 208.12,125.06 207.68,125.51 205.96,125.51 205.71,125.25 204.28,125.25 R33.2 v2(202.85,125.89)
  BOTTOM w0.102: v4(174.34,126.58) 177.02,126.58 179.1,128.66 179.76,128.66 182.58,131.48 v1(184,131.48) 184.31,131.17 196.04,131.17 199.3,127.92 200.82,127.92 v2(202.85,125.89) ; SJ1.12 225.66,122.41 v2(225.58,122.33)
CFG10: length 61.3
  TOP w0.102: CPU1.AA34 v4(173.43,126.58) ; v2(202.85,127.03) R34.2 203.81,127.03 204.29,126.55 205.75,126.55 206.03,126.27 212.57,126.27 213.58,125.26 221.28,125.26 223.82,122.71 225.2,122.71 v2(225.58,123.1)
  BOTTOM w0.102: v2(225.58,123.1) 225.9,123.41 SJ1.16 ; v4(173.43,126.58) 173.91,127.06 176.79,127.06 182,132.27 185.45,132.27 v1(185.88,131.83) 186.32,131.4 196.4,131.4 198.66,129.14 200.16,129.14 202.27,127.03 v2(202.85,127.03)
CFG11: length 57.5
  TOP w0.102: v2(225.58,123.91) 225.1,124.39 225.1,125.07 224.28,125.89 222.2,125.89 221.8,126.3 215.25,126.3 v1(212.22,129.32) 211.7,129.84 210.89,129.84 209.29,131.45 206.34,131.45 205.83,131.96 201.15,131.96 200.74,132.37 198.31,132.37 R36.2 183.27,132.87 180.43,130.03 179.41,130.03 178.8,129.42 178.03,129.42 177.84,129.23 176.89,129.23 176.87,129.24 176.09,129.24 CPU1.V37
  BOTTOM w0.102: SJ1.18 v2(225.58,123.91)
CFG12: length 68.9
  TOP w0.102: v2(223.81,129.19) 223.81,128.94 223.04,128.18 222.52,128.18 222.02,127.67 216.82,127.67 209.2,135.29 206.92,135.29 205.87,136.33 204.13,136.33 R37.2 203.65,136.46 202.85,135.67 201.71,135.67 201.35,136.02 200.79,136.02 v2(200.31,135.54) ; v4(173.43,127.49) CPU1.Y34
  BOTTOM w0.102: SJ1.28 224.31,126.41 224.06,126.66 224.06,128.68 223.81,128.94 v2(223.81,129.19) ; v4(173.43,127.49) 172.99,127.92 172.99,130.45 174.78,132.23 178.31,132.23 181.36,135.29 197.77,135.29 v1(198.28,135.8) 198.66,136.18 199.68,136.18 v2(200.31,135.54)
CFG13: length 67.8
  TOP w0.102: v2(202.85,125) 203.11,124.75 R50.2 ; CPU1.U38 176.99,129.78 177.33,129.43 177.73,129.43 178.02,129.72 178.02,129.87 178.27,130.13 178.87,130.13 179.52,130.79 180.21,130.79 183.69,134.27 R52.2 197.8,134.11 198.33,133.59 200.95,133.59 201.05,133.48 201.61,133.48 v2(202.09,133) 202.57,133.48 205.8,133.48 206.53,132.75 208.68,132.75 209.63,131.8 210.3,131.8 v1(210.85,131.25) 211.77,131.25 216.27,126.75 222.11,126.75 222.46,126.4 224.44,126.4 v2(224.95,126.91)
  BOTTOM w0.102: v2(202.85,125) 203.51,125.66 203.51,132.98 203.21,133.28 202.37,133.28 v2(202.09,133) ; SJ1.30 v2(224.95,126.91)
CFG14: length 64.5
  TOP w0.102: v2(224.57,129.19) 224.57,129.06 223.45,127.95 222.62,127.95 222.11,127.44 216.73,127.44 209.11,135.06 206.82,135.06 205.78,136.1 204.05,136.1 203.65,135.7 R39.2 203.39,135.41 201.2,135.41 v2(201.07,135.54) ; CPU1.W34 v4(173.43,128.4)
  BOTTOM w0.102: v2(201.07,135.54) 200.59,135.06 182.86,135.06 v1(182.51,134.7) 181.1,134.7 178.35,131.95 174.91,131.95 173.91,130.95 173.91,128.89 v4(173.43,128.4) ; v2(224.57,129.19) 224.57,128.43 225.09,127.91 SJ1.34
CFG15: length 61.4
  TOP w0.102: v2(225.58,128.41) 223.82,126.65 222.54,126.65 222.21,126.98 216.36,126.98 208.8,134.55 206.56,134.55 206.35,134.75 204.13,134.75 R41.2 202.9,134.27 v2(202.85,134.32) ; v4(174.34,129.32) CPU1.V35
  BOTTOM w0.102: v4(174.34,129.32) 174.77,129.75 174.77,131.28 175.1,131.6 178.33,131.6 180.69,133.97 184.06,133.97 v1(184.49,134.4) 184.92,134.83 202.34,134.83 v2(202.85,134.32) ; SJ1.36 v2(225.58,128.41)
CFG16: length 60.1
  TOP w0.102: v2(202.85,128.56) R44.2 203.65,128.32 203.87,128.1 211.56,128.1 214.18,125.49 221.54,125.49 223.8,123.22 v2(224.57,123.22) ; CPU1.Y37 v4(176.17,127.49)
  BOTTOM w0.102: v2(224.57,123.22) 224.57,121.29 224.95,120.91 SJ1.6 ; v2(202.85,128.56) 200.82,130.59 197.9,130.59 196.73,131.76 188.27,131.76 v1(187.99,132.04) 187.53,132.5 181.85,132.5 176.84,127.49 v4(176.17,127.49)
CFG17: length 63
  TOP w0.102: v2(202.85,129.95) 202.98,130.08 203.52,130.08 R43.2 204.15,130.46 205.9,130.46 206.41,129.95 210.09,129.95 214.29,125.76 221.65,125.76 223.29,124.11 v2(224.57,124.11) ; CPU1.Y36 v4(175.25,127.49)
  BOTTOM w0.102: SJ1.4 224.97,120.41 224.06,121.32 224.06,123.6 v2(224.57,124.11) ; v2(202.85,129.95) v1(201.96,130.84) 198.28,130.84 196.4,132.72 181.65,132.72 176.84,127.92 175.69,127.92 v4(175.25,127.49)
CFG18: length 59.1
  TOP w0.102: v2(202.85,131.48) 202.98,131.6 203.52,131.6 R47.2 204.15,130.97 205.9,130.97 206.15,131.22 209.19,131.22 214.35,126.07 221.7,126.07 222.13,125.64 223.81,125.64 v2(224.57,124.87) ; CPU1.W36 v4(175.25,128.4)
  BOTTOM w0.102: v4(175.25,128.4) 175.74,128.89 177.49,128.89 181.55,132.95 187.72,132.95 188.35,133.59 196.15,133.59 v1(196.35,133.38) 197.75,131.99 202.34,131.99 v2(202.85,131.48) ; v2(224.57,124.87) 225.1,125.41 SJ1.24
CFG19: length 59.2
  TOP w0.102: v4(175.25,129.32) CPU1.V36 ; v2(225.58,124.91) 225.33,125.16 225.33,125.17 224.35,126.14 222.27,126.14 221.89,126.52 216.11,126.52 212.25,130.38 210.72,130.38 208.59,132.52 205.75,132.52 205.65,132.42 203.94,132.42 203.65,132.72 R45.2 202.98,132.87 v2(202.85,132.75)
  BOTTOM w0.102: SJ1.22 v2(225.58,124.91) ; v4(175.25,129.32) 177.59,129.32 181.46,133.18 187.16,133.18 188.02,134.04 196.86,134.04 v1(198.15,132.75) 198.53,132.37 202.47,132.37 v2(202.85,132.75)
CFG_RCOMP: length 21
  TOP w0.381: R57.2 197.64,141.89 195.75,140 v2(195.36,140) 181.27,140 179.28,138.01 CPU1.H40
CK_DMI_100M_N: length 145.3
  TOP w0.102: PCH1.R2 49.22,107.12 48.88,107.46 48.88,108.32 49.31,108.74 49.31,111.05 49.56,111.3 49.56,113.07 52.89,116.4 66.68,116.4 74.84,108.24 74.84,101.78 75.04,101.58 75.04,100.82 74.89,100.67 74.7,100.67 v2(74.65,100.72) ; v3(142.88,129.32) CPU1.V4
  BOTTOM w0.102: v2(74.65,100.72) 74.96,101.04 74.96,101.51 75.22,101.76 76.66,101.76 79.63,104.73 90.76,104.73 98.84,112.81 98.84,114.84 107.3,123.3 107.3,124.95 112.5,130.16 v1(112.5,130.66) 113.01,130.66 113.44,131.1 121.72,131.1 122.63,132.01 133.26,132.01 arc(133.89,131.38) 133.26,130.74 127.67,130.74 arc(127.29,130.36) 127.67,129.98 139.12,129.98 139.15,129.95 139.88,129.95 141,128.84 143.12,128.84 143.23,128.95 143.23,129.15 143.06,129.32 v3(142.88,129.32)
CK_DMI_100M_P: length 145.3
  TOP w0.102: v3(143.79,129.32) CPU1.V5 ; PCH1.T2 48.68,107.17 48.68,108.4 49.11,108.83 49.11,111.21 49.3,111.41 49.3,113.18 52.78,116.66 66.78,116.66 75.09,108.35 75.09,101.89 75.19,101.79 75.29,101.69 75.29,100.96 75.29,100.96 v2(75.53,100.72)
  BOTTOM w0.102: v2(75.53,100.72) 75.34,100.72 75.22,100.85 75.22,101.4 75.32,101.51 76.77,101.51 79.74,104.48 90.86,104.48 99.09,112.71 99.09,114.74 107.55,123.19 107.55,124.84 111.64,128.94 v1(112.17,128.94) 112.17,129.47 113.55,130.84 121.83,130.84 122.74,131.76 133.26,131.76 arc(133.64,131.38) 133.26,130.99 127.67,130.99 arc(127.03,130.36) 127.67,129.72 139.12,129.72 139.15,129.75 139.8,129.75 140.92,128.63 143.2,128.63 143.43,128.87 143.43,129.16 143.59,129.32 v3(143.79,129.32)
CK_DP_NSSC_N: length 136.9
  TOP w0.102: CPU1.W6 145.17,128.84 v4(145.63,128.38) ; v2(78.07,100.62) 77.83,100.86 77.83,101.63 78.14,101.94 78.14,107.73 67.58,118.28 52.11,118.28 47.53,113.71 47.53,109.74 47.3,109.51 47.3,107.11 PCH1.W2
  BOTTOM w0.102: v2(78.07,100.62) 77.88,100.81 77.88,101.38 80.17,103.66 91.22,103.66 99.96,112.4 99.96,113.88 100.79,114.71 102.01,114.71 104.26,116.96 104.26,118.33 108.36,122.44 108.36,124.49 111.28,127.41 113.11,127.41 114.69,128.99 118.52,128.99 v1(118.93,128.58) 119.34,128.99 121.47,128.99 122.82,130.33 125.63,130.33 127.08,128.89 138.94,128.89 138.97,128.91 139.05,128.91 139.14,128.82 139.14,128.51 139.75,127.9 142.82,127.9 142.98,127.74 144.16,127.74 144.36,127.95 144.89,127.95 145.32,128.38 v4(145.63,128.38)
CK_DP_NSSC_P: length 136.9
  TOP w0.102: CPU1.W5 144.38,128.86 144.71,128.53 v4(144.71,128.4) ; v2(77.19,100.62) 77.24,100.57 77.48,100.57 77.58,100.67 77.58,101.74 77.88,102.04 77.88,107.62 67.48,118.03 52.21,118.03 47.78,113.6 47.78,109.63 47.55,109.4 47.55,107.45 47.66,107.35 47.66,107.06 PCH1.U2
  BOTTOM w0.102: v2(77.19,100.62) 77.45,100.62 77.63,100.79 77.63,101.48 80.06,103.92 91.11,103.92 99.7,112.51 99.7,113.98 100.69,114.97 101.91,114.97 104.01,117.07 104.01,118.44 106.04,120.47 108.11,122.54 108.11,124.6 111.18,127.67 113.01,127.67 114.58,129.24 116.95,129.24 v1(117.51,129.8) 118.07,129.24 121.37,129.24 122.71,130.59 125.74,130.59 127.18,129.14 138.94,129.14 138.97,129.12 139.13,129.12 139.34,128.91 139.34,128.59 139.83,128.1 142.91,128.1 143.06,127.95 144.08,127.95 144.28,128.15 144.61,128.15 144.71,128.25 v4(144.71,128.4)
CK_DP_SSC_N: length 157.2
  TOP w0.102: v3(143.8,130.21) 143.8,130.46 144.03,130.69 CPU1.U5 ; PCH1.T3 48.69,106.41 48.51,106.85 48.51,106.86 48.42,107.09 48.42,107.32 48.47,107.38 48.47,108.54 48.75,108.82 48.75,111.36 48.67,111.44 48.67,113.34 52.55,117.22 67.01,117.22 76.36,107.87 76.36,102.47 76.16,102.27 75.93,102.27 75.72,102.47 75.72,102.76 v2(75.85,102.89)
  BOTTOM w0.102: v3(143.8,130.21) 143.56,129.97 142.97,129.97 141.82,131.12 140.09,131.12 139.76,130.79 135.9,130.79 133.81,132.87 120.65,132.87 119.71,131.93 111.65,131.93 arc(111.28,132.3) 111.65,132.67 118.92,132.67 arc(119.54,133.29) 118.92,133.92 109,133.92 arc(108.46,133.69) 108.24,133.15 108.24,133.13 arc(108.46,132.59) 109,132.37 109.58,132.37 arc(109.75,132.33) 109.89,132.24 arc(109.98,132.1) 110.01,131.93 110.01,128.89 106.48,125.36 106.48,123.76 97.95,115.22 97.95,113.09 94.57,109.71 93.45,109.71 93.23,109.48 v1(92.72,109.48) 92.72,108.97 91.5,107.75 87.33,107.75 85.12,105.54 77.93,105.54 76.38,104 76.38,102.93 76.21,102.75 75.99,102.75 v2(75.85,102.89)
CK_DP_SSC_P: length 157.3
  TOP w0.102: v2(76.87,102.89) 76.61,103.14 76.61,107.98 67.12,117.47 52.44,117.47 48.42,113.44 48.42,111.4 48.55,111.28 48.55,108.91 48.27,108.63 48.27,107.46 48.22,107.41 48.22,107.05 48.37,106.66 48.37,105.9 PCH1.T5 ; CPU1.U6 145.17,130.66 v3(144.74,130.23)
  BOTTOM w0.102: v3(144.74,130.23) 144.43,130.23 143.95,129.75 142.9,129.75 141.73,130.92 140.17,130.92 139.79,130.54 135.79,130.54 133.71,132.62 120.76,132.62 119.82,131.68 111.65,131.68 arc(111.03,132.3) 111.65,132.93 118.92,132.93 arc(119.29,133.29) 118.92,133.66 109,133.66 arc(108.64,133.51) 108.49,133.15 108.49,133.13 arc(108.64,132.77) 109,132.62 109.58,132.62 arc(109.84,132.57) 110.07,132.42 arc(110.22,132.2) 110.27,131.93 110.27,128.79 106.74,125.25 106.74,123.65 98.2,115.12 98.2,112.99 94.67,109.46 93.56,109.46 92.39,108.28 v1(92.39,107.75) 91.86,107.75 91.6,107.5 87.44,107.5 85.23,105.29 78.04,105.29 76.64,103.89 76.64,103.12 v2(76.87,102.89)
CK_H_XDP_N: length 409
  TOP w0.102: v2(78.52,89.87) 78.59,89.8 78.87,89.8 78.98,89.9 78.98,107.78 67.91,118.84 55.97,118.84 55.27,119.54 54.63,119.54 v2(54.3,119.21) ; PCH1.U6 48.46,104.7 v3(48.68,104.7)
  BOTTOM w0.102: v3(48.68,104.7) 48.72,104.66 48.72,104.43 48.65,104.35 48.33,104.35 48.26,104.42 48.26,105.15 48.64,105.54 48.64,108.24 49.92,109.51 49.92,114.6 53.5,118.18 53.5,119.43 53.73,119.67 54.31,119.67 54.41,119.56 54.41,119.32 v2(54.3,119.21) ; v2(78.52,89.87) 78.9,89.49 78.9,89.18 79.28,88.81 79.81,88.81 85.38,83.24 85.38,76.72 81.13,72.48 81.13,64.19 81.85,63.48 82.68,63.48 83.19,62.97 83.19,59.57 82.53,58.91 82.53,56.75 82.2,56.42 v1(81.57,56.42) 81.57,55.79 80.04,54.26 80.04,46.26 81.44,44.86 81.44,41.08 89.44,33.07 89.44,31.66 93.25,27.85 110.95,27.85 112.17,26.63 118.4,26.63 119.98,25.04 120.17,24.85 121.02,24.85 123.33,22.54 147.84,22.54 151.04,19.34 155.34,19.34 156.48,18.19 166.81,18.19 167.57,18.96 178.49,18.96 179.89,20.35 190.33,20.35 191.91,18.78 198.29,18.78 198.72,19.21 200.4,19.21 202.19,21 206.27,21 211.65,26.37 217.62,26.37 219.87,24.12 228.72,24.12 229.52,24.92 231.81,24.92 232.57,25.69 232.57,29.88 234.35,31.66 234.35,37.39 235.49,38.54 235.49,42.22 236.99,43.72 236.99,49.94 240.32,53.27 240.32,64.85 239.28,65.89 239.28,67.24 236.89,69.63 235.26,69.63 229.32,75.57 229.32,82.05 223.43,87.94 223.43,99.45 222.03,100.85 222.03,107.12 231.05,116.13 231.05,119.13 231.48,119.56 231.48,121.4 231.05,121.83 231.05,125.29 SR34.1
CK_H_XDP_P: length 408.8
  TOP w0.102: v2(54.3,120.12) 54.63,119.79 55.38,119.79 56.08,119.1 68.02,119.1 79.23,107.88 79.23,90.08 v2(79.43,89.87) ; v3(48.68,103.94) 48.39,104.23 PCH1.U7
  BOTTOM w0.102: v2(79.43,89.87) 79.15,89.59 79.15,89.29 79.38,89.06 79.92,89.06 85.63,83.34 85.63,76.61 81.39,72.37 81.39,64.3 81.95,63.74 82.73,63.74 83.45,63.02 83.45,59.46 82.79,58.8 82.79,56.65 81.31,55.17 v1(81.31,54.52) 80.66,54.52 80.3,54.16 80.3,46.37 81.69,44.97 81.69,41.18 89.69,33.18 89.69,31.76 93.36,28.1 111.06,28.1 112.28,26.88 118.5,26.88 120.28,25.1 121.12,25.1 121.32,24.9 121.35,24.88 123.44,22.79 147.94,22.79 150.36,20.37 151.14,19.59 155.44,19.59 156.58,18.45 166.7,18.45 167.47,19.21 178.38,19.21 179.78,20.61 190.44,20.61 192.01,19.03 198.18,19.03 198.62,19.46 200.3,19.46 202.08,21.25 206.17,21.25 211.54,26.63 217.73,26.63 219.97,24.38 228.61,24.38 229.41,25.18 231.7,25.18 232.32,25.79 232.32,29.98 234.09,31.76 234.09,37.5 235.24,38.64 235.24,42.32 236.74,43.82 236.74,50.05 240.06,53.37 240.06,64.75 239.02,65.79 239.02,67.14 236.78,69.37 235.15,69.37 229.06,75.46 229.06,81.94 223.17,87.84 223.17,99.35 221.77,100.74 221.77,107.22 230.79,116.24 230.79,119.23 231.22,119.67 231.22,121.29 230.79,121.72 230.79,125.61 230.64,125.76 230.38,125.76 SR33.1 ; v3(48.68,103.94) 48.47,104.15 48.24,104.15 48.06,104.33 48.06,105.24 48.39,105.57 48.39,108.34 49.66,109.62 49.66,114.7 53.25,118.28 53.25,119.56 53.6,119.92 54.1,119.92 v2(54.3,120.12)
CLKIN_GND_N: length 14
  TOP w0.102: v2(62.26,106.27) 62.71,106.71 R150.1 ; v3(53.27,99.94) 53.57,99.65 PCH1.G16
  BOTTOM w0.102: v2(62.26,106.27) 61.66,105.67 61.66,105.07 59.52,102.93 58.1,102.93 56.77,101.6 56.77,101.07 55.88,100.18 54.36,100.18 54.29,100.26 54.21,100.34 53.68,100.34 v3(53.27,99.94)
CLKIN_GND_P: length 12.4
  TOP w0.102: R149.1 62.45,105.57 v2(62.33,105.44) ; v3(54.04,99.94) 54.04,99.64 PCH1.F16
  BOTTOM w0.102: v3(54.04,99.94) 54.06,99.96 55.95,99.96 56.97,100.99 56.97,101.51 57.85,102.39 v1(58.73,102.39) 59.47,102.39 62.33,105.25 v2(62.33,105.44)
CLKIN_SATA_N: length 19
  TOP w0.102: v2(55.4,80.88) 55.74,81.21 56.21,81.21 56.84,81.84 60.08,81.84 62.64,79.28 R163.1 ; PCH1.H35 53.23,89.32 v3(53.4,89.15)
  BOTTOM w0.102: v3(53.4,89.15) 53.4,89.14 53.03,88.76 53.03,88.19 54.31,86.9 54.31,84.36 54.64,84.03 v1(54.64,81.46) 54.77,81.46 55.36,80.88 v2(55.4,80.88)
CLKIN_SATA_P: length 18.8
  TOP w0.102: PCH1.H36 53.28,88.67 v3(53.43,88.52) ; R164.1 62.15,78.79 62.15,79.45 59.96,81.64 57.13,81.64 v2(56.17,80.68)
  BOTTOM w0.102: v3(53.43,88.52) 53.43,88.08 54.52,87 54.52,84.61 55.14,83.99 55.14,83.56 v1(55.51,83.19) 55.15,82.84 55.15,82.01 56.17,81 v2(56.17,80.68)
CLR_CMOS_P3: length 3.5
  TOP w0.102: CLR_CMOS.3 6.35,65.18 R254.2
COM1_CTS_L: length 234.5
  TOP w0.102: v2(237.01,62.67) 238.16,63.81 238.16,70.42 231.96,76.61 231.96,81.59 235.01,84.64 239.75,84.64 242.27,87.16 242.27,199.92 238.96,203.23 228.75,203.23 227.71,202.19 212.53,202.19 208.59,206.13 204.65,206.13 200.61,210.18 U42.14 ; v2(229.52,34.58) 229.27,34.83 226.35,34.83 223.93,32.41 U21.1
  BOTTOM w0.102: v2(229.52,34.58) 229.52,34.68 229.81,34.96 229.81,39.54 230.89,40.62 230.89,49.33 232.19,50.63 232.19,56.19 v1(233.41,57.41) 234.73,58.73 234.73,60.38 v2(237.01,62.67)
COM1_DCD_L: length 229.7
  TOP w0.102: v2(236.89,59.6) 237.52,59.6 239.43,61.5 239.43,70.64 243.21,74.43 243.21,81.46 241.59,83.09 241.59,84.26 243.44,86.11 243.44,200.49 239.43,204.5 228.22,204.5 227.18,203.46 213.42,203.46 207.27,209.61 204.22,209.61 203.86,209.97 U42.19 ; v2(227.36,33.75) 226.16,33.75 223.3,30.89 223.3,30.13 223.52,29.91 U21.127
  BOTTOM w0.102: v2(236.89,59.6) 236.28,58.99 v1(235.77,58.99) 235.11,58.33 235.11,57.46 232.42,54.77 232.42,50.43 231.11,49.12 231.11,40.52 230.03,39.44 230.03,34.41 229.19,33.56 227.55,33.56 v2(227.36,33.75)
COM1_DSR_L: length 239.1
  TOP w0.102: U21.123 225.4,27.91 226.04,28.56 226.04,29.89 227.87,31.72 v2(228.12,31.72) ; v2(240.7,84.23) 240.7,84.61 242.98,86.9 242.98,200.18 239.2,203.96 228.47,203.96 227.41,202.9 213.12,202.9 207.84,208.19 204.12,208.19 202.56,209.75 U42.17 ; v2(237.93,73.26) 238.92,72.27 238.92,62.01 238.03,61.12 v2(236.91,61.12)
  BOTTOM w0.102: v2(240.7,84.23) 235.24,84.23 232.47,81.46 232.47,76.75 233.88,75.34 234.35,74.87 235.96,73.26 v2(237.93,73.26) ; v2(236.91,61.12) 237.6,60.43 237.6,56.1 235.74,54.25 235.74,53.75 v1(234.73,52.74) 233.79,51.8 233.79,46.39 232.49,45.09 232.49,39.87 231.41,38.79 231.41,33.74 229.39,31.72 v2(228.12,31.72)
COM1_DTR_L: length 237.2
  TOP w0.102: U21.126 223.43,29.41 223.07,29.77 223.07,30.99 226.66,34.58 228.54,34.58 v2(228.8,34.32) ; U42.13 199.96,210.32 204.48,205.8 208.49,205.8 212.33,201.96 227.8,201.96 228.84,203 238.87,203 242.04,199.83 242.04,87.26 239.66,84.87 234.91,84.87 231.73,81.69 231.73,76.52 237.9,70.35 237.9,64.24 v2(237.24,63.58)
  BOTTOM w0.102: v2(237.24,63.58) v1(233.03,59.37) 231.96,58.3 231.96,50.84 230.66,49.54 230.66,40.71 229.58,39.63 229.58,35.78 228.8,35 v2(228.8,34.32)
COM1_NCTS_L: length 15.5
  TOP w0.102: U42.7 200.61,218.43 199.83,219.21 CN5.4 199.83,220.86 199.93,220.96 201.02,220.96 201.23,221.16 201.23,224.77 203.02,226.56 COM1.8
COM1_NDCD_L: length 13.2
  TOP w0.102: U42.2 203.86,218.21 204.96,219.31 CN6.2 205.35,220.19 205.73,220.57 205.73,223.25 COM1.1
COM1_NDSR_L: length 18.6
  TOP w0.102: COM1.6 207.95,230.3 205.77,228.12 205.77,226.85 205.14,226.22 203.87,226.22 201.94,224.29 201.94,221.16 202.14,220.96 203.26,220.96 203.33,220.89 CN6.6 203.33,219.21 202.56,218.43 U42.4
COM1_NDTR_L: length 13.7
  TOP w0.102: COM1.4 197.59,223.42 197.59,221.19 197.82,220.96 198.91,220.96 199.02,220.86 CN5.6 199.02,219.51 199.96,218.57 U42.8
COM1_NRI_L: length 35.5
  TOP w0.102: COM1.9 200.25,226.66 197.37,223.78 197.37,220.53 197.71,220.19 CN5.8 198.2,219.69 199.31,218.59 U42.9 199.31,216.06 198.99,215.74 196.25,215.74 195.94,215.44 195.94,212.81 195.99,212.76 195.99,212.76 196.1,212.66 196.1,211 197.39,209.71 198.05,209.71 198.56,209.2 198.56,207.58 197.9,206.92 197.9,203.12 D15.P
COM1_NRTS_L: length 15.9
  TOP w0.102: COM1.7 203.36,227.87 203.36,226.58 201.45,224.67 201.45,220.5 201.14,220.19 CN5.2 200.64,219.29 201.26,218.67 U42.6
COM1_NSIN: length 12.6
  TOP w0.102: COM1.2 205.51,225.79 205.51,221.26 205.4,221.15 205.4,221.13 205.24,220.96 204.25,220.96 204.15,220.86 CN6.4 204.15,219.26 203.21,218.32 U42.3
COM1_NSOUT: length 12.4
  TOP w0.102: U42.5 201.91,218.67 202.52,219.29 CN6.8 202.03,220.19 201.71,220.5 201.71,224.57 204.4,227.26 COM1.3
COM1_RI_L: length 432.2
  TOP w0.102: v2(61.88,235.87) 62.21,235.54 65.07,235.54 66.47,234.14 72.63,234.14 74.07,232.7 v2(74.07,225.84) ; v2(60.61,238.54) 59.85,239.3 59.21,239.3 58.71,238.79 R461.2 ; v2(82.58,210.09) 83.6,210.09 85.2,208.49 93.64,208.49 95.03,209.89 102.56,209.89 104.79,212.12 105.95,212.12 106.74,211.34 v2(106.74,206.33) ; v2(196.45,219.39) 196.1,219.03 196.1,215.91 195.71,215.53 195.71,212.71 195.87,212.56 195.87,210.6 196.63,209.84 196.63,208.46 D32.N 197.83,209.15 v2(197.92,209.15) ; v2(199.3,209.15) 200.49,209.15 204.07,205.57 208.34,205.57 212.17,201.73 227.9,201.73 228.94,202.78 238.77,202.78 241.82,199.73 241.82,87.35 239.56,85.1 234.69,85.1 231.5,81.91 231.5,76.42 237.67,70.25 237.67,65.46 236.86,64.65 v2(236.86,64.37) ; v2(75.47,224.44) 77.76,224.44 78.26,223.93 78.26,222.95 R695.2 ; v2(228.06,34.07) 228.06,33.62 227.55,33.12 226.28,33.12 224.48,31.31 U21.128
  BOTTOM w0.102: v2(74.07,225.84) v2(75.47,224.44) 75.72,224.19 75.72,217.48 76.61,216.59 76.61,213.14 78.32,211.44 81.24,211.44 v2(82.58,210.09) ; v2(60.61,238.54) 61.42,238.54 62.4,237.56 62.4,236.39 v2(61.88,235.87) ; v2(236.86,64.37) 236.86,64.27 v1(235.97,63.38) 231.73,59.14 231.73,50.93 230.43,49.63 230.43,40.81 229.35,39.73 229.35,35.93 228,34.58 228,34.13 v2(228.06,34.07) ; v2(106.74,206.33) 107.84,206.33 110.38,208.87 113.62,208.87 116.84,212.09 120.72,212.09 121.57,211.23 129.7,211.23 133.82,215.35 137.22,215.35 143.06,221.19 148.29,221.19 149.26,222.16 153.32,222.16 154.29,223.12 160.36,223.12 161.83,221.65 187.99,221.65 189.25,220.39 193.44,220.39 195.03,218.8 195.87,218.8 v2(196.45,219.39) ; v2(197.92,209.15) v2(199.3,209.15)
COM1_RI_L_IC: length 6.4
  TOP w0.102: D32.P 196.88,210.85 197.77,209.96 198.99,209.96 199.31,210.28 U42.12 v2(199.31,212.87)
COM1_RTS_L: length 242.2
  TOP w0.102: U42.15 201.26,210.03 204.76,206.53 208.69,206.53 212.78,202.44 227.6,202.44 228.64,203.49 239.03,203.49 242.5,200.02 242.5,87.07 239.85,84.41 235.1,84.41 232.19,81.5 232.19,76.71 238.41,70.49 238.41,63.08 v2(237.78,62.44) ; U21.122 222.64,27.41 221.95,28.1 v2(221.95,29.24)
  BOTTOM w0.102: v2(221.95,29.24) 223.3,29.24 225.01,30.96 229.27,30.96 231.86,33.55 231.86,38.44 232.94,39.52 232.94,44.74 234.25,46.04 234.25,51.05 236.76,53.56 v1(236.76,54.13) 236.76,54.62 238.06,55.91 238.06,62.16 v2(237.78,62.44)
COM1_SIN: length 230.5
  TOP w0.102: U21.125 225.38,28.91 225.58,29.12 225.58,31.85 226.03,32.29 226.98,32.29 v2(227.3,31.97) ; U42.18 203.21,210.09 204.3,209 v1(206.18,209) 207.35,209 213.2,203.15 227.31,203.15 228.35,204.19 239.3,204.19 243.21,200.28 243.21,86.37 241.21,84.36 241.21,83.09 242.98,81.31 242.98,74.58 239.17,70.77 239.17,61.75 237.78,60.36 v2(236.89,60.36)
  BOTTOM w0.102: v2(227.3,31.97) 227.58,32.25 229.5,32.25 231.18,33.93 231.18,38.89 232.26,39.97 232.26,45.44 233.56,46.74 233.56,52.38 237.37,56.19 237.37,59.87 v2(236.89,60.36)
COM1_SOUT: length 238.2
  TOP w0.102: v2(237.27,61.88) 237.9,61.88 238.67,62.64 238.67,70.56 232.42,76.8 232.42,81.4 235.2,84.18 239.94,84.18 242.73,86.97 242.73,200.11 239.13,203.72 228.55,203.72 227.51,202.67 212.94,202.67 208.44,207.17 v1(206.15,207.17) 204.76,207.17 201.91,210.02 U42.16 ; v2(226.35,31.78) 225.81,31.25 225.81,28.71 225.52,28.41 U21.124
  BOTTOM w0.102: v2(226.35,31.78) 226.92,31.21 229.2,31.21 231.63,33.64 231.63,38.59 232.71,39.67 232.71,44.83 234.02,46.13 234.02,51.14 236.1,53.23 236.1,54.28 237.83,56.01 237.83,61.32 v2(237.27,61.88)
COM2_CTS_L: length 339.9
  TOP w0.102: v2(226.54,20.92) 226.85,20.92 227.9,19.88 227.9,16.7 230.09,14.5 231.23,14.5 232.91,12.82 237.36,12.82 238.67,14.13 240.46,14.13 242.97,11.62 242.97,3.46 240.53,1.02 4.29,1.02 2.32,2.99 1.65,3.66 1.65,21.89 1.65,21.89 1.65,22.46 1.65,24.1 3.88,26.33 5.52,26.33 9.25,30.06 10.01,30.06 12.45,30.06 13.88,28.63 13.88,27.88 U43.14 ; U21.27 209.48,31.12 214.31,26.3 214.31,24.26 212.62,22.57 v2(212.62,22.2)
  BOTTOM w0.102: v2(212.62,22.2) 212.83,21.99 212.88,21.99 214.19,23.3 216.62,23.3 218.68,21.24 224.95,21.24 v1(225.46,20.73) 226.35,20.73 v2(226.54,20.92)
COM2_DCD_L: length 323
  TOP w0.102: v2(226.5,17.6) 226.5,16.48 229.62,13.35 230.76,13.35 232.1,12.01 232.1,9.21 231.49,8.6 231.49,2.95 230.7,2.16 87.64,2.16 86.34,3.46 86.34,8.96 82.69,12.61 77.64,12.61 73.98,8.94 73.98,4.65 71.48,2.16 4.77,2.16 2.79,4.13 2.79,23.62 4.36,25.19 5.99,25.19 9.73,28.92 10.42,28.92 10.6,28.73 U43.19 ; v2(212.12,20.73) 212.12,20.86 213.16,21.9 213.16,22.79 214.54,24.16 214.54,26.56 209.98,31.12 U21.26
  BOTTOM w0.102: v2(212.12,20.73) 212.12,20.35 212.38,20.1 222.41,20.1 v1(222.79,19.72) 224.91,17.6 v2(226.5,17.6)
