# Allegro board Acer Q87H3-AM v1.0.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
COM2_DSR_L: length 324.1
  TOP w0.102: U43.17 11.92,27.87 11.92,28.64 11.19,29.37 9.73,29.37 9.54,29.37 5.8,25.64 4.17,25.64 2.34,23.81 2.34,3.94 2.6,3.68 2.6,3.68 4.58,1.7 71.67,1.7 74.44,4.46 74.44,8.75 77.83,12.15 82.51,12.15 85.88,8.77 85.88,3.27 87.45,1.7 230.89,1.7 231.95,2.76 231.95,8.41 232.56,9.02 232.56,12.2 230.95,13.81 229.81,13.81 227.21,16.41 227.21,18.47 v2(226.54,19.15) ; U21.22 211.98,30.91 215.09,27.79 215.09,23.91 213.9,22.71 213.9,21.96 v2(213.98,21.88)
  BOTTOM w0.102: v2(213.98,21.88) 213.98,21.87 v1(214.74,21.11) 215.3,20.56 223.76,20.56 225.17,19.15 v2(226.54,19.15)
COM2_DTR_L: length 343.5
  TOP w0.102: U21.29 208.48,31.29 212.38,27.4 212.38,22.77 212.12,22.51 v2(212.12,21.62) ; U43.13 14.5,29.53 13.74,30.29 10.1,30.29 9.16,30.29 5.43,26.56 3.79,26.56 1.42,24.19 1.42,22.55 1.42,3.56 2.23,2.76 4.2,0.79 240.62,0.79 243.2,3.37 243.2,11.71 240.55,14.36 238.58,14.36 237.27,13.05 233,13.05 231.33,14.73 230.19,14.73 228.12,16.79 228.12,20.42 v2(227.81,20.73)
  BOTTOM w0.102: v2(212.12,21.62) 212.12,22.38 212.63,22.89 213.46,22.89 214.1,23.53 216.72,23.53 218.78,21.47 226.69,21.47 227.43,20.73 v2(227.81,20.73)
COM2_NCTS_L: length 13.4
  TOP w0.102: U43.7 13.85,20.68 14,20.53 14,16.95 13.16,16.11 11.24,16.11 11.13,16.01 11.13,15.04 10.9,14.82 CN8.3 7.8,14.82 COM2.8
COM2_NDCD_L: length 11.7
  TOP w0.102: U43.2 10.6,20.11 CN7.1 9.25,19.74 8.8,20.2 8.8,23.17 8.12,23.85 5.81,23.85 COM2.1
COM2_NDSR_L: length 12.8
  TOP w0.102: U43.4 11.9,21.13 12.05,20.99 12.32,20.99 12.33,20.98 12.38,20.98 13.27,20.1 13.27,17.3 12.76,16.8 11.23,16.8 11.03,17 11.03,17.91 10.83,18.12 CN7.5 7.7,18.12 COM2.6
COM2_NDTR_L: length 31.3
  TOP w0.102: COM2.4 6.33,21.37 3.84,21.37 3.64,21.17 3.64,14.84 4.48,14 CN8.5 10.78,14 11.03,13.75 11.03,12.83 11.18,12.68 12.86,12.68 13.39,13.22 13.39,14.62 14.23,15.46 14.23,20.13 14.5,20.4 U43.8
COM2_NRI_L: length 449.1
  TOP w0.102: v2(7.4,24.99) 14.19,24.99 15.15,24.03 U43.9 15.15,20.72 14.46,20.03 14.46,15.37 13.62,14.53 13.62,13.12 12.95,12.45 10.68,12.45 10.23,12.9 CN8.7 5.32,13.19 COM2.9 ; v2(75.7,123.45) 75.06,123.45 66.78,131.73 59.21,131.73 58.55,132.39 50.23,132.39 46.39,136.23 46.39,137.29 45.53,138.15 44.66,138.15 43.36,139.44 43.36,140.63 41.03,142.97 41.03,149.73 39.98,150.78 39.53,150.78 38.13,152.18 35.34,152.18 33.56,153.96 26.96,153.96 26.65,154.27 23.47,154.27 22.47,153.27 19.03,153.27 18.07,152.31 17.27,152.31 16.42,151.45 16.42,150.59 11.18,145.35 1.45,145.35 1.07,144.96 1.07,30.89 2.71,29.24 4.99,29.24 5.75,28.48 v2(6.64,28.48) ; v2(99.47,179.74) 99.19,179.46 99.19,149.31 v2(99.22,149.28) ; D14.P 200.95,202.22 200.06,201.33 198.03,201.33 198.02,201.34 196.66,199.98 151.25,199.98 148.63,202.6 142.68,202.6 141.62,201.53 133.2,201.53 130.84,199.17 120.58,199.17 112.3,190.89 112.3,184.69 v2(112.68,184.31) ; v2(75.7,128.66) 77.32,130.28 77.32,148.2 77.9,148.77 78.92,148.77 79.92,149.77 83.47,149.77 84.51,148.73 85.59,148.73 86.37,149.51 v2(90.2,149.51)
  BOTTOM w0.102: v2(90.2,149.51) 90.2,149.38 91.22,148.37 97.8,148.37 98.71,149.28 v2(99.22,149.28) ; v2(75.7,128.66) 74.99,127.95 74.99,124.16 v2(75.7,123.45) ; v2(112.68,184.31) 110.85,182.48 104.55,182.48 101.81,179.74 v1(101,179.74) v2(99.47,179.74) ; v2(7.4,24.99) 6.64,25.75 v2(6.64,28.48)
COM2_NRTS_L: length 15.6
  TOP w0.102: U43.6 13.2,20.81 13.72,20.29 13.72,20.28 13.77,20.23 13.77,17.08 13.04,16.34 10.65,16.34 10.23,15.92 CN8.1 8.73,15.63 8.1,16.26 5.85,16.26 COM2.7
COM2_NSIN: length 9.7
  TOP w0.102: U43.3 11.25,21.17 11.06,20.97 11.06,19.34 10.65,18.93 CN7.3 8.87,18.93 8.49,19.31 8.49,21.75 COM2.2
COM2_NSOUT: length 17.1
  TOP w0.102: U43.5 12.55,21.14 13.49,20.19 13.49,17.21 13.36,17.08 12.85,16.57 10.78,16.57 10.23,17.11 CN7.7 8.41,17.3 8.01,16.9 6.69,16.9 5.8,17.79 5.8,19.36 COM2.3
COM2_RI_L: length 328.2
  TOP w0.102: U21.28 208.98,31.11 212.88,27.21 v2(212.88,23.53) ; D31.N 1.19,24.83 1.19,22.65 1.19,3.47 2.13,2.53 4.1,0.56 240.72,0.56 243.43,3.27 243.43,11.81 240.65,14.59 238.48,14.59 237.17,13.28 233.1,13.28 231.42,14.96 230.28,14.96 228.35,16.89 228.35,20.89 227.81,21.43 v2(227.49,21.43)
  BOTTOM w0.102: v2(212.88,23.53) 213.24,23.88 216.69,23.88 218.87,21.7 227.22,21.7 v2(227.49,21.43)
COM2_RI_L_IC: length 13.8
  TOP w0.102: D31.P 4.62,31.26 5.62,30.26 v1(5.98,30.26) 6.31,30.59 14.23,30.59 15.15,29.67 U43.12
COM2_RTS_L: length 332.3
  TOP w0.102: U43.15 13.23,27.88 13.23,28.63 12.03,29.83 9.91,29.83 9.35,29.83 5.62,26.1 3.98,26.1 1.88,24 1.88,22.36 1.88,3.75 2.41,3.22 4.39,1.24 71.86,1.24 72.13,1.51 74.99,4.37 74.99,8.66 78.02,11.69 82.32,11.69 85.43,8.58 85.43,3.08 87.26,1.24 231.08,1.24 232.4,2.57 232.4,8.22 233.01,8.83 233.01,12.39 231.14,14.27 230,14.27 227.67,16.6 227.67,19.41 v2(227.36,19.72) ; U21.23 211.48,31.08 214.87,27.7 214.87,24 213.39,22.53 v2(213.39,21.37)
  BOTTOM w0.102: v2(227.36,19.72) 227.36,20.04 226.98,20.42 226.03,20.42 225.71,20.1 225.08,20.1 224.16,21.01 218.59,21.01 216.88,22.71 v1(215.53,22.71) 215.17,23.07 214.28,23.07 213.39,22.18 v2(213.39,21.37)
COM2_SIN: length 324.4
  TOP w0.102: U21.20 212.98,30.67 215.68,27.97 215.68,22.89 213.39,20.61 v2(212.88,20.61) ; v2(226.54,18.38) 226.98,17.94 226.98,16.32 229.72,13.58 230.85,13.58 232.33,12.11 232.33,9.12 231.72,8.51 231.72,2.85 230.8,1.93 87.54,1.93 86.11,3.36 86.11,8.86 82.6,12.38 77.74,12.38 74.21,8.85 74.21,4.56 71.58,1.93 4.67,1.93 2.7,3.9 2.57,4.04 2.57,23.72 4.26,25.41 5.9,25.41 9.63,29.15 11.08,29.15 11.25,28.97 U43.18
  BOTTOM w0.102: v2(212.88,20.61) 213.16,20.33 223.17,20.33 v1(225.08,18.42) 225.11,18.38 v2(226.54,18.38)
COM2_SOUT: length 325.6
  TOP w0.102: U43.16 12.58,27.88 12.58,28.63 11.61,29.6 9.82,29.6 9.82,29.6 9.44,29.6 5.71,25.87 4.07,25.87 2.11,23.91 2.11,22.27 2.11,3.85 2.51,3.45 4.48,1.47 71.77,1.47 71.9,1.61 74.71,4.41 74.71,8.7 77.93,11.92 82.41,11.92 85.66,8.67 85.66,3.17 87.35,1.47 230.99,1.47 232.18,2.66 232.18,8.32 232.79,8.93 232.79,12.3 231.04,14.04 229.9,14.04 227.44,16.51 227.44,18.94 226.54,19.84 v2(226.54,19.91) ; U21.21 212.48,30.79 215.32,27.95 215.32,23.43 v2(214.41,22.51)
  BOTTOM w0.102: v2(226.54,19.91) 226.35,19.72 224.92,19.72 223.86,20.78 217.43,20.78 v1(216.8,21.42) 215.5,21.42 v2(214.41,22.51)
COM_+12V: length 471.7
  TOP w0.254: v2(77.5,113.19) 76.97,113.19 75.34,114.81 75.34,119.9 64.91,130.33 58.58,130.33 57.82,131.1 49.69,131.1 45.74,135.05 44.12,135.05 43.56,134.49 41.47,134.49 40.55,135.41 39.81,135.41 38.59,136.63 38.59,138.67 37.75,139.5 37.75,142.11 38.21,142.57 38.21,143.48 37.88,143.81 37.88,144.82 38.24,145.18 38.24,145.98 38.03,146.18 38.03,147.44 38.21,147.62 38.21,148.48 37.47,149.22 36.06,149.22 32.82,152.46 27.5,152.46 25.41,150.38 23.63,150.38 22.64,149.38 19.21,149.38 18.19,148.37 16.47,148.37 12.15,144.05 3.69,144.05 1.75,142.12 1.75,31.17 2.95,29.98 5.26,29.98 5.68,29.56 6.47,29.56 6.89,29.98 7.55,29.98 v2(7.78,29.75) ; v2(146.21,223.04) 146.21,222.12 148.11,220.22 148.11,218.63 144.94,215.46 144.37,215.46 143.87,214.96 143.87,213.82 144.18,213.52 144.18,207.42 140.24,203.49 130.84,203.49 128.81,201.45 119.98,201.45 110.14,191.61 110.14,186.34 v2(109.76,185.96) ; v2(6.7,24.67) 7.08,24.29 8.86,24.29 9.95,23.2 U43.1 ; U42.1 204.51,217.83 204.76,218.08 D29.N 206.41,218.2 v2(206.41,220.12) ; v2(96.17,182.66) 95.79,182.28 95.79,180.91 96.25,180.45 96.25,156.7 95.16,155.61 95.16,132.49 93.25,130.59 93.25,116.11 92.11,114.97 86.65,114.97 83.34,111.67 81.12,111.67 79.92,112.87 v2(79.92,113.19)
  BOTTOM w0.254: v2(7.78,29.75) 7.96,29.57 7.96,29.17 8.16,28.96 8.16,24.67 7.84,24.35 7.02,24.35 v2(6.7,24.67) ; v2(96.17,182.66) 98.99,185.48 108.85,185.48 109.33,185.96 v2(109.76,185.96) ; v2(77.5,113.19) v2(79.92,113.19) ; v2(206.41,220.12) 206.08,220.45 v1(204.35,220.45) 203.66,221.14 189.83,221.14 188.56,222.41 180.02,222.41 178.57,223.86 162.72,223.86 162.68,223.82 156.95,223.82 156.91,223.86 153.88,223.86 152.94,222.92 152.21,222.92 150.81,224.31 147.48,224.31 v2(146.21,223.04)
COM_-12V: length 464.6
  TOP w0.254: U42.10 198.66,218.02 198.35,218.33 D30.P 196.88,218.88 v2(197.39,219.39) ; v2(147.1,223.04) 147.1,221.77 148.5,220.38 148.5,218.47 145.1,215.07 144.53,215.07 144.25,214.8 144.25,213.98 144.56,213.68 144.56,207.27 140.4,203.11 131,203.11 128.97,201.07 120.14,201.07 110.52,191.46 110.52,185.71 110.01,185.2 v2(109.76,185.2) ; v2(79.79,113.95) 79.28,113.44 79.28,112.97 80.96,111.28 83.5,111.28 86.8,114.59 92.27,114.59 93.63,115.95 93.63,130.43 95.54,132.34 95.54,155.45 96.63,156.54 96.63,180.63 96.43,180.83 96.43,181.9 v2(96.93,182.4) ; U43.10 15.8,24.27 14.7,25.37 7.91,25.37 v2(7.46,25.81) ; v2(76.99,113.95) 76.81,113.95 75.72,115.04 75.72,120.05 65.06,130.72 58.74,130.72 57.98,131.48 49.85,131.48 45.85,135.48 43.86,135.48 42.91,136.43 41.48,136.43 38.13,139.78 38.13,141.95 38.59,142.41 38.59,143.64 38.26,143.97 38.26,144.66 38.62,145.02 38.62,146.13 38.41,146.34 38.41,147.28 38.59,147.46 38.59,148.64 37.63,149.6 36.22,149.6 32.98,152.85 27.21,152.85 25.12,150.76 23.47,150.76 22.48,149.77 18.96,149.77 17.94,148.75 16.19,148.75 11.87,144.43 3.53,144.43 1.37,142.27 1.37,31.01 2.79,29.6 5.1,29.6 5.56,29.14 v2(7.14,29.14)
  BOTTOM w0.254: v2(7.46,25.81) 7.65,26 7.65,28.63 v2(7.14,29.14) ; v2(197.39,219.39) 197.39,220.12 197.06,220.45 v1(196.98,220.45) 196.68,220.76 189.67,220.76 188.4,222.03 162.08,222.03 160.69,223.43 154.08,223.43 153.19,222.54 152.05,222.54 150.65,223.93 147.99,223.93 v2(147.1,223.04) ; v2(109.76,185.2) 109.51,184.94 99.47,184.94 v2(96.93,182.4) ; v2(76.99,113.95) v2(79.79,113.95)
COM_NRI_L: length 5.8
  TOP w0.102: R414.1 201.95,205.76 D14.N ; v1(201.07,207.42) 201.07,205.88 D14.N ; D14.N D15.N
COM_NRI_L_R: length 5.5
  TOP w0.102: QN45.B 203.39,202.95 R418.2 R414.2 202.83,204.15 203.18,204.5 203.18,205.57 v1(202.57,206.18)
COMP1: length 3.6
  TOP w0.178: v1(56.19,34.65) 55.9,34.36 U41.13
  TOP w0.254: v1(56.19,34.65) 56.78,35.24 C804.2 57.67,35.24 57.7,35.21 C802.2
COMP1_RC: length 1.2
  TOP w0.508: C801.1 R928.1
COMP1_RC1: length 1.1
  TOP w0.508: R929.1 C802.1
COMP2: length 3.4
  TOP w0.178: U41.9 56.18,32.76 56.55,32.39 C793.2
  TOP w0.508: C792.2 57.69,31.88 C793.2
COMP2_RC: length 2.5
  TOP w0.102: v1(59.72,27.49) 59.85,27.62 59.85,28.51 R917.1
  TOP w0.508: C791.1 58.96,28.64 R917.1
COMP2_RC2: length 1.1
  TOP w0.508: C792.1 R918.1
COPEN_L: length 394.6
  TOP w0.102: C711.1 202.44,14.57 204.5,14.57 204.77,14.85 205.35,14.85 205.48,14.98 U21.68 205.48,17.01 206.79,18.32 206.79,19.84 v2(207.04,20.1) ; v2(2.88,139.94) 2.5,139.55 2.5,59.83 3.04,59.29 7.03,59.29 7.25,59.52 8.51,59.52 10.69,61.7 12.72,61.7 13.43,62.41 16,62.41 16.8,63.22 21.5,63.22 v2(21.62,63.09) ; v2(41.18,54.64) 40.8,54.64 34.83,48.67 26.58,48.67 25.94,49.31 25.28,49.31 v2(25.03,49.05) ; D8.3 11.39,171.38 R386.2 C682.1 9.1,169.21 C_INTRUSION.2 ; v2(75.57,61.3) 74.58,62.29 69.91,62.29 67.9,64.29 60.7,64.29 59.17,62.77 51.85,62.77 49.28,60.21 v2(47.94,60.21)
  BOTTOM w0.102: v2(75.57,61.3) 77.99,58.88 77.99,45.51 79.48,44.01 79.48,40.41 79.82,40.07 79.82,40.07 80.94,38.95 82.45,38.95 88.65,32.75 88.65,31.33 93,26.98 110.66,26.98 114.01,23.63 v1(116.44,23.63) 120.89,23.63 122.87,21.65 141.9,21.65 145,18.55 155.01,18.55 156.15,17.41 167.2,17.41 167.96,18.17 178.83,18.17 180.23,19.57 190.01,19.57 192.4,17.18 199.63,17.18 202.55,20.1 v2(207.04,20.1) ; C_INTRUSION.2 4.15,169.91 1.58,167.34 1.58,153.42 4.43,150.58 4.43,145.03 4.43,145.03 4.43,144.84 4.45,144.81 5.01,144.25 5.34,143.93 5.34,141.89 5.08,141.64 3.89,141.64 3.03,140.77 3.03,140.09 v2(2.88,139.94) ; v2(21.62,63.09) 24.54,60.17 24.73,60.17 26.4,58.5 26.4,56.83 25.03,55.46 v2(25.03,49.05) ; v2(41.18,54.64) 41.36,54.46 41.94,54.46 42.68,55.2 43.31,55.2 47.94,59.82 v2(47.94,60.21)
CPU_AA35: length 6.1
  TOP w0.102: PCH1.AA35 45.99,89.38 v3(45.64,89.72)
  BOTTOM w0.102: STP14.1 44.86,85.02 44.86,86.65 44.74,86.77 44.74,88.33 45.19,88.79 45.19,89.27 v3(45.64,89.72)
CPU_AB8: length 2.6
  TOP w0.356: CPU1.AB8 v4(146.54,126.58)
  BOTTOM w0.508: SR17.1 147.92,126.04 v1(147.17,126.04) 147.07,126.04 v4(146.54,126.58)
CPU_AC35: length 4.3
  TOP w0.102: v3(44.58,89.67) 44.87,89.38 PCH1.AC35
  BOTTOM w0.102: v3(44.58,89.67) 44.58,89.61 44.17,89.21 44.17,88.63 43.97,88.44 43.97,86.82 STP13.1
CPU_AL20: length 1.6
  TOP w0.102: v4(159.71,117.43) CPU1.AL20
  BOTTOM w0.102: v4(159.71,117.43) 159.67,117.47 STP12.1
CPU_AV20: length 23.2
  TOP w0.102: TP14.1 167.09,90.96 167.09,97.87 160.71,104.25 160.71,106.66 160.47,106.9 160.47,109.26 160.17,109.57 CPU1.AV20
CPU_AW12: length 16.6
  TOP w0.102: CPU1.AW12 152.85,109.61 152.51,109.27 152.51,108.46 152.34,108.29 152.34,107.93 151.23,106.83 151.23,95.01 TP12.1
CPU_AW27: length 16.5
  TOP w0.102: CPU1.AW27 166.14,109.23 166.14,107.78 167.95,105.96 167.95,102.37 170.92,99.4 170.92,95.69 TP15.1
CPU_E16: length 2.9
  TOP w0.102: CPU1.E16 v4(153.85,141.21)
  BOTTOM w0.102: v4(153.85,141.21) 153.39,140.74 153.39,139.8 STP1.1
CPU_G38: length 25.2
  TOP w0.102: CPU1.G38 v4(176.17,139.38)
  BOTTOM w0.102: STP8.1 197.7,144.23 191.66,144.23 187.9,140.47 177.26,140.47 v4(176.17,139.38)
CPU_H37: length 28.3
  TOP w0.102: CPU1.H37 v4(176.17,138.46)
  BOTTOM w0.102: STP4.1 199.88,144 191.88,144 188.12,140.24 177.34,140.24 176.64,139.54 176.64,138.93 v4(176.17,138.46)
CPU_H38: length 23.9
  TOP w0.102: CPU1.H38 v4(177.08,138.46)
  BOTTOM w0.102: STP9.1 197.85,142.6 191.47,142.6 188.65,139.78 178.4,139.78 v4(177.08,138.46)
CPU_J12: length 1.7
  TOP w0.102: CPU1.J12 v4(151.11,137.55)
  BOTTOM w0.102: v4(151.11,137.55) 151.11,136.61 STP3.1
CPU_J38: length 26.7
  TOP w0.102: CPU1.J38 v4(177.08,137.55)
  BOTTOM w0.102: STP10.1 200.18,143.16 199.4,142.37 191.57,142.37 188.75,139.55 179.81,139.55 178.29,138.03 177.57,138.03 v4(177.08,137.55)
CPU_K11: length 1.6
  TOP w0.102: CPU1.K11 v4(149.28,137.55)
  BOTTOM w0.102: v4(149.28,137.55) 149.26,137.57 STP2.1
CPU_K37: length 27.7
  TOP w0.102: v4(176.17,136.63) CPU1.K37
  BOTTOM w0.102: STP6.1 200.18,141.89 192.9,141.89 190.11,139.1 180.21,139.1 178.18,137.07 176.6,137.07 v4(176.17,136.63)
CPU_K39: length 24.1
  TOP w0.102: v4(177.08,136.63) CPU1.K39
  BOTTOM w0.102: STP5.1 198.15,141.51 193.06,141.51 190.42,138.87 180.4,138.87 178.16,136.63 v4(177.08,136.63)
CPU_M36: length 16.8
  TOP w0.102: CPU1.M36 v4(175.25,134.8)
  BOTTOM w0.102: v4(175.25,134.8) 178.11,134.8 180.88,137.57 STP7.1
CPU_N35: length 20
  TOP w0.356: CPU1.N35 v4(174.34,132.98)
  BOTTOM w0.279: 180.68,136.77 178.33,134.41 175.78,134.41 v4(174.34,132.98)
  BOTTOM w0.508: 188.15,136.77 191.5,136.77 STP18.1 ; 188.15,136.77 180.68,136.77 ; 188.15,136.77 v1(188.14,136.76)
CPU_PECI: length 47.9
  TOP w0.102: v2(206.47,124.24) 206.78,123.93 207.91,123.93 208.31,124.33 R24.1 R27.1 ; CPU1.N37 v4(176.17,132.98)
  BOTTOM w0.102: v2(206.47,124.24) 205.9,124.24 204.27,125.86 204.27,133.87 v1(201.81,136.33) 201.56,136.58 197.92,136.58 197.03,135.69 181.19,135.69 179.14,133.64 176.83,133.64 v4(176.17,132.98)
CPU_PLTRST_L: length 388
  TOP w0.102: R19.2 205.39,137.95 206.15,137.19 206.15,136.55 207.04,135.67 209.33,135.67 216.44,128.56 219.77,128.56 R986.1 221.04,129.81 221.66,129.19 v2(223.04,129.19) ; v2(68.49,87.48) 68.49,86.98 67.83,86.32 67.83,85.31 66.39,83.88 59.49,83.88 59.01,83.4 55.88,83.4 54.3,84.98 PCH1.F41
  BOTTOM w0.102: v2(223.04,129.19) 223.04,128.84 223.68,128.2 223.68,125.16 223.68,125.15 223.68,120.81 223.81,120.68 223.81,119.16 218.09,113.44 v1(218.09,109.74) 218.09,102.52 222.16,98.46 222.16,87.54 228.07,81.62 228.07,76.41 228.28,76.21 228.28,75.13 231.45,71.96 231.45,71.71 234.75,68.41 236.33,68.41 237.94,66.8 237.94,65.25 239.12,64.07 239.12,53.96 235.62,50.45 235.62,44.13 234.3,42.81 234.3,39 233.18,37.88 233.18,33.01 229.81,29.64 225.58,29.64 223.54,27.59 211.2,27.59 205.81,22.21 201.65,22.21 200.56,21.11 198.56,21.11 197.49,20.05 194.05,20.05 193.39,20.71 191.66,20.71 190.85,21.52 179.39,21.52 177.99,20.12 166.83,20.12 166.07,19.36 157.77,19.36 156.62,20.5 151.75,20.5 148.55,23.71 126.68,23.71 125.08,25.31 123.32,25.31 122.59,26.04 120.66,26.04 118.9,27.79 112.7,27.79 111.38,29.12 93.64,29.12 90.74,32.02 90.74,33.62 86.38,37.98 86.36,37.98 82.71,41.63 82.71,46.54 80.93,48.32 80.93,52.86 83.37,55.3 83.37,58.58 84.08,59.29 84.08,74.17 85.12,75.21 85.12,75.22 86.24,76.33 86.24,84.65 80.13,90.76 77.92,90.76 75.64,88.48 70.72,88.48 69.73,87.48 v2(68.49,87.48)
CPU_PWROK: length 476.4
  TOP w0.102: v2(88.93,11.03) 88.93,11.77 85.96,14.74 85.96,19.36 89.85,23.24 89.85,32.12 88.48,33.49 88.48,43.39 89.57,44.48 89.57,45.14 90.33,45.91 90.33,47.12 88.91,48.55 v2(87.28,48.55) ; PCH1.D40 54.64,86.3 54.64,85.54 54.52,85.42 54.52,85.05 55.97,83.6 58.83,83.6 59.47,84.23 66.24,84.23 67.22,85.2 67.22,86.32 67.77,86.88 67.77,88.48 v2(68.1,88.81) ; v2(207.32,124.62) 207.04,124.9 206.18,124.9 205.95,124.67 205.95,124.67 205.26,123.98 202.6,123.98 201.9,124.68 201.04,124.68 200.34,125.38 R16.2 ; v2(235.47,133.26) 235.16,133.56 232.77,133.56 231.45,134.88 229.24,134.88 228.92,134.56 R64.2 226.89,132.11 225.05,132.11 223.93,130.99 218.42,130.99 R982.1 217.95,131.46 217.95,131.48 217.54,131.88 213.62,131.88 209.45,136.05 207.55,136.05 v2(206.79,136.81)
  BOTTOM w0.102: v2(68.1,88.81) 68.49,89.19 75.34,89.19 77.63,91.47 80.43,91.47 86.95,84.95 86.95,75.89 84.79,73.73 84.79,58.89 86.64,57.04 86.64,54.59 87.03,54.21 87.03,48.8 v2(87.28,48.55) ; v2(235.47,133.26) 234.88,132.67 234.88,132.11 235.77,131.22 235.77,129.35 235.19,128.76 235.19,123.1 235.72,122.56 235.72,117.64 234.55,116.47 233.82,116.47 224.64,107.29 224.64,100.92 225.08,100.49 225.08,92.48 226.45,91.11 226.45,87.76 230.28,83.92 230.28,75.9 235.59,70.59 237.24,70.59 241.66,66.17 241.66,50.41 241.3,50.05 241.3,48.19 241.71,47.78 241.71,28.48 v1(240.82,27.59) 239.69,26.46 239.69,18.79 230.19,9.29 230.19,6.99 229.43,6.23 228.42,6.23 227.39,5.2 226.05,5.2 225.75,4.9 223.45,4.9 221.12,2.57 116.01,2.57 113.64,4.93 111.72,4.93 110.26,6.39 105.84,6.39 103.02,3.57 92.81,3.57 88.93,7.45 v2(88.93,11.03) ; v2(206.79,136.81) 206.92,136.68 206.92,134.02 206.15,133.26 206.15,125.79 v2(207.32,124.62)
CPU_PWROK_RC: length 33.4
  TOP w0.102: CPU1.AB35 174.41,125.73 177.11,125.73 177.78,126.39 180.11,126.39 183.76,130.04 194.8,130.04 197.73,127.11 C2.1 198.27,127.47 198.27,127.49 198.45,127.67 200.79,127.67 201.3,127.16 R739.2 R16.1 201.91,125.28 v2(202.06,125.28)
CPU_RST_L_RC: length 28.9
  TOP w0.102: CPU1.M39 177.97,134.78 181.39,134.78 183.42,136.81 v2(193.2,136.81) 193.45,136.81 194.47,137.83 C3.1 197.8,137.54 198.08,137.27 199.14,137.27 199.19,137.22 199.78,137.22 199.88,137.32 201.81,137.32 202.24,137.75 202.24,138.11 202.6,138.46 203.14,138.46 R19.1
CPU_T8: length 1.6
  TOP w0.381: CPU1.T8 v4(146.54,131.15)
  BOTTOM w0.102: v4(146.54,131.15) 146.54,130.26 STP11.1
CPU_THERMTRIP_L: length 28.5
  TOP w0.102: v2(194.72,144.94) 196.63,143.03 R42.2 ; CPU1.F37 v4(175.25,140.29)
  BOTTOM w0.102: v2(194.72,144.94) v1(193.2,144.94) 191.85,144.94 187.74,140.82 175.62,140.82 175.25,140.46 v4(175.25,140.29)
CSP1_RC: length 7.5
  TOP w0.127: R931.2 R930.1 55.79,39.5 56.07,39.22 C803.2 56.4,38.06 56.4,37.4 55.63,36.63 54.82,36.63 54.57,36.38 54.37,36.38 53.92,35.93 U41.16
CSP2_RC: length 5.2
  TOP w0.127: U41.6 53.92,31.11 53.98,31.05 53.98,30.41 54.08,30.31 54.08,29.58 C790.2 54.64,29.02 54.64,28.19 R914.1 R915.2
DDC1CLK: length 17.8
  TOP w0.102: VGA.15 166.69,228.8 168.03,227.46 168.03,221.83 C710.1 168.56,221.09 166.14,218.67 U24.4 165.16,218.2 165.16,216.89 R802.1
DDC1DATA: length 26.5
  TOP w0.102: VGA.12 159.82,231.55 160.43,232.16 164.22,232.16 165.59,230.79 165.59,229.57 167.61,227.55 167.8,227.36 167.8,221.86 C707.1 166.51,220.57 U24.6 164.94,220.57 164.75,220.38 164.75,218.35 164.93,218.17 164.93,216.14 165.39,215.68 R801.1
DDIB_AUX_N: length 39.8
  TOP w0.102: R797.1 194.79,207.96 194.52,208.24 194.24,208.24 192.9,209.58 QN75.D 191.14,209.58 191.02,209.71 191.02,210.54 191.38,210.9 192.52,210.9 192.95,211.33 192.95,213.16 192.56,213.54 191.7,213.54 191.51,213.73 191.51,214.04 191.78,214.31 192.56,214.31 QN71.D 192.31,215.07 191.8,215.07 191.55,215.32 191.55,215.71 191.2,216.06 190.04,216.06 189.37,216.73 189.37,217.13 U6.1 189.37,217.57 189.37,218.32 190,218.96 190,220.78 188.82,221.97 188.82,223.68 190.09,224.95 193.14,224.95 195.25,227.06 195.25,232.66 DP2.17
DDIB_AUX_P: length 38.3
  TOP w0.102: DP2.15 195.05,232.66 195.05,227.15 193.05,225.15 190,225.15 188.61,223.76 188.61,221.88 189.8,220.7 189.8,220.07 U6.6 189.8,219.63 189.8,219.04 189.16,218.41 189.16,216.65 189.5,216.31 189.95,215.86 191.12,215.86 191.35,215.63 191.35,215.32 191.09,215.07 190.53,215.07 QN69.S 190.28,214.31 191.01,214.31 191.31,214.01 191.31,213.65 191.62,213.34 192.48,213.34 192.74,213.08 192.74,211.41 192.44,211.11 191.29,211.11 190.81,210.62 190.81,209.71 190.68,209.58 QN73.D 188.72,209.87 R794.1
DDIB_AUXN: length 270.4
  TOP w0.102: PCH1.AK6 41.98,104.63 v3(42.14,104.8) ; C702.1 194.31,205.68 194.56,205.43 194.8,205.43 v2(195.16,205.79)
  BOTTOM w0.102: v3(42.14,104.8) 42.42,104.52 42.64,104.52 42.81,104.69 42.81,105.08 42.2,105.69 42.2,113.54 41.49,114.25 41.49,115.77 40.67,116.58 40.67,117.43 38.26,119.84 38.26,121.94 32.86,127.34 32.86,178.61 33.6,179.34 33.6,179.72 36.41,182.53 37.87,182.53 39.06,183.73 40.36,183.73 41.65,185.02 43.17,185.02 44.44,183.75 45.8,183.75 46.57,184.52 46.57,185.73 47.32,186.48 48.02,186.48 49.16,187.62 49.16,188.43 50.9,190.18 55.02,190.18 57.61,192.77 58.75,192.77 59.64,193.66 63.07,193.66 64.08,194.67 65.31,194.67 65.95,195.31 65.95,196.97 71.14,202.17 100.38,202.17 101.29,203.08 108.58,203.08 111,205.49 118.08,205.49 119.86,207.27 129.41,207.27 134.92,212.78 138.38,212.78 139.7,214.1 144.06,214.1 144.62,213.54 151.87,213.54 152.89,214.56 164.78,214.56 166.33,216.11 168.36,216.11 168.94,215.53 170.49,215.53 172.55,217.58 184.09,217.58 189.19,212.49 189.19,210.99 190.34,209.84 v1(190.86,209.84) 190.86,209.31 193.53,206.64 193.53,205.98 194.05,205.47 194.84,205.47 v2(195.16,205.79)
DDIB_AUXN_C: length 4.5
  TOP w0.102: C702.2 192.89,205.43 192.14,205.43 191.93,205.64 191.93,206.03 192.18,206.28 192.82,206.28 QN75.S
DDIB_AUXP: length 270.4
  TOP w0.102: v3(42.15,104.07) 42,103.92 PCH1.AK8 ; C701.1 194.31,204.98 194.56,205.23 194.8,205.23 v2(195.16,204.87)
  BOTTOM w0.102: v2(195.16,204.87) 194.76,205.26 193.96,205.26 193.33,205.9 193.33,206.56 191.78,208.11 v1(191.24,208.11) 191.24,208.64 188.98,210.9 188.98,212.4 184,217.38 172.63,217.38 170.58,215.32 168.86,215.32 168.27,215.91 166.41,215.91 164.86,214.36 152.97,214.36 151.96,213.34 144.53,213.34 143.97,213.9 139.78,213.9 138.46,212.58 135.01,212.58 129.5,207.07 119.95,207.07 118.17,205.29 111.08,205.29 108.67,202.88 101.38,202.88 100.46,201.96 71.23,201.96 66.15,196.88 66.15,195.22 65.39,194.47 64.17,194.47 63.15,193.45 59.72,193.45 58.83,192.56 57.69,192.56 55.1,189.97 50.98,189.97 49.36,188.35 49.36,187.54 48.1,186.28 47.4,186.28 46.77,185.64 46.77,184.44 45.88,183.55 44.36,183.55 43.09,184.82 41.74,184.82 40.44,183.52 39.15,183.52 37.95,182.33 36.49,182.33 33.8,179.64 33.8,179.26 33.07,178.52 33.07,127.43 38.46,122.03 38.46,119.93 40.88,117.52 40.88,116.67 41.69,115.86 41.69,114.33 42.4,113.62 42.4,105.77 43.01,105.16 43.01,104.6 42.72,104.32 42.39,104.32 v3(42.15,104.07)
DDIB_AUXP_C: length 4.7
  TOP w0.102: C701.2 192.89,205.23 192.06,205.23 191.73,205.56 191.73,206.13 191.5,206.36 190.96,206.36 QN73.S
DDIB_CTRLCLK: length 259.1
  TOP w0.102: v3(38.72,110.29) 39.07,110.29 39.43,109.94 39.43,109.35 40.25,108.53 PCH1.AM1 ; v2(188.37,217.71) 187.52,216.85 R786.1 187.52,213.77 QN69.D
  BOTTOM w0.102: v3(38.72,110.29) 38.46,110.55 38.46,112.53 38.89,112.96 38.89,116.82 36.56,119.16 36.56,122.31 31.92,126.95 31.92,179.06 32.66,179.8 32.66,179.98 32.66,182.61 35.77,185.72 35.77,186.65 36.71,187.59 37.92,187.59 39.16,188.83 40.48,188.83 41.79,190.14 43.06,190.14 44.28,188.92 45.87,188.92 48.47,191.52 53.79,191.52 56.85,194.59 56.85,195.88 57.8,196.83 58.53,196.83 59.47,197.77 63.24,197.77 64.26,198.79 66.31,198.79 70.68,203.16 99.4,203.16 101.18,204.93 104.45,204.93 104.91,204.48 108.34,204.48 111.13,207.27 114.31,207.27 116.62,209.58 130.32,209.58 134.48,213.75 137.88,213.75 141.13,217 150.22,217 151.9,218.68 157.98,218.68 158.85,217.8 162.41,217.8 163.81,219.21 168.76,219.21 169.27,218.7 184.89,218.7 v1(185.25,219.06) 185.6,218.7 187.38,218.7 v2(188.37,217.71)
DDIB_CTRLDATA: length 284.5
  TOP w0.089: 39.92,108.23 39.92,107.47 40.29,107.09 40.37,107.09 40.63,106.84 40.63,106.84 40.67,106.79 40.67,106.59
  TOP w0.102: v3(39.02,109.74) 39.02,109.43 39.63,108.82 39.63,108.52 39.92,108.23 ; QN71.S 193.83,211.79 194.69,210.93 R791.1 194.98,211.14 194.98,213.14 194.47,213.65 v2(193.83,213.65) ; 40.67,106.59 40.67,106.19 40.91,105.96 41.08,105.96 41.67,105.36 PCH1.AJ5
  BOTTOM w0.102: v3(39.02,109.74) 39.28,109.99 39.28,110.4 38.72,110.95 38.72,112.46 39.12,112.87 39.12,116.91 36.79,119.25 36.79,122.41 32.15,127.05 32.15,178.96 32.89,179.7 32.89,180.08 32.89,182.52 36,185.63 36,186.55 36.81,187.36 38.01,187.36 39.26,188.6 40.58,188.6 41.89,189.91 42.96,189.91 44.18,188.69 47.38,188.69 49.92,191.24 53.83,191.24 57.08,194.49 57.08,195.79 57.9,196.6 58.62,196.6 59.56,197.54 63.34,197.54 64.35,198.56 66.41,198.56 70.78,202.93 99.61,202.93 101.39,204.71 104.27,204.71 104.73,204.25 108.59,204.25 111.39,207.04 114.46,207.04 116.77,209.35 130.41,209.35 134.58,213.52 137.98,213.52 141.15,216.69 150.27,216.69 152.03,218.45 157.88,218.45 158.77,217.56 163.15,217.56 v1(163.63,218.04) 164.57,218.98 168.61,218.98 169.12,218.47 186.93,218.47 arc(187.17,218.23) 186.93,217.99 185.88,217.99 arc(185.64,217.75) 185.88,217.51 187.7,217.51 arc(187.94,217.27) 187.7,217.02 186.84,217.02 arc(186.6,216.78) 186.84,216.54 189.61,216.54 192.55,213.59 arc(192.89,213.59) 192.89,213.94 190.05,216.78 arc(190.05,217.12) 190.39,217.12 193.83,213.68 v2(193.83,213.65)
DDIB_N0_C: length 4.5
  TOP w0.102: CMK33.4 181.56,223.11 181.24,222.79 181.24,221.8 181.12,221.69 181.12,219.98 C100.2
DDIB_N0_R: length 11.5
  TOP w0.102: DP2.3 186.54,232.66 186.54,232.39 185.45,231.3 183.55,231.3 181.77,229.52 181.77,228.92 181.9,228.78 U4.9 U4.2 181.9,227.09 181.72,226.91 181.72,226.7 181.34,226.32 181.34,226.12 181.62,225.84 RN43.4
DDIB_N1_C: length 2.4
  TOP w0.102: C102.2 182.82,222.09 182.82,222.31 182.96,222.45 182.96,222.82 183.24,223.1 RN43.7
DDIB_N1_R: length 13.3
  TOP w0.102: RN43.8 183.24,225.81 183.01,226.04 183.01,226.19 183.24,226.42 183.24,226.96 183.4,227.12 U4.5 U4.6 183.4,228.89 183.29,229 183.29,229.52 184.31,230.54 185.75,230.54 186.77,231.55 188.03,231.55 188.96,232.49 188.96,233.86 189.15,234.06 DP2.6
DDIB_N2_C: length 4.5
  TOP w0.102: CMK35.4 185.24,222.9 184.93,222.59 184.93,221.47 184.51,221.06 184.51,219.89 C98.2
DDIB_N2_R: length 12
  TOP w0.102: DP2.9 190.39,232.66 190.39,231.92 189.27,230.79 187.23,230.79 186.21,229.78 185.45,229.78 185.06,229.38 185.06,228.92 185.21,228.77 U5.9 U5.2 185.21,227.01 185.07,226.88 185.07,226.73 184.92,226.58 184.92,226.16 185.24,225.84 CMK35.3
DDIB_N3_C: length 2.4
  TOP w0.102: RN44.7 186.93,223.13 186.62,222.82 186.62,222.54 186.76,222.4 186.76,222.09 C105.2
DDIB_N3_R: length 12.6
  TOP w0.102: CMK36.3 187.02,225.77 186.67,226.12 186.67,226.43 186.54,226.56 186.54,226.85 186.71,227.02 U5.5 U5.6 186.71,228.77 186.56,228.92 186.56,229.1 187.48,230.03 189.52,230.03 191.93,232.44 191.93,233.69 DP2.12
DDIB_P0_C: length 4.4
  TOP w0.102: CMK33.1 180.71,223.19 181.03,222.87 181.03,221.88 180.92,221.77 180.92,219.88 C101.2
DDIB_P0_R: length 11.5
  TOP w0.102: RN43.2 180.8,225.79 181.13,226.12 181.13,226.41 181.52,226.79 181.52,226.96 181.4,227.07 U4.1 U4.10 181.4,228.76 181.57,228.92 181.57,229.61 183.46,231.5 185.37,231.5 186.34,232.47 186.34,232.66 DP2.1
DDIB_P1_C: length 2.4
  TOP w0.102: RN43.5 182.43,223.1 182.76,222.77 182.76,222.54 182.62,222.4 182.62,222.09 C103.2
DDIB_P1_R: length 13.3
  TOP w0.102: DP2.4 188.75,233.6 188.75,232.57 187.94,231.76 186.68,231.76 185.67,230.74 184.23,230.74 183.09,229.61 183.09,229.07 182.9,228.89 U4.7 U4.4 182.9,227.12 183.04,226.98 183.04,226.51 182.81,226.28 182.81,226.12 182.43,225.74 RN43.6
DDIB_P2_C: length 4.6
  TOP w0.102: C99.2 184.31,219.96 184.31,221.14 184.73,221.56 184.73,222.61 184.39,222.95 CMK35.1
DDIB_P2_R: length 12
  TOP w0.102: DP2.7 190.19,232.66 190.19,232 189.18,230.99 187.15,230.99 186.13,229.98 185.37,229.98 184.85,229.47 184.85,228.92 184.71,228.77 U5.10 U5.1 184.71,227.06 184.87,226.9 184.87,226.81 184.72,226.66 184.72,226.11 184.39,225.79 CMK35.2
DDIB_P3_C: length 2.4
  TOP w0.102: RN44.5 186.11,223.17 186.42,222.87 186.42,222.46 186.56,222.32 186.56,222.09 C104.2
DDIB_P3_R: length 12.6
  TOP w0.102: CMK36.2 186.17,225.86 186.47,226.16 186.47,226.35 186.34,226.47 186.34,226.88 186.21,227.01 U5.4 U5.7 186.21,228.77 186.35,228.92 186.35,229.19 187.4,230.23 189.43,230.23 191.73,232.53 191.73,233.63 DP2.10
DDIB_TX_N0: length 147
  TOP w0.102: v2(181.57,214.86) 181.49,214.86 181.16,215.2 181.16,218.02 181.64,218.5 C100.1 ; v4(154.77,140.29) CPU1.F17
  BOTTOM w0.102: v4(154.77,140.29) 154.31,140.75 154.31,143.41 153.94,143.78 153.94,144.32 152.61,145.65 152.61,146.64 147.16,152.09 133.5,152.09 124.65,160.94 124.65,166.12 122.64,168.13 122.64,169.58 v1(122.28,169.93) 122.64,170.29 122.64,177.17 123.37,177.91 123.37,191.66 137.31,205.59 139.06,205.59 141.33,207.86 165.12,207.86 173.26,216.01 180.96,216.01 181.31,215.66 181.31,215.12 v2(181.57,214.86)
DDIB_TX_N1: length 153.6
  TOP w0.102: v2(183.14,215.84) 183.14,215.84 182.82,216.16 182.82,220.19 C102.1 ; v4(155.67,139.38) 156.13,139.83 CPU1.G18
  BOTTOM w0.102: v4(155.67,139.38) 155.96,139.67 156.09,139.67 156.37,139.95 156.37,140.75 155.22,141.89 155.22,143.42 155.47,143.66 155.47,144.83 154.34,145.96 154.34,146.08 154.34,146.34 153.64,147.03 153.48,147.03 152.97,147.54 147.53,152.98 133.91,152.98 125.58,161.31 125.58,166.49 124.21,167.86 124.21,174 123.58,174.63 123.58,175.01 v1(123.93,175.37) 123.58,175.72 123.58,176.3 124.26,176.99 124.26,191.27 137.68,204.68 139.4,204.68 141.7,206.98 167.61,206.98 169.7,209.07 169.7,211.19 173.56,215.04 178.85,215.04 180.86,213.04 182.21,213.04 182.79,213.61 182.79,215.48 v2(183.14,215.84)
DDIB_TX_N2: length 152.1
  TOP w0.102: v2(184.77,213.89) 184.46,214.2 184.46,218.02 C98.1 ; CPU1.H19 v4(157.51,139.38)
  BOTTOM w0.102: v2(184.77,213.89) 184.41,213.54 184.41,213.23 183.5,212.33 180.55,212.33 178.72,214.15 173.64,214.15 170.47,210.98 170.47,208.69 168.06,206.29 141.99,206.29 139.67,203.97 137.95,203.97 124.98,190.99 124.98,168.11 126.27,166.82 126.27,161.63 134.15,153.75 148.02,153.75 150.61,151.16 v1(151.14,151.16) 151.14,150.64 151.53,150.25 152.21,150.25 153.33,149.13 153.83,149.13 156.32,146.64 156.32,143.8 156.49,143.62 156.49,141.45 156.95,140.99 156.95,140.16 157.15,139.96 157.15,139.73 v4(157.51,139.38)
DDIB_TX_N3: length 156.7
  TOP w0.102: CPU1.G20 v4(158.42,140.29) ; v2(184.18,210.98) 184.51,211.31 185.3,211.31 185.76,211.77 185.76,216.58 186.85,217.68 186.85,220.28 C105.1
  BOTTOM w0.102: v2(184.18,210.98) 184.18,211.26 184,211.44 180.42,211.44 178.47,213.39 173.84,213.39 171.23,210.78 171.23,208.34 168.49,205.6 142.28,205.6 139.96,203.28 138.26,203.28 125.74,190.76 125.74,168.37 126.99,167.12 126.99,161.88 134.43,154.44 141.66,154.44 142.35,155.12 144.71,155.12 v1(145.07,155.48) 145.42,155.12 148.98,155.12 157,147.1 157,145.07 157.49,144.58 157.49,143.96 157.05,143.52 157.05,141.85 158.08,140.83 158.08,140.52 158.3,140.29 v4(158.42,140.29)
DDIB_TX_P0: length 147
  TOP w0.102: v4(154.77,141.21) CPU1.E17 ; C101.1 180.96,218.05 180.96,215.37 180.45,214.86 v2(180.44,214.86)
  BOTTOM w0.102: v2(180.44,214.86) 180.44,214.45 180.58,214.31 180.98,214.31 181.11,214.43 181.11,215.58 180.88,215.81 173.35,215.81 165.2,207.66 141.41,207.66 139.14,205.39 137.4,205.39 123.58,191.57 123.58,177.82 122.84,177.09 122.84,171.97 v1(123.2,171.61) 122.84,171.25 122.84,168.21 124.85,166.2 124.85,161.02 133.58,152.29 147.25,152.29 152.81,146.73 152.81,145.74 154.15,144.4 154.15,143.86 154.51,143.49 154.51,141.28 154.59,141.21 v4(154.77,141.21)
DDIB_TX_P1: length 153.6
  TOP w0.102: C103.1 182.62,220.19 182.62,216.23 v2(182.23,215.84) ; CPU1.F18 v4(155.68,140.29)
  BOTTOM w0.102: v2(182.23,215.84) 182.45,215.84 182.58,215.7 182.58,213.7 182.13,213.24 180.94,213.24 178.93,215.25 173.47,215.25 169.5,211.28 169.5,209.16 167.52,207.18 141.61,207.18 139.32,204.88 137.59,204.88 124.06,191.35 124.06,177.07 123.37,176.38 123.37,174.55 124.01,173.91 124.01,173.64 v1(123.65,173.29) 124.01,172.93 124.01,167.77 125.38,166.4 125.38,161.22 133.83,152.78 147.45,152.78 152.83,147.4 153.4,146.83 153.56,146.83 154.13,146.25 154.13,146.17 154.13,146.17 154.13,145.87 155.26,144.74 155.26,143.74 155.02,143.5 155.02,141.81 156.17,140.66 156.17,140.03 156,139.87 155.79,139.87 155.68,139.98 v4(155.68,140.29)
DDIB_TX_P2: length 152.1
  TOP w0.102: C99.1 184.26,218.05 184.26,214.3 v2(183.85,213.89) ; CPU1.G19 v4(156.6,139.38)
  BOTTOM w0.102: v4(156.6,139.38) 156.95,139.73 156.95,139.88 156.75,140.08 156.75,140.91 156.29,141.36 156.29,143.54 156.12,143.71 156.12,146.56 153.75,148.93 153.25,148.93 152.76,149.41 v1(152.25,149.41) 152.25,149.92 152.13,150.04 151.44,150.04 147.94,153.55 134.06,153.55 126.07,161.55 126.07,166.73 124.77,168.03 124.77,191.07 137.87,204.17 139.59,204.17 141.91,206.49 167.98,206.49 170.26,208.78 170.26,211.07 173.55,214.36 178.81,214.36 180.63,212.53 183.42,212.53 184.21,213.32 184.21,213.54 v2(183.85,213.89)
DDIB_TX_P3: length 156.7
  TOP w0.102: C104.1 186.44,220.66 186.65,220.45 186.65,217.76 185.55,216.67 185.55,211.85 185.22,211.51 184.49,211.51 184.18,211.82 v2(184.18,211.89) ; v4(157.52,140.29) 157.52,140.3 157.97,140.75 CPU1.F20
  BOTTOM w0.102: v4(157.52,140.29) 157.87,140.64 157.87,140.74 156.85,141.76 156.85,143.6 157.29,144.04 157.29,144.49 156.8,144.98 156.8,147.01 148.89,154.92 147.12,154.92 v1(146.77,154.57) 146.41,154.92 142.43,154.92 141.75,154.24 135.91,154.24 134.35,154.24 126.78,161.8 126.78,167.03 125.53,168.28 125.53,190.85 138.17,203.49 139.87,203.49 142.19,205.81 168.41,205.81 171.03,208.42 171.03,210.86 173.76,213.6 178.55,213.6 180.51,211.64 183.93,211.64 v2(184.18,211.89)
DDIC_AUX_N: length 29.7
  TOP w0.102: R89.1 222.5,213.04 QN13.D 220.5,213.52 220.25,213.77 220.25,214.54 220.63,214.92 221.78,214.92 222.13,215.26 222.13,216.88 221.73,217.28 221.02,217.28 220.83,217.46 220.83,217.63 221.06,217.86 221.55,217.86 QN9.D 221.65,218.73 220.99,218.73 220.87,218.85 220.87,218.93 221.37,219.43 221.37,219.8 U3.1 221.37,220.23 221.37,220.8 222.01,221.43 222.01,223.24 220.19,225.06 220.19,230.73 219.45,231.46 219.45,232.66 DP1.17
DDIC_AUX_P: length 28.8
  TOP w0.102: DP1.15 219.25,232.66 219.25,231.38 219.98,230.64 219.98,224.98 221.8,223.16 221.8,222.73 U3.6 221.8,222.3 221.8,221.52 221.17,220.88 221.17,219.52 220.64,218.98 220.64,218.86 220.5,218.73 219.74,218.73 QN7.S 219.84,217.86 220.4,217.86 220.63,217.63 220.63,217.38 220.94,217.08 221.65,217.08 221.93,216.8 221.93,215.35 221.7,215.12 220.55,215.12 220.05,214.62 220.05,213.77 219.79,213.52 QN12.D 217.93,213.93 R87.1
DDIC_AUXN: length 279.3
  TOP w0.102: C94.1 221.37,208.85 221.16,208.65 221.16,208.24 220.81,207.88 219.78,207.88 v2(219.47,207.58) ; v3(43.47,104.3) 43.23,104.54 43.02,104.54 42.84,104.36 PCH1.AG7
  BOTTOM w0.102: v2(219.47,207.58) 219.17,207.88 218.79,207.88 217.46,209.22 217.46,212 215.48,213.98 206.74,213.98 200.69,207.93 200.35,207.93 197.77,205.36 v1(197.77,204.83) 197.25,204.83 196.2,203.79 194.04,203.79 187.92,209.91 187.92,212.42 183.67,216.67 173.06,216.67 164.75,208.36 141.05,208.36 138.77,206.08 135.54,206.08 129.09,199.63 118.31,199.63 116.28,201.66 112.92,201.66 110.53,199.27 106.48,199.27 103.66,196.45 97.94,196.45 96.14,198.25 87.04,198.25 85.16,196.37 84.36,196.37 83.47,195.49 80.3,195.49 79.28,194.47 77.93,194.47 75.72,192.26 75.72,191.32 73.01,188.6 73.01,185.27 69.04,181.31 69.04,178.72 69.86,177.91 69.86,176.91 59.7,166.75 59.7,156.43 60.36,155.77 60.36,153.96 59.7,153.3 59.7,142.21 55.35,137.87 55.35,136.76 52.03,133.43 52.03,133.43 49.18,130.58 49.18,124.71 46.59,122.12 46.59,119.33 46.08,118.82 46.08,118.31 45.8,118.03 45.8,113.97 43.72,111.89 43.72,105.82 44.03,105.52 44.03,105.15 44.03,104.98 43.47,104.42 v3(43.47,104.3)
DDIC_AUXN_C: length 3.9
  TOP w0.102: v1(222.56,209.8) C94.2 221.34,209.8 221.22,209.93 221.22,210.14 221.47,210.4 222.21,210.4 QN13.S
DDIC_AUXP: length 279.2
  TOP w0.102: v2(219.47,208.49) 219.47,208.28 219.67,208.08 220.72,208.08 220.96,208.32 220.96,208.74 220.85,208.85 C93.1 ; PCH1.AG6 43.04,104.74 43.27,104.74 43.47,104.93 v3(43.47,105.06)
  BOTTOM w0.102: v2(219.47,208.49) 219.47,208.35 219.21,208.08 218.88,208.08 217.66,209.3 217.66,212.08 215.56,214.18 206.65,214.18 200.61,208.13 200.26,208.13 198.74,206.61 v1(198.23,206.61) 198.23,206.1 196.12,203.99 194.12,203.99 188.12,210 188.12,212.5 183.75,216.87 172.97,216.87 164.67,208.57 140.97,208.57 138.68,206.28 135.46,206.28 129.01,199.83 118.4,199.83 116.36,201.86 112.83,201.86 110.45,199.47 106.4,199.47 103.58,196.65 98.03,196.65 96.22,198.46 86.95,198.46 85.07,196.58 84.28,196.58 83.39,195.69 80.21,195.69 79.2,194.67 77.85,194.67 75.52,192.34 75.52,191.4 72.8,188.69 72.8,185.36 68.84,181.4 68.84,178.64 69.65,177.82 69.65,177 59.49,166.84 59.49,156.34 60.15,155.68 60.15,154.05 59.49,153.39 59.49,142.3 55.15,137.95 55.15,136.85 51.82,133.52 51.82,133.51 48.98,130.67 48.98,124.8 46.39,122.21 46.39,119.41 45.88,118.9 45.88,118.4 45.6,118.12 45.6,114.05 43.52,111.97 43.52,105.74 43.82,105.43 43.82,105.06 43.7,104.93 43.59,104.93 v3(43.47,105.06)
DDIC_AUXP_C: length 3.9
  TOP w0.102: QN12.S 220.2,210.4 220.76,210.4 221.01,210.14 221.01,209.93 220.89,209.8 C93.2 v1(219.46,209.8)
DDIC_CTRLCLK: length 294.6
  TOP w0.102: v2(218.73,219.77) R77.1 217.58,217.84 QN7.D ; PCH1.AN3 39.33,106.6 39.33,107.76 39,108.09 39,108.49 38.64,108.85 38.16,108.85 37.45,109.56 v3(37.45,110.4)
  BOTTOM w0.102: v3(37.45,110.4) 38.01,110.95 38.01,112.72 38.41,113.13 38.41,116.58 35.24,119.75 35.24,122.92 31.47,126.69 31.47,179.25 32.2,179.98 32.2,182.89 35.31,186.01 35.31,187.98 36.98,189.64 38.06,189.64 39.38,190.96 40.72,190.96 41.98,192.22 42.84,192.22 44.11,190.95 47.19,190.95 48.27,192.03 51.54,192.03 52.23,192.72 52.23,194.7 53.42,195.89 54.88,195.89 58.61,199.63 66.51,199.63 70.49,203.61 99.1,203.61 100.88,205.39 104.66,205.39 105.11,204.93 108.12,204.93 110.92,207.73 114.09,207.73 117.29,210.93 120.16,210.93 121,210.09 130.18,210.09 134.29,214.21 137.69,214.21 140.94,217.46 149.73,217.46 151.75,219.47 158.55,219.47 159.27,218.75 162.54,218.75 163.48,219.69 168.99,219.69 169.45,219.23 176.18,219.23 177.4,220.45 187.28,220.45 188.25,219.49 191.17,219.49 192.89,217.76 196.35,217.76 v1(196.68,218.09) 214.79,218.09 216.47,219.77 v2(218.73,219.77)
DDIC_CTRLDATA: length 320.1
  TOP w0.089: 39.68,108.13 39.73,108.09 39.73,107.34 39.94,107.12 39.94,107.09
  TOP w0.102: v2(223.55,214.66) 223.93,215.04 223.93,215.55 224.44,216.06 R83.1 224.28,216.31 223.3,216.31 QN9.S ; PCH1.AM2 39.94,107.09 ; 39.68,108.13 39.4,108.41 39.4,108.69 v3(38.36,109.74)
  BOTTOM w0.102: v3(38.36,109.74) 38.23,109.86 38.23,112.62 38.64,113.03 38.64,116.75 36.33,119.06 36.33,122.22 31.69,126.86 31.69,179.15 32.43,179.89 32.43,182.8 35.54,185.91 35.54,186.74 36.62,187.81 37.82,187.81 39.07,189.06 40.39,189.06 41.7,190.37 43.15,190.37 44.37,189.15 45.74,189.15 48.37,191.78 51.67,191.78 52.46,192.56 52.46,194.55 53.55,195.64 54.95,195.64 58.6,199.3 66.5,199.3 70.59,203.38 99.24,203.38 101.02,205.16 104.55,205.16 105.01,204.71 108.22,204.71 111.01,207.5 114.19,207.5 117.39,210.7 120.07,210.7 120.9,209.86 130.27,209.86 134.39,213.98 137.79,213.98 141.04,217.23 149.87,217.23 151.88,219.24 158.45,219.24 159.17,218.52 162.64,218.52 163.55,219.44 168.89,219.44 169.35,218.98 177.88,218.98 178.7,219.79 v1(181.74,219.79) 187.18,219.79 187.74,219.23 191.1,219.23 192.9,217.43 215.07,217.43 215.81,216.69 220.52,216.69 arc(220.76,216.45) 220.52,216.21 209.51,216.21 arc(209.27,215.97) 209.51,215.73 222.49,215.73 v2(223.55,214.66)
DDIC_N0_C: length 2.4
  TOP w0.102: CMK1.4 209.25,216.89 208.92,216.57 208.92,216.26 208.72,216.06 208.72,215.75 C86.2
DDIC_N0_R: length 16.1
  TOP w0.102: DP1.3 210.73,232.65 210.73,232.32 211.87,231.17 211.87,226.14 209.3,223.57 209.3,222.82 209.46,222.66 U1.9 U1.2 209.46,220.89 209.28,220.7 209.28,220.58 208.99,220.29 208.99,219.84 209.25,219.58 CMK1.3
DDIC_N1_C: length 4.5
  TOP w0.102: CMK2.4 210.9,216.76 210.57,216.44 210.57,215.09 210.76,214.9 210.76,213.58 C88.2
DDIC_N1_R: length 16.5
  TOP w0.102: DP1.6 213.14,233.7 213.14,232.06 212.58,231.5 212.58,225.55 210.83,223.79 210.83,223.03 210.96,222.89 U1.6 U1.5 210.96,220.99 210.8,220.83 210.8,220.28 210.54,220.01 210.54,219.81 210.9,219.44 CMK2.3
DDIC_N2_C: length 2.3
  TOP w0.102: C90.2 212.86,215.67 212.86,216.44 213.26,216.84 CMK3.4
DDIC_N2_R: length 15.1
  TOP w0.102: DP1.9 214.54,232.61 214.54,232.07 213.42,230.94 213.42,223.77 213.16,223.52 213.16,222.92 213.27,222.81 U2.9 U2.2 213.27,220.77 213.11,220.61 213.11,220.38 212.94,220.2 212.94,220.01 213.24,219.7 RN2.4
DDIC_N3_C: length 4.9
  TOP w0.102: CMK4.4 214.88,216.81 214.56,216.49 214.56,216.26 215.17,215.65 v1(215.2,215.65) 214.83,215.28 214.83,213.58 C91.2
DDIC_N3_R: length 16.3
  TOP w0.102: DP1.12 216.38,234.06 216.1,233.78 216.1,232.36 214.38,230.64 214.38,223.94 214.66,223.66 214.66,222.85 214.77,222.74 U2.6 U2.5 214.77,220.96 214.61,220.8 214.61,220.13 214.87,219.87 RN2.8
DDIC_P0_C: length 2.4
  TOP w0.102: CMK1.1 208.4,216.87 208.72,216.54 208.72,216.35 208.52,216.14 208.52,215.72 C85.2
DDIC_P0_R: length 16.1
  TOP w0.102: DP1.1 210.52,232.68 210.52,232.23 211.67,231.09 211.67,226.22 209.1,223.65 209.1,222.84 208.96,222.7 U1.10 U1.1 208.96,220.89 209.07,220.77 209.07,220.67 208.78,220.37 208.78,219.96 208.4,219.58 CMK1.2
DDIC_P1_C: length 4.5
  TOP w0.102: C87.2 210.56,213.58 210.56,214.82 210.37,215.01 210.37,216.49 210.05,216.81 CMK2.1
DDIC_P1_R: length 16.5
  TOP w0.102: DP1.4 212.82,233.74 212.82,233.73 212.94,233.62 212.94,232.15 212.38,231.59 212.38,225.63 210.62,223.88 210.62,222.92 210.46,222.76 U1.7 U1.4 210.46,220.99 210.6,220.85 210.6,220.36 210.33,220.09 210.33,219.79 210.05,219.51 CMK2.2
DDIC_P2_C: length 2.3
  TOP w0.102: C89.2 212.66,215.8 212.66,216.64 212.41,216.89 CMK3.1
DDIC_P2_R: length 15.1
  TOP w0.102: DP1.7 214.05,233.06 214.34,232.77 214.34,232.15 213.21,231.03 213.21,223.86 212.96,223.6 212.96,222.92 212.77,222.73 U2.10 U2.1 212.77,220.79 212.91,220.66 212.91,220.46 212.73,220.28 212.73,219.97 212.43,219.67 RN2.2
DDIC_P3_C: length 4.9
  TOP w0.102: C92.2 214.62,213.58 214.62,213.81 v1(214.28,214.15) 214.62,214.5 214.62,215.91 214.36,216.18 214.36,216.54 214.03,216.87 CMK4.1
DDIC_P3_R: length 16.3
  TOP w0.102: RN2.6 214.05,219.74 214.41,220.1 214.41,220.83 214.27,220.96 U2.4 U2.7 214.27,222.69 214.46,222.87 214.46,223.58 214.18,223.86 214.18,230.72 215.9,232.44 215.9,233.66 DP1.10
DDIC_TX_N0: length 163.9
  TOP w0.102: C86.1 208.72,213.83 208.72,213.39 208.85,213.27 v2(209.07,213.27) ; v4(157.51,142.12) CPU1.E19
  BOTTOM w0.102: v2(209.07,213.27) 208.67,212.86 208.67,210.7 207.55,209.58 205.68,209.58 199.13,203.03 193.53,203.03 189.01,207.55 182,207.55 180.63,206.18 v1(180.63,205.65) 180.09,205.65 179.31,204.86 179.31,204.21 177.26,202.17 143.69,202.17 141.3,199.77 139.78,199.77 131.55,191.54 131.55,189.49 129.19,187.13 129.19,169.98 130.42,168.75 130.42,163.45 134.93,158.93 146.18,158.93 157.56,147.55 157.56,145.39 158.05,144.9 158.05,143.8 158.3,143.55 158.3,142.71 157.71,142.12 v4(157.51,142.12)
DDIC_TX_N1: length 161.4
  TOP w0.102: C88.1 210.99,212.15 210.78,211.94 210.78,211.31 210.98,211.11 v2(211.11,211.11) ; CPU1.D20 157.97,142.7 158.17,142.91 158.28,142.91 158.53,143.16 158.53,143.77 157.84,144.45 157.84,144.91 158.11,145.18 v4(158.56,145.18)
  BOTTOM w0.102: v2(211.11,211.11) 210.83,210.83 210.83,210.5 209.13,208.8 206.03,208.8 199.53,202.29 193.22,202.29 189.05,206.46 183.27,206.46 181.36,204.55 180.91,204.55 177.83,201.48 143.98,201.48 141.54,199.04 140.86,199.04 134.7,192.89 134.7,192.61 133.38,191.29 v1(133.38,190.76) 132.85,190.76 132.42,190.33 132.42,189.31 129.88,186.77 129.88,170.27 131.11,169.04 131.11,163.81 135.3,159.62 146.58,159.62 158.12,148.08 158.12,146.44 158.56,146 v4(158.56,145.18)
DDIC_TX_N2: length 164.7
  TOP w0.102: CPU1.E21 v4(159.34,142.12) ; C90.1 212.77,213.82 212.77,213.3 v2(213.06,213.01)
  BOTTOM w0.102: v2(213.06,213.01) 212.71,212.66 212.71,210.4 210.34,208.03 206.42,208.03 199.91,201.53 192.96,201.53 188.72,205.77 184.31,205.77 180.93,202.39 v1(180.93,201.86) 180.4,201.86 179.33,200.79 144.26,200.79 141.77,198.3 141.19,198.3 135.59,192.71 135.59,191.27 130.56,186.24 130.56,170.55 131.79,169.32 131.79,164.13 135.62,160.31 146.91,160.31 158.68,148.53 158.68,146.6 159.23,146.06 159.23,143.97 158.96,143.7 158.96,142.5 v4(159.34,142.12)
DDIC_TX_N3: length 163.9
  TOP w0.102: C91.1 215.01,212.15 214.83,211.97 214.83,211.04 214.96,210.91 v2(215.18,210.91) ; CPU1.D22 159.8,142.59 159.33,143.06 159.33,145.77 159.53,145.98 159.53,146.43 v4(159.24,146.72)
  BOTTOM w0.102: v4(159.24,146.72) 159.52,147 159.81,147 160.08,147.27 160.08,148.14 147.2,161.02 135.9,161.02 132.48,164.44 132.48,169.61 131.25,170.84 131.25,185.94 136.28,190.96 136.28,192.34 141.49,197.54 141.98,197.54 144.55,200.11 181.12,200.11 183.99,202.98 v1(184.49,202.98) 184.49,203.48 186.07,205.06 188.42,205.06 192.67,200.81 200.21,200.81 206.75,207.35 212.12,207.35 214.9,210.13 214.9,210.63 v2(215.18,210.91)
DDIC_TX_P0: length 163.9
  TOP w0.102: v2(208.16,213.27) 208.44,213.27 208.52,213.34 208.52,213.85 208.06,214.31 C85.1 ; v4(157.51,143.03) CPU1.D19
  BOTTOM w0.102: v4(157.51,143.03) 157.51,142.81 157.69,142.63 157.93,142.63 158.1,142.79 158.1,143.47 157.85,143.71 157.85,144.82 157.36,145.31 157.36,147.47 146.1,158.73 134.85,158.73 130.22,163.36 130.22,168.67 128.99,169.9 128.99,187.21 131.35,189.58 131.35,191.62 139.7,199.97 141.21,199.97 143.61,202.37 177.17,202.37 179.1,204.3 179.1,204.94 181.06,206.9 v1(181.06,207.4) 181.56,207.4 181.91,207.75 189.09,207.75 193.61,203.23 199.04,203.23 205.59,209.79 207.47,209.79 208.46,210.78 208.46,213.2 208.35,213.32 208.21,213.32 v2(208.16,213.27)
DDIC_TX_P1: length 161.5
  TOP w0.102: CPU1.C20 157.97,143.21 158.07,143.11 158.19,143.11 158.33,143.25 158.33,143.68 157.64,144.37 157.64,145 158.12,145.48 158.12,145.62 v4(158.02,145.72) ; v2(210.19,211.11) 210.29,211.11 210.57,211.39 210.57,211.89 210.31,212.15 C87.1
  BOTTOM w0.102: v2(210.19,211.11) 210.32,211.23 210.45,211.23 210.62,211.06 210.62,210.58 209.04,209 205.95,209 199.45,202.5 193.3,202.5 189.14,206.66 183.18,206.66 181.28,204.76 180.82,204.76 177.75,201.68 143.89,201.68 141.46,199.25 140.78,199.25 134.5,192.97 134.5,192.7 134.32,192.51 v1(133.81,192.51) 133.81,192.01 132.21,190.41 132.21,189.4 129.67,186.86 129.67,170.18 130.9,168.95 130.9,163.72 135.21,159.42 146.49,159.42 157.92,147.99 157.92,146.35 158.27,146 158.27,145.78 158.22,145.72 v4(158.02,145.72)
DDIC_TX_P2: length 164.7
  TOP w0.102: v4(158.42,142.12) CPU1.D21 ; v2(212.15,213.01) 212.57,213.43 212.57,213.87 C89.1
  BOTTOM w0.102: v2(212.15,213.01) 212.5,212.66 212.5,210.48 210.26,208.24 206.33,208.24 199.83,201.73 193.05,201.73 188.81,205.98 184.23,205.98 181.84,203.59 v1(181.36,203.59) 181.36,203.11 179.25,201 144.18,201 141.69,198.51 141.1,198.51 135.39,192.79 135.39,191.35 130.36,186.32 130.36,170.47 131.59,169.24 131.59,164.05 135.53,160.1 146.82,160.1 158.48,148.45 158.48,146.52 159.02,145.97 159.02,144.05 158.76,143.78 158.76,142.45 v4(158.42,142.12)
DDIC_TX_P3: length 163.9
  TOP w0.102: C92.1 214.45,212.15 214.62,211.98 214.62,211.03 214.51,210.91 v2(214.27,210.91) ; CPU1.C22 159.53,143.76 159.53,145.69 159.74,145.89 159.74,147.09 v4(159.21,147.61)
  BOTTOM w0.102: v2(214.27,210.91) 214.32,210.91 214.7,210.54 214.7,210.21 212.04,207.55 206.66,207.55 200.13,201.01 192.75,201.01 188.5,205.26 185.99,205.26 185.4,204.68 v1(184.89,204.68) 184.89,204.17 181.03,200.31 144.46,200.31 141.9,197.75 141.4,197.75 136.07,192.42 136.07,191.05 131.05,186.02 131.05,170.75 132.28,169.52 132.28,164.35 135.81,160.81 147.12,160.81 159.87,148.06 159.87,147.35 159.72,147.2 159.37,147.2 159.21,147.35 v4(159.21,147.61)
DDID_CTRLCLK: length 245.9
  TOP w0.102: PCH1.AN4 39.71,105.79 39.25,106.24 38.98,106.24 38.64,106.59 38.64,107.76 38.79,107.92 38.79,108.4 38.55,108.64 38.01,108.64 36.89,109.77 36.89,111.54 v2(37.22,111.87) ; QN20.S 153.04,207.52 R104.2 154.06,206.66 154.46,207.07 154.46,208.57 153.85,209.18 150.54,209.18 150.29,209.43 147.05,209.43 146.31,210.17 146.31,214.05 147.53,215.27 148.4,215.27 148.62,215.49 148.62,216.97 149.66,218.01 149.66,219.11 v2(150.15,219.59)
  BOTTOM w0.102: v2(150.15,219.59) 148.8,218.24 141.08,218.24 137.5,214.66 134.1,214.66 129.99,210.55 121.19,210.55 120.35,211.39 117.11,211.39 113.91,208.19 110.73,208.19 107.93,205.39 105.3,205.39 104.85,205.85 100.69,205.85 98.91,204.07 69.16,204.07 66.04,200.95 60.25,200.95 59.42,200.11 58.39,200.11 54.63,196.35 52.32,196.35 51.97,196.7 50.58,196.7 49.74,195.87 49.74,194.31 46.84,191.41 44.3,191.41 43.03,192.68 41.79,192.68 40.53,191.42 39.19,191.42 37.87,190.1 36.79,190.1 34.86,188.17 34.86,186.2 31.74,183.08 31.74,180.25 31.01,179.51 31.01,124.48 v1(31.99,123.5) 34.78,120.71 34.78,119.56 37.95,116.39 37.95,113.39 37.51,112.95 37.51,112.16 v2(37.22,111.87)
DDID_CTRLDATA: length 267.8
  TOP w0.102: v2(150.15,218.83) 150.02,218.7 150.02,218.04 148.88,216.9 148.88,215.42 148.43,214.98 147.57,214.98 146.54,213.95 146.54,210.27 147.15,209.66 150.38,209.66 150.61,209.43 155.25,209.43 155.61,209.07 158.02,209.07 158.4,208.69 158.4,207.17 157.83,206.6 156.78,206.6 R107.2 156.72,207.26 QN23.S ; v3(37.5,111.13) 37.88,110.75 37.88,109.41 38.24,109.05 38.72,109.05 39.2,108.57 39.2,108.18 39.53,107.85 39.53,107.11 PCH1.AN2
  BOTTOM w0.102: v2(150.15,218.83) 150.15,218.42 149.61,217.89 141.05,217.89 137.6,214.43 134.2,214.43 130.08,210.32 121.09,210.32 120.25,211.16 117.2,211.16 114,207.96 110.82,207.96 108.03,205.16 105.21,205.16 104.75,205.62 100.79,205.62 99.01,203.84 70.35,203.84 66.64,200.12 arc(66.39,200.12) 66.39,200.38 69.44,203.43 arc(69.44,203.68) 69.19,203.68 66.07,200.57 60.46,200.57 arc(60.28,200.39) 60.46,200.21 65.89,200.21 arc(66.07,200.03) 65.89,199.85 58.46,199.85 54.72,196.12 52.23,196.12 51.87,196.48 50.71,196.48 49.99,195.76 49.99,194.21 46.97,191.18 44.21,191.18 42.94,192.45 41.89,192.45 40.63,191.19 39.28,191.19 37.96,189.87 36.88,189.87 35.08,188.07 35.08,186.1 31.97,182.99 31.97,180.08 31.24,179.34 31.24,126.05 v1(33.97,123.32) 35.01,122.28 35.01,119.66 38.18,116.48 38.18,113.22 37.78,112.81 37.78,111.41 v3(37.5,111.13)
